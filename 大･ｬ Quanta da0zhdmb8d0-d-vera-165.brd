# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDI2_LANE_DN*<3>: length 145.9
  TOP w0.102: v1(25.91,46.73) 25.63,46.45 25.47,46.45 C151.1
  IN1 w0.079: v1(134.03,42.4) 134.03,42.25 133.62,41.84 133.62,41.21 134.82,40.02 134.82,36.35 128.25,29.78 124.84,29.78 118.53,23.48 117.44,23.48 116.71,22.74 116.1,22.74 115.74,22.39 112.84,22.39 112.24,21.78 111.4,21.78 108.81,19.18 104.61,19.18 103.45,18.02 99.41,18.02 98.61,17.22 90.81,17.22 90.54,17.49 64.04,17.49 56.98,24.56 56.98,26.69 52.82,30.84 51.94,30.84 51.12,31.66 50.39,31.66 43.21,38.84 42.03,38.84 41.62,39.25 41.62,39.83 40.01,41.44 34.26,41.44 33.31,42.39 28.65,42.39 27.83,43.21 27.83,45.09 26.43,46.5 26.15,46.5 26.05,46.59 v1(25.91,46.73)
  BOTTOM w0.076: v1(134.03,42.4) 133.27,42.4 133.2,42.47 133.2,43.45 132.43,44.22 132.43,45.18 132.47,45.22 132.47,46.15 132.68,46.36 132.68,46.64 132.69,46.65 132.69,46.87 U80.D51
DDI2_LANE_DP<0>: length 144
  TOP w0.102: v1(29.18,43.47) 29.35,43.64 29.35,43.73 29.33,43.76 29.33,43.82 29.28,43.88 28.66,43.88 28.43,44.1 28.43,44.77 28.34,44.86 28.17,44.86 C981.1
  IN1 w0.079: v1(133.77,39.26) 133.77,39.48 133.93,39.63 134.04,39.63 134.17,39.51 134.17,38.66 133.7,38.2 133.7,36.15 128.13,30.57 124.69,30.57 118.31,24.19 117.24,24.19 116.46,23.41 112.11,23.41 108.61,19.91 104.3,19.91 103.09,18.7 99.17,18.7 98.33,17.86 91.08,17.86 90.77,18.18 64.27,18.18 57.62,24.83 57.62,26.96 53.08,31.5 52.22,31.5 50.05,33.68 49.28,33.68 40.81,42.15 34.46,42.15 33.24,43.37 29.89,43.37 29.58,43.06 29.01,43.06 28.63,43.44 28.63,43.88 28.77,44.03 28.92,44.03 29.01,43.94 29.21,43.94 29.28,43.87 29.28,43.57 v1(29.18,43.47)
  BOTTOM w0.076: U80.D50 131.61,47.41 131.53,47.14 131.53,47.02 131.39,46.54 131.39,46.3 131.42,46.21 131.42,46.02 131.39,45.92 131.39,45.41 131.52,45.28 131.52,44.71 131.4,44.6 131.4,42.92 131.68,42.64 131.68,42.48 131.66,42.46
  BOTTOM w0.102: v1(133.77,39.26) 133.52,39.51 133.31,39.51 133.12,39.7 132.28,39.7 131.66,40.32 131.66,42.46
DDI2_LANE_DP<1>: length 150.4
  TOP w0.102: v1(25.98,43.72) 25.72,43.98 25.38,43.98 C139.1
  IN1 w0.079: v1(135.49,39.91) 135.69,39.71 136.1,39.71 136.57,39.25 136.57,38.67 137.08,38.15 137.08,36.53 128.73,28.17 125.37,28.17 119.53,22.33 119.53,21.72 119.04,21.23 116.68,21.23 115.66,20.22 112.01,20.22 109.16,17.37 108.71,17.37 105.17,13.84 95.32,13.84 93.68,15.48 78.96,15.48 78.53,15.91 63.54,15.91 55.5,23.95 55.5,26.08 52.27,29.31 51.33,29.31 50.49,30.16 48.5,30.16 43.62,35.03 43.62,35.8 42.08,37.34 34.41,37.34 32.15,39.6 30.27,39.6 27,42.87 27,43.73 26.88,43.85 26.1,43.85 v1(25.98,43.72)
  BOTTOM w0.076: 135.05,43.08 135.03,43.1 135.03,43.22 133.25,45 133.25,45.43 133.38,45.56 133.38,45.92 133.35,46.01 133.35,46.02 133.35,46.21 133.38,46.3 133.38,46.54 133.24,47.02 133.24,47.14 133.17,47.41 U80.D52
  BOTTOM w0.102: v1(135.49,39.91) 135.24,39.91 135.05,40.1 135.05,40.78 135.47,41.19 135.47,42.06 135.05,42.47 135.05,43.08
DDI2_LANE_DP<2>: length 147.4
  TOP w0.102: C129.1 25.46,41.7 28.53,41.7 30.3,39.93 30.99,39.93 31.34,40.27 31.34,40.61 v1(31.53,40.8)
  IN1 w0.079: v1(135.7,38.31) 135.89,38.12 136.09,38.12 136.39,37.81 136.39,36.75 128.47,28.83 125.09,28.83 118.87,22.61 118.03,22.61 117.32,21.89 116.43,21.89 116.07,21.54 115.23,21.54 114.9,21.21 112.96,21.21 112.69,20.94 111.74,20.94 109.04,18.24 105.86,18.24 103.46,15.83 98.87,15.83 98.19,15.15 95.34,15.15 94.1,16.39 90.46,16.39 90.19,16.66 88,16.66 87.48,16.14 79.61,16.14 79.2,16.55 63.81,16.55 56.14,24.21 56.14,26.35 52.49,30 51.56,30 50.74,30.82 50.06,30.82 45.28,35.59 44.74,35.59 42.32,38.01 36.51,38.01 32.96,41.56 31.67,41.56 31.44,41.32 31.44,40.89 v1(31.53,40.8)
  BOTTOM w0.076: 132.11,43.59 132.09,43.61 132.09,45.95 132.05,46.01 U80.B50
  BOTTOM w0.102: 132.11,43.59 132.11,43.49 132.56,43.04 132.56,42.02 133.34,41.24 133.78,41.24 134.5,40.52 134.5,39.44 135.17,38.77 135.17,38.36 135.33,38.2 135.59,38.2 v1(135.7,38.31)
DDI2_LANE_DP<3>: length 145.9
  TOP w0.102: C983.1 25.43,46.24 25.57,46.24 v1(25.91,45.89)
  IN1 w0.079: v1(134.03,41.69) 133.88,41.69 133.81,41.62 133.81,41.29 135,40.09 135,36.27 128.33,29.6 124.92,29.6 118.61,23.29 117.52,23.29 116.78,22.55 116.17,22.55 115.82,22.2 112.92,22.2 112.32,21.6 111.48,21.6 108.88,19 104.69,19 103.52,17.83 99.48,17.83 98.69,17.03 90.73,17.03 90.46,17.31 63.97,17.31 56.79,24.48 56.79,26.61 52.75,30.66 51.87,30.66 51.05,31.48 50.31,31.48 43.13,38.66 41.95,38.66 41.44,39.17 41.44,39.76 39.94,41.26 34.18,41.26 33.23,42.21 28.57,42.21 27.65,43.14 27.65,45.02 26.35,46.31 25.98,46.31 25.8,46.13 25.8,46.01 v1(25.91,45.89)
  BOTTOM w0.076: v1(134.03,41.69) 134.03,41.96 133.99,42 133.87,42 133.64,42.23 133.2,42.23 133.03,42.41 133.03,43.38 132.26,44.15 132.26,45.25 132.31,45.29 132.31,46.22 132.51,46.42 132.51,46.7 132.46,46.76 U80.C51
DDR_CA_VREF: length 60.1
  TOP w0.381: v3(145.83,68.64) 147.94,66.54 147.94,65.52 151.81,61.64 156.34,61.64 159.26,64.56 172.7,64.56 175.66,67.52 175.66,72.48 175.33,72.82 175.33,81.29 v1(174.36,82.25) 173.4,83.22 CAP1020.2 RAP1026.1
  BOTTOM w0.102: 142.88,68.83 142.71,68.66 142.71,68.22 141.73,67.25 U80.AY67
  BOTTOM w0.152: 142.88,68.83 145.64,68.83 v3(145.83,68.64)
DDR_VREFDQ_CHA: length 60.8
  TOP w0.381: RAP1027.1 CAP1022.2 167.73,83.23 167.96,83 167.96,81.08 168.32,80.73 173.77,80.73 173.98,80.53 173.98,77.33 173.8,77.16 173.8,76.72 174.09,76.44 v1(174.09,75.59) 174.09,71.31 174.7,70.7 174.7,67.92 172.3,65.52 161.23,65.52 156.09,70.66 152.1,70.66 151.07,69.63 147.23,69.63 v3(147,69.39)
  BOTTOM w0.102: U80.AY68 143.32,67.36 143.39,67.43 143.63,67.43 143.82,67.62 144.01,67.62 144.57,67.62 144.59,67.6
  BOTTOM w0.203: 144.59,67.6 145.67,67.6 147,68.93 v3(147,69.39)
DDR_VREFDQ_CHB: length 61.1
  TOP w0.381: v3(146.29,69.44) 146.29,69.36 146.78,68.87 147.29,68.87 147.57,69.15 151.47,69.15 152.5,70.18 155.89,70.18 161.03,65.04 172.5,65.04 175.18,67.72 175.18,72.28 174.84,72.62 174.84,80.83 174.29,81.39 v1(173.07,81.39) 170.96,81.39 170.65,81.69 170.65,82.96 170.36,83.26 CAP1024.2 RAP1028.1
  BOTTOM w0.076: U80.BA67 141.73,67.89 141.47,68.15 141.47,68.27 141.46,68.28 141.46,68.56 141.62,68.72 141.75,68.72 142.09,69.06 142.09,69.36 142.18,69.45 142.72,69.45 143.04,69.13
  BOTTOM w0.152: 143.04,69.13 145.98,69.13 v3(146.29,69.44)
DDR_VTT_CTRL: length 180.3
  TOP w0.102: v1(105.55,95.08) 105.92,95.45 130.21,95.45 131.05,94.61 135.11,94.61 135.59,94.13 139.3,94.13 139.56,93.87 v1(139.91,93.87) 140.26,93.87 152.29,93.87 153.37,92.79 156.46,92.79 159.61,89.64 172.28,89.64 172.79,89.14 172.79,86.04 175.67,83.16 175.67,72.96 176,72.62 176,67.38 172.84,64.21 172.55,64.21 159.4,64.21 156.49,61.3 151.67,61.3 147.6,65.38 147.6,66.39 147.22,66.77 144.91,66.77 144.74,66.6 v3(144.74,66.12) ; PR64.1 74.08,83.11 74.49,83.52 v1(75.15,83.52)
  IN1 w0.079: v1(105.55,95.08) 105.15,95.49 98.75,95.49 98.19,94.93 98.19,91.3 97.04,90.14 93.07,90.14 92.03,89.1 91.12,89.1 88.33,86.32 88.33,83.75 82.58,78 81.48,78 80.69,78.8 79.44,78.8 78.65,79.59 77.51,79.59 77.04,80.06 77.04,81.08 75.15,82.97 v1(75.15,83.52)
  BOTTOM w0.102: U80.AW67 142.16,66.78 142.16,66.84 142.33,67.01 142.39,67.01 142.4,67.02 143.19,67.02 143.38,66.83 143.81,66.83 143.93,66.95 144.4,66.95 144.74,66.61 v3(144.74,66.12)
DDR_VTT_CTRL_R: length 5.1
  TOP w0.079: PR64.2 75.13,82.67 75.13,82.25 73.98,81.11 73.98,80.14 73.46,79.62 v4(73.18,79.62)
  BOTTOM w0.079: PU3254.E4 72.54,79.62 v4(73.18,79.62)
DEVICE_PROCHOT*: length 325.1
  TOP w0.102: v1(79.92,72.43) 79.55,72.8 PR41.2 ; v1(71.32,36.63) 72.23,37.55 72.23,39.81 72.4,39.98 RAP3042.2 72.94,40.17 QPM3387.2 ; PR63.2 201.13,38.57 v1(201.24,38.46)
  IN1 w0.079: v1(88.46,11.37) 88.46,11.36 91.05,8.77 114.03,8.77 114.58,9.32 114.58,15.06 116.74,17.23 120.28,17.23 121.78,18.73 141.42,18.73 141.73,18.42 144.93,18.42 145.23,18.72 154.59,18.72 155.77,19.9 160.43,19.9 160.99,20.45 179.85,20.45 180.99,19.31 180.99,17.13 181.22,16.9 183.28,16.9 184.24,17.86 189.88,17.86 191.62,19.6 191.62,21.1 191.17,21.55 190.52,21.55 189.81,22.26 189.81,24.38 190.97,25.54 205.51,25.54 206.4,26.44 210.02,26.44 210.79,27.2 211.51,27.2 212.62,28.3 212.62,29.78 212.18,30.21 206.88,30.21 203.8,33.28 203.8,35.9 v1(201.24,38.46)
  IN2 w0.079: v1(84.29,72.75) 83.63,72.75 83.37,72.49 83.37,70.1 79.03,65.76 77.47,65.76 76.58,64.88 76.58,64.59 71.76,59.77 71.76,58.81 70.39,57.44 69.43,57.44 68.81,56.82 68.81,55.19 67.28,53.66 67.28,44.41 68.95,42.74 68.95,40.48 68.44,39.97 68.44,38.33 70.13,36.63 v1(71.32,36.63) ; v1(68.9,31.81) 68.19,31.81 v1(66.51,30.13)
  BOTTOM w0.102: v1(66.51,30.13) 65.75,30.89 57.24,30.89 55.16,32.98 53.53,32.98 53.43,32.88 53.43,31.84 PR46.1 ; RAP1364.1 90.52,9.3 88.46,11.36 v1(88.46,11.37) 88.45,11.37 85.56,14.26 85.56,16.06 85.68,16.18 RCP4074.1 86.58,15.88 88.47,13.99 RCP4072.2 89.54,13.99 89.93,14.38 89.93,15.91 90.37,16.34 90.37,18.67 93.4,21.7 96.3,21.7 98.39,23.79 98.39,24.78 97.72,25.46 93.04,25.46 89.72,22.13 84.43,22.13 82.95,23.6 77.53,23.6 76.67,24.47 70.71,24.47 v1(70.22,24.95) 69.74,25.43 69.74,29.62 68.9,30.46 v1(68.9,31.81) 68.9,32.91 R1076.2 68.92,33.17 69.18,33.43 69.94,33.43 70.22,33.71 70.22,34.36 70.39,34.53 70.78,34.53 71.32,35.06 v1(71.32,36.63) ; v1(79.92,72.43) 80.27,72.09 80.76,72.09 80.99,72.32 82.2,72.32 82.63,72.75 v1(84.29,72.75)
DMIC_CLK0_L: length 81.6
  TOP w0.102: R5142.1 102.35,40.42 v1(102.35,40.43)
  IN1 w0.079: v1(49.09,53.51) 48.34,52.76 48.34,51.49 49.51,50.32 49.51,49.14 51.11,47.54 51.11,44.55 53.35,42.31 57.06,42.31 59.75,39.62 61.78,39.62 68.41,32.99 70.32,32.99 73.03,30.29 78.77,30.29 79.86,29.19 84.67,29.19 84.97,29.49 87.97,29.49 88.36,29.88 89.76,29.88 94.54,34.66 98.17,34.66 101.67,38.16 101.67,39.75 v1(102.35,40.43)
  BOTTOM w0.102: v1(102.35,40.43) 102.07,40.14 R5140.1 ; R772.2 52.67,57.3 52.67,56.27 51.56,55.17 50.81,55.17 49.14,53.51 v1(49.09,53.51)
DMIC_CLK0_R: length 9.1
  BOTTOM w0.076: U80.D8 107.6,47.24 107.91,46.94 107.91,46.6 107.65,46.35 107.65,45.26 106.85,44.46 105.85,44.46 104.23,42.84
  BOTTOM w0.102: 104.23,42.84 104.23,42.15 104.06,41.98 103.85,41.98 103.57,41.7 R900.2
DMIC_CLK_L2: length 6.1
  BOTTOM w0.102: J8L1.39 55.4,60.11 54.53,59.24 53.43,59.24 53.18,58.99 R772.1 53.35,58.59 53.64,58.3 53.64,57.14 C1110.1
DMIC_DAT_L2: length 6.8
  BOTTOM w0.102: C67.1 51.92,57.15 51.42,57.65 51.42,58.32 51.69,58.59 R771.1 52.04,58.83 52.8,59.6 54.38,59.6 54.9,60.12 J8L1.38
DMIC_DATA0_L: length 83.1
  TOP w0.102: v1(102.3,39.76) 102.3,39.8 R5141.1
  IN1 w0.079: v1(102.3,39.76) 102.3,38.32 98.31,34.33 94.68,34.33 89.9,29.55 88.5,29.55 88.11,29.16 85.63,29.16 85.33,28.86 79.73,28.86 78.63,29.95 72.89,29.95 70.18,32.66 68.27,32.66 61.64,39.29 59.61,39.29 56.93,41.97 53.21,41.97 50.78,44.41 50.78,47.4 49.17,49 49.17,50.18 48,51.35 48,53.07 v1(48.48,53.54)
  BOTTOM w0.102: R771.2 52.31,57.53 52.31,56.42 51.42,55.52 50.66,55.52 49.15,54.02 48.95,54.02 v1(48.48,53.54) ; R5143.1 101.13,40.12 101.54,39.71 102.25,39.71 v1(102.3,39.76)
DRVH1: length 4
  BOTTOM w0.305: PU3254.T14 67.47,74.13 67.56,74.05 67.56,71.81 v1(67.37,71.62) 67.18,71.43 67.18,70.92 67.32,70.78 PU3045.1
DRVH3: length 7.7
  IN1 w0.305: v1(67.33,82.13) 67.33,82.53 64.69,85.17 v1(64.69,87.54)
  BOTTOM w0.305: 67.47,81.73 67.47,81.99 v1(67.33,82.13) ; PU3044.1 64.41,87.86 64.69,87.59 v1(64.69,87.54)
  BOTTOM w0.33: PU3254.A14 67.47,81.73
DRVH4: length 5.3
  BOTTOM w0.305: PU3047.1 75.63,84.98 74.73,84.07 74.73,83.81 v1(74.19,83.27) 73.75,82.83 73.48,82.83 72.97,82.32
  BOTTOM w0.33: PU3254.A3 72.97,82.32
DRVHVR5: length 6.9
  IN2 w0.305: v1(74.57,73.82) 75.89,73.82 76.95,74.89 v1(77.94,74.89)
  BOTTOM w0.305: v1(74.57,73.82) 74.5,73.82 74.5,73.82 73.3,73.82 72.97,74.15 PU3254.T3 ; v1(77.94,74.89) 78.15,74.89 78.5,75.23 PU3048.1
DRVL1: length 6.2
  BOTTOM w0.305: PU3045.4 67.53,68.76 67.89,69.12 67.89,69.46 68.54,70.11 68.78,70.35 68.78,72.07 v1(68.93,72.22) 68.93,73.9 68.97,73.94 PU3254.T11
DRVL3: length 10.8
  IN2 w0.305: v1(62.7,87.56) 63.44,87.56 64.48,86.52 v1(65.19,86.52)
  BOTTOM w0.305: v1(62.7,87.56) 62.77,87.63 PU3044.4 ; v1(65.19,86.52) 65.19,85.61 66.95,83.85 68.34,83.85 v1(68.66,83.54) 68.97,83.23 PU3254.A11
DRVL4: length 5.3
  BOTTOM w0.305: PU3047.4 73.88,85.62 73.88,85 72.29,83.41 72.02,83.41 v1(71.8,83.19) 71.47,82.86 PU3254.A6
DRVLVR5: length 13.1
  IN2 w0.305: v1(77.92,77.48) 78.81,76.59 78.81,74.87 78.23,74.29 v1(78.23,74.13)
  BOTTOM w0.305: PU3254.T6 71.47,73.9 71.52,73.85 71.52,72.85 72.15,72.22 73.02,72.22 73.3,72.51 75.66,72.51 v1(76.48,73.32) 77.29,74.13 v1(78.23,74.13)
EAR_N: length 2
  BOTTOM w0.102: v1(151.1,43.21) 150.85,43.46 RAP1343.1 RAP1344.1
EC_3P3DSW_EN: length 11.1
  BOTTOM w0.102: EUPM3247.A18 76.92,37.79 76.6,37.47 76.6,35.94 76.2,35.54 75.47,35.54 RAP3041.2 74.28,35.09 73.78,35.59 72.59,35.59 v1(72.05,36.13) 72.05,36.47 71.46,37.07 70.91,37.07 70.32,36.48 QPM3382.2
EC_ACIN_R: length 6.5
  TOP w0.102: v1(87.37,45.17) 87.37,44.21 87.16,44 RPM3455.1 86.96,43.37 86.67,43.09 85.73,43.09 85.49,42.85 85.49,42.37 v1(85.97,41.88)
  BOTTOM w0.102: v1(85.97,41.88) 86.36,42.27 86.73,42.27 87,42.54 EUPM3247.B57
EC_BATT_TMP: length 71.3
  TOP w0.102: v1(65.54,24.54) v1(61.97,24.54) 58.41,24.54 PR22.1 ; R1A4PD1.2 78.87,40.03 v1(78.94,39.96)
  IN2 w0.079: v1(92.03,22.09) 90.84,22.09 87.18,25.75 87.18,27.47 86.72,27.93 83.88,27.93 82.49,29.32 80.99,29.32 80.76,29.55 80.76,30.82 79.21,32.37 79.21,33.18 78.43,33.95 78.43,36.96 78.01,37.38 78.01,39.04 v1(78.94,39.96)
  BOTTOM w0.102: v1(78.94,39.96) 78.86,40.04 EUPM3247.B24 ; v1(92.03,22.09) 90.8,20.86 83.88,20.86 82.48,22.26 75.73,22.26 74.99,22.99 66.38,22.99 PR119.2 v1(65.54,24.54)
EC_BL_DISABLE*: length 43.6
  IN1 w0.079: v1(50.39,57.72) 51.47,57.72 59.57,49.61 62.15,49.61 63.3,48.46 63.49,48.46 64.77,47.18 68.45,47.18 69.22,46.4 72.17,46.4 72.85,45.72 73.99,45.72 74.25,45.46 77.85,45.46 78.39,46 82.46,46 82.98,46.52 82.98,47.1 v1(83.18,47.3)
  BOTTOM w0.102: v1(50.39,57.72) 49.88,57.2 49.88,56.5 48.66,55.28 U111.2 ; EUPM3247.A41 82.96,47.08 v1(83.18,47.3)
EC_BRD_ID0: length 3.8
  BOTTOM w0.102: EUPM3247.A2 85.96,35.37 86.89,34.44 86.89,33.95 86.47,33.53 R1051.2 R1054.1
EC_BRD_ID1: length 2.8
  TOP w0.102: R1053.1 82.74,43.95 82.34,44.36 82.34,44.79 v1(82.49,44.94) 82.49,45.55 R1050.2
  BOTTOM w0.102: EUPM3247.B43 82.71,45.16 v1(82.49,44.94)
EC_BRD_ID2: length 3.4
  TOP w0.102: R1052.1 82.87,44.28 v1(82.87,44.46) 83,44.59 83,45.51 R1049.2
  BOTTOM w0.102: v1(82.87,44.46) 83,44.58 83,45.16 83.21,45.38 EUPM3247.B44
EC_CAP: length 2.7
  BOTTOM w0.102: EUPM3247.A7 83.46,35.13 84.27,34.32 84.27,33.42 CPM3439.2
EC_ENTERING_RW: length 96.1
  TOP w0.102: U83.8 150.16,20.08 149.4,19.31 v1(144.47,19.31)
  IN2 w0.079: v1(144.47,19.31) 143.88,19.9 141.55,19.9 141.3,19.65 122,19.65 121.25,20.4 116.58,20.4 113.48,17.31 110.28,17.31 109.73,17.86 104.78,17.86 104.34,18.3 96.97,18.3 96.78,18.49 95.69,18.49 92.48,21.69 90.98,21.69 87,25.67 87,27.4 86.65,27.75 83.8,27.75 82.42,29.14 80.91,29.14 80.58,29.47 80.58,30.74 79.03,32.3 79.03,33.11 78.25,33.88 78.25,36.88 77.83,37.3 77.83,39.8 76.05,41.58 76.05,42.69 75.79,42.96 v1(75.79,43.75)
  BOTTOM w0.102: EUPM3247.A30 75.83,43.79 v1(75.79,43.75)
EC_FAN_PWM: length 197.2
  TOP w0.102: v1(181.63,69.5) 181.63,68.08 183.86,65.84 189.12,65.84 190.95,64.02 190.95,60.74 194.07,57.62 194.07,48.95 194.51,48.52 v1(194.91,48.52)
  IN2 w0.079: v1(86.58,39.04) 86.69,39.04 88.85,36.88 88.85,35.79 89.42,35.22 90.02,35.22 90.79,34.45 91.28,34.45 95.31,30.43 95.31,29.3 96.27,28.34 96.27,27.84 98.02,26.09 99.31,26.09 100.51,24.89 101.64,24.89 101.94,25.2 107.93,25.2 108.5,24.63 114.57,24.63 118.2,20.99 121.94,20.99 122.01,21.06 144.85,21.06 148.25,17.66 155.42,17.66 155.88,18.12 167.27,18.12 167.73,17.66 179.6,17.66 179.85,17.91 182.82,17.91 185.12,15.61 187.09,15.61 189.54,18.06 199.9,18.06 v1(199.99,17.97)
  BOTTOM w0.102: v1(199.99,17.97) 200.12,18.09 200.12,18.92 199.92,19.13 199.92,26.21 206.25,32.54 206.25,33.98 201.63,38.6 201.63,38.79 200.47,39.94 200.47,41.7 200.09,42.08 200.09,42.66 200.55,43.12 200.55,43.87 195.9,48.52 v1(194.91,48.52) ; Q5.1 v1(181.63,69.5) ; EUPM3247.B64 v1(86.58,39.04)
EC_FAN_TACH: length 204.2
  TOP w0.102: v1(194.51,49.16) 194.28,49.39 194.28,57.7 191.15,60.82 191.15,64.1 189.21,66.05 184.29,66.05 v1(182.85,67.5)
  IN2 w0.079: v1(86.5,43.49) 86.5,43.24 86.9,42.84 86.9,42.41 87.16,42.16 87.16,39.85 87.87,39.14 87.87,38.37 89.21,37.03 89.21,36.52 89.54,36.19 89.85,36.19 90.08,35.96 90.08,35.67 90.94,34.81 91.43,34.81 95.67,30.58 95.67,29.45 96.62,28.5 97.82,28.5 99.03,27.29 99.03,26.93 100.71,25.25 101.49,25.25 101.79,25.56 108.08,25.56 108.65,24.99 114.79,24.99 118.38,21.39 121.81,21.39 121.83,21.42 145.03,21.42 148.38,18.07 155.32,18.07 155.73,18.48 167.42,18.48 167.83,18.07 172.51,18.07 174.13,19.69 181.29,19.69 185.2,15.79 186.99,15.79 189.45,18.24 199.7,18.24 199.86,18.4 200.42,18.4 v1(200.53,18.3)
  BOTTOM w0.102: v1(194.51,49.16) 195.56,49.16 200.75,43.96 200.75,43.04 200.3,42.58 200.3,42.16 200.68,41.78 200.68,40.03 201.83,38.88 201.83,38.68 206.45,34.06 206.45,32.46 200.12,26.13 200.12,19.22 200.53,18.81 v1(200.53,18.3) ; v1(86.5,43.49) 87.05,44.04 EUPM3247.B54 ; CN4.3 185.13,65.19 183.47,66.84 C130.1 R874.2 183.08,68.11 182.9,67.93 182.9,67.55 v1(182.85,67.5)
EC_HID_INT*: length 11
  BOTTOM w0.076: U80.AU11 109.84,65.86 109.31,66.39 109.31,67.21 109.33,67.29 109.33,67.41 109.3,67.52 109.19,67.64 109.07,67.64 108.87,67.84 108.73,68.33 108.73,68.57 107.71,69.58
  BOTTOM w0.102: 107.71,69.58 106.79,69.58 105.99,70.38 105.99,71.59 104.71,72.87 104.71,72.94 TP21.1
EC_IN_RW: length 113.3
  TOP w0.102: U83.9 150.56,20.1 151.43,19.24 154.44,19.24 R56.2 154.85,20.82 v1(154.5,21.17)
  IN2 w0.079: v1(154.5,21.17) 154.12,20.79 150.81,20.79 147.21,24.39 136.04,24.39 135.55,24.87 120.53,24.87 117.05,28.35 109.8,28.35 109.38,28.77 106.51,28.77 105.91,29.37 105.91,29.77 103.63,32.04 103.63,33.12 102.31,34.44 102.31,36.41 99.65,39.07 97.65,39.07 96.76,39.96 96.13,39.96 92.2,43.89 92.2,46.11 89.51,48.81 89.51,50.88 89.91,51.27 89.91,53.76 89.28,54.38 89.28,55.2 89.58,55.5 89.58,56.43 90.93,57.78 90.93,58.25 91.63,58.95 93.68,58.95 v1(93.95,58.68)
  BOTTOM w0.076: U80.W3 104.58,55.68
  BOTTOM w0.079: 104.58,55.68 103.34,55.68 103.23,55.78
  BOTTOM w0.102: 103.23,55.78 103.18,55.84 100.37,55.84 100.07,56.14 98.81,56.14 97.59,57.36 95.7,57.36 95.24,57.82 95.24,58 95.12,58.12 94.33,58.12 93.95,58.5 v1(93.95,58.68)
EC_JTAG_TRST*: length 2.5
  BOTTOM w0.102: RPM3426.2 75.5,41.82 v1(76.1,41.21) 76.37,41.21 76.45,41.29 EUPM3247.A25
EC_LPC_CLK: length 42.3
  IN2 w0.079: v1(79.59,41.73) 79.98,42.11 79.98,43.85 80.23,44.1 80.23,46.83 80.36,46.96 80.36,47.44 81.06,48.14 81.06,48.76 81.74,49.45 81.74,53.46 81.97,53.69 81.97,57.14 82.42,57.58 82.42,59.96 83.2,60.75 83.2,61.33 86.65,64.77 86.65,65.47 89.87,68.69 89.87,71.68 89.78,71.76 89.78,73.75 v1(91.51,75.47)
  BOTTOM w0.102: v1(91.51,75.47) 91.51,75.87 91.78,76.15 92.38,76.15 92.52,76.28 RPM3429.2 ; v1(79.59,41.73) 79.09,42.23 78.85,42.23 78.54,42.54 EUPM3247.B29
EC_LPC_CLK_R: length 25.2
  IN2 w0.079: v1(92.59,77.21) 92.73,77.35 96.13,77.35 96.89,78.11 98.4,78.11 99.31,77.2 99.94,77.2 100.57,76.57 101.44,76.57 101.66,76.35 101.66,75.59 101.99,75.25 v1(102.45,75.25)
  BOTTOM w0.076: 107.65,69.36 108.18,68.84 108.18,68.25 108.36,68.06 108.53,68.06 108.66,67.93 108.69,67.81 108.69,67.67 108.68,67.66 108.68,66.72 U80.AW9
  BOTTOM w0.102: RPM3429.1 92.97,76.83 v1(92.59,77.21) ; 107.65,69.36 107.61,69.41 106.71,69.41 105.5,70.61 105.5,71.5 104.3,72.7 103.88,72.7 103.5,73.08 103.5,74.38 102.62,75.25 v1(102.45,75.25)
EC_MUX_CLK: length 112.1
  TOP w0.102: R1168.2 88.8,41.93 v1(88.94,41.79) ; U90.14 21.69,70.52 21.76,70.59 21.76,70.77 v1(21.61,70.92)
  IN1 w0.079: v1(21.61,70.92) 21.76,70.77 21.76,70.48 22.24,70 40.26,70 43.35,66.91 51.01,66.91 52.53,65.39 52.53,64.88 v1(52.37,64.72) ; v1(55.3,49.81) 55.46,49.97 55.9,49.97 56.62,49.24 56.62,46.92 57.33,46.21 58.11,46.21 59.13,45.19 62.14,45.19 64.26,43.07 67.54,43.07 67.73,42.87 67.73,40.98 68.54,40.17 70.83,40.17 72.84,38.16 74.47,38.16 74.94,38.63 75.96,38.63 78.68,35.91 86.08,35.91 87.33,37.16 87.33,38.09 87.93,38.69 87.93,41.71 88.01,41.79 v1(88.94,41.79)
  IN2 w0.079: v1(52.37,64.72) 52.53,64.56 52.53,64.26 52.95,63.84 56.14,63.84 57.29,62.68 57.29,60.91 56.2,59.82 56.2,56.5 54.59,54.88 54.59,50.31 54.96,49.94 55.17,49.94 v1(55.3,49.81)
  BOTTOM w0.102: EUPM3247.A55 v1(88.94,41.79) ; U96.36 21.38,66.18 21.61,66.4 21.61,66.91 22.06,67.36 23.23,67.36 23.49,67.62 23.49,69.23 22.96,69.76 22.24,69.76 21.75,70.24 21.75,70.78 v1(21.61,70.92)
EC_MUX_SDA: length 111
  TOP w0.102: U90.13 22.19,70.52 22.12,70.59 22.12,70.8 v1(22.24,70.92) ; R1169.2 86.65,41.93 v1(86.58,41.87)
  IN1 w0.079: v1(86.58,41.87) 87.44,41.87 87.6,41.71 87.6,38.83 87,38.23 87,37.3 86.74,37.03 85.94,36.24 78.82,36.24 76.1,38.96 74.8,38.96 74.33,38.49 72.98,38.49 70.96,40.51 68.68,40.51 68.07,41.12 68.07,43.01 67.67,43.4 64.4,43.4 62.28,45.52 59.26,45.52 58.25,46.54 57.47,46.54 56.96,47.06 56.96,49.38 56.04,50.3 55.42,50.3 v1(55.3,50.42) ; v1(22.24,70.92) 22.09,70.77 22.09,70.62 22.37,70.34 40.4,70.34 43.49,67.24 51.15,67.24 52.87,65.53 52.87,64.88 v1(53.02,64.72)
  IN2 w0.079: v1(53.02,64.72) 52.86,64.56 52.86,64.4 53.09,64.17 56.28,64.17 57.62,62.82 57.62,60.78 56.53,59.68 56.53,56.36 54.92,54.74 54.92,50.45 55.09,50.27 55.16,50.27 v1(55.3,50.42)
  BOTTOM w0.102: EUPM3247.B58 87.01,42.04 86.83,41.87 v1(86.58,41.87) ; U96.38 22.18,66.21 21.96,66.43 21.96,66.76 22.21,67.01 23.38,67.01 23.84,67.47 23.84,69.38 23.11,70.11 22.38,70.11 22.1,70.39 22.1,70.78 v1(22.24,70.92)
EC_PCH_ACPRESENT: length 72.1
  TOP w0.102: v1(108.77,75.15) 108.58,75.34 RAP1081.2
  IN2 w0.079: v1(81.09,44.36) 81.12,44.39 81.12,46.26 81.4,46.54 81.4,47.28 81.63,47.51 81.63,48.69 82.2,49.26 82.2,51.23 82.62,51.65 82.62,51.88 82.2,52.29 82.2,53.27 82.43,53.5 82.43,56.95 82.88,57.39 82.88,59.77 83.66,60.55 83.66,61.13 87.11,64.58 87.11,65.28 90.33,68.5 90.33,71.37 90.6,71.64 90.6,73.72 92.19,75.32 92.19,77.38 92.5,77.68 95.35,77.68 96.16,78.5 98.52,78.5 99.48,77.53 100.08,77.53 100.7,76.9 101.45,76.9 102.28,76.9 102.85,76.33 102.85,74.54 103.7,73.68 104.38,73.68 104.57,73.87 106.64,73.87 107.15,73.37 107.91,73.37 108.37,73.82 108.37,74.76 v1(108.77,75.15)
  BOTTOM w0.076: U80.AY15 112.39,67.57 112.39,67.8 112.5,67.91 112.5,69.65 111.08,71.07 111.07,71.07
  BOTTOM w0.102: EUPM3247.B39 80.71,44.73 v1(81.09,44.36) ; 111.07,71.07 109.99,72.14 109.99,72.56 109.36,73.19 109.36,73.97 109.18,74.16 109.18,74.75 v1(108.77,75.15) 108.57,75.36 R5150.1
EC_PCH_PROCHOT: length 11.1
  BOTTOM w0.102: 73.12,34.88 72.41,34.88 72.23,34.7 72.23,34.07 72.48,33.82 v1(73.29,33.82) 73.6,33.82 74.5,32.92 76.2,32.92 77.41,34.13 RPM3465.1 77.41,36.45 78,37.04 EUPM3247.B18
EC_PCH_PWRBTN*: length 64
  TOP w0.102: v1(88.93,43.9) 88.93,44.91 87.99,45.85 87.99,47.59 85.84,49.75 85.84,57.53 86.4,58.1 86.4,61.93 86.2,62.13 86.2,64.06 85.18,65.08 85.18,67.31 84.96,67.54 84.96,68.19 85.16,68.4 v1(85.5,68.4) ; RAP1457.2 107.66,77.25 107.23,76.82 103.74,76.82 102.91,77.64 102.91,79 v1(103.17,79.26)
  IN2 w0.079: v1(103.17,79.26) 103.17,79.27 103.4,79.5 103.4,80.47 102.53,81.34 100.12,81.34 99.78,81.01 99.46,81.01 99.04,81.43 92.44,81.43 88.57,77.57 88.57,76.25 87.02,74.7 87.02,71.66 86.78,71.41 86.78,69.69 85.5,68.41 v1(85.5,68.4)
  BOTTOM w0.102: EUPM3247.A51 88.83,43.79 v1(88.93,43.9)
EC_PCH_RCIN*: length 86.4
  TOP w0.102: v1(101.5,79.26) 102.2,78.55 102.2,77.73 103.44,76.49 RAP1000.2 ; v1(85.39,67.8) 85.41,67.77 85.41,66.15 86.65,64.91 86.65,62.26 86.81,62.1 86.81,57.93 86.24,57.36 86.24,49.92 88.4,47.76 88.4,46.11 89.58,44.93 89.58,43.41 91.28,41.71 91.28,39.8 v1(90.88,39.4)
  IN2 w0.079: v1(101.5,79.26) 100.38,80.37 99.84,80.37 99.29,80.92 98.96,81.25 92.51,81.25 88.76,77.49 88.76,76.12 87.2,74.57 87.2,71.59 86.96,71.34 86.96,69.61 86.19,68.84 86.19,68.5 85.49,67.8 v1(85.39,67.8)
  BOTTOM w0.076: 109.71,71.25 111.16,69.81 111.16,68.76 111.28,68.63 111.28,68.31 111.22,68.15 111.22,68.04 111.29,67.82 111.29,67.59 111.23,67.44 111.18,67.26 111.18,67.16 111.01,66.64 U80.AW13
  BOTTOM w0.102: 109.71,71.25 109.47,71.5 109.29,71.5 108.85,71.93 108.85,72.86 108.48,73.24 108.39,73.33 108.39,75.34 108.16,75.56 108.16,79.03 107.01,80.18 103.25,80.18 103.08,80.01 101.91,80.01 101.5,79.6 v1(101.5,79.26) ; EUPM3247.A61 90.27,38.79 v1(90.88,39.4)
EC_PCH_WAKE*: length 72
  IN1 w0.079: v3(112.12,62.45) 111.16,62.45 110.53,63.08 110.15,63.08 109.82,63.41 109.82,64.3 107.66,66.46 107.61,66.46 106.96,67.11 103.48,67.11 99.4,71.19 98.29,71.19 97.45,72.03 97.45,72.18 97.08,72.55 95.55,72.55 94.91,71.92 94.91,71.7 v1(94.79,71.58)
  IN2 w0.079: v1(94.79,71.58) 94.79,71.57 94.23,71 94.23,69.31 93.14,68.22 93.14,67.86 92.59,67.31 92.59,64.61 91.74,63.76 89.9,63.76 87.3,61.16 87.3,59.28 86.4,58.38 86.4,57.9 86.09,57.58 86.09,49.44 86.59,48.94 86.59,47.39 88.96,45.02 88.96,44.76 89.51,44.21 89.51,42.86 91.11,41.26 91.11,40.69 92,39.8 92,38.95 v1(93.06,37.88)
  BOTTOM w0.076: v3(112.12,62.45) U80.AM15
  BOTTOM w0.102: v1(94.79,71.58) 94.79,71.79 95.42,72.42 95.83,72.42 95.98,72.58 96.23,72.58 RAP1008.2 ; EUPM3247.A62 89.44,38.29 89.98,37.75 92.93,37.75 v1(93.06,37.88)
EC_PD_I2C_CLK: length 58.9
  TOP w0.102: v1(84.42,44.97) 84.52,45.07 84.52,46.06 83.75,46.83 83.75,47.74 RPM3467.1 ; v1(65.14,45.54) 65.05,45.63 64.8,45.63 62.16,42.98 60.85,42.98 60.63,43.21 56.99,43.21 56.86,43.34 50.19,43.34 50.11,43.42 41.11,43.42 39.79,44.73 39.79,48.12 39.34,48.57 38.78,48.57 38.02,49.34 U95.42
  IN1 w0.079: v1(84.42,44.97) 84.05,45.34 78.67,45.34 78.09,44.76 73.96,44.76 73.81,44.91 72.35,44.91 71.53,45.73 67.67,45.73 67.59,45.81 65.41,45.81 v1(65.14,45.54)
  BOTTOM w0.102: EUPM3247.B47 84.71,45.25 v1(84.42,44.97)
EC_PD_I2C_SDA: length 57.3
  TOP w0.102: RPM3458.1 83.91,48.13 v1(84.17,47.88) ; U95.43 37.8,49.84 37.94,49.69 38.17,49.69 38.93,48.93 39.48,48.93 40.15,48.26 40.15,44.88 41.26,43.77 50.26,43.77 50.34,43.7 57.01,43.7 57.14,43.57 60.77,43.57 61,43.34 62.01,43.34 64.65,45.98 64.99,45.98 v1(65.15,46.14)
  IN1 w0.079: v1(84.17,47.88) 83.76,47.47 83.76,46.36 83.07,45.67 78.53,45.67 77.95,45.09 74.1,45.09 73.95,45.25 72.48,45.25 71.67,46.06 67.81,46.06 67.72,46.14 v1(65.15,46.14)
  BOTTOM w0.102: EUPM3247.A44 84.46,46.86 84.6,47 84.6,47.44 v1(84.17,47.88)
EC_ROP_I2C_CLK: length 94.5
  TOP w0.102: v1(66.26,42.1) 66.41,41.94 66.41,40.93 68.83,38.52 68.83,38.34 69.54,37.63 69.54,36.18 70.99,34.73 73.72,34.73 73.9,34.91 75.18,34.91 75.7,34.38 76.03,34.38 76.35,34.07 79,34.07 79.66,33.41 82.24,33.41 82.5,33.15 83.2,33.15 84.62,31.74 85.42,31.74 85.83,31.33 87.65,31.33 90.74,34.42 90.74,37.21 89.05,38.9 88.51,38.9 88.03,39.39 88.03,40.57 88.27,40.81 RPM3472.1 88.95,41.28 v1(89.27,41.28) ; RPM3592.1 80.5,74.51 v1(80.5,74.02)
  IN1 w0.079: v1(76.07,76.82) 76.16,76.91 76.49,76.91 77.43,75.98 78.45,75.98 78.96,75.47 78.96,74.94 79.44,74.46 80.7,74.46 80.76,74.39 80.76,74.28 v1(80.5,74.02)
  IN2 w0.079: v1(66.26,42.1) 66.39,42.22 66.39,43.2 64.15,45.43 64.15,46.79 65.8,48.45 65.8,56.71 72.42,63.33 73.02,63.33 76.93,67.24 78.47,67.24 79.24,68.02 79.24,69.82 79.88,70.45 81.16,70.45 81.78,71.07 81.78,72.31 80.76,73.32 80.76,73.76 v1(80.5,74.02)
  BOTTOM w0.102: EUPM3247.A56 89.25,41.29 v1(89.27,41.28) ; PU3254.M1 75.21,76.19 75.84,76.82 v1(76.07,76.82)
EC_ROP_I2C_SDA: length 95.3
  TOP w0.102: v1(85.91,41.04) 86.33,41.46 86.94,41.46 87.22,41.18 RPM3470.1 87.46,40.81 87.67,40.6 87.67,39.2 88.32,38.55 88.9,38.55 90.38,37.06 90.38,34.56 87.5,31.68 85.98,31.68 85.57,32.09 84.77,32.09 83.35,33.51 82.64,33.51 82.39,33.76 79.81,33.76 79.15,34.42 76.5,34.42 76.18,34.74 75.85,34.74 75.32,35.26 73.75,35.26 73.58,35.09 71.13,35.09 69.89,36.33 69.89,37.77 69.18,38.48 69.18,38.66 66.77,41.08 66.77,41.97 v1(66.9,42.1) ; v1(81.36,74.02) 81.42,73.96 RPM3591.1
  IN1 w0.079: v1(81.36,74.02) 81.1,74.28 81.1,74.53 80.84,74.79 79.58,74.79 79.29,75.08 79.29,75.61 78.59,76.31 77.56,76.31 76.63,77.24 76.24,77.24 v1(76,77.48)
  IN2 w0.079: v1(81.36,74.02) 81.35,74.02 81.1,73.77 81.1,73.46 82.11,72.45 82.11,70.94 81.29,70.12 80.01,70.12 79.58,69.68 79.58,67.88 78.61,66.91 77.07,66.91 73.16,63 72.56,63 66.14,56.58 66.14,48.31 64.49,46.66 64.49,45.57 66.72,43.34 66.72,42.27 v1(66.9,42.1)
  BOTTOM w0.102: EUPM3247.B59 87.02,41.54 86.94,41.46 86.33,41.46 v1(85.91,41.04) ; v1(76,77.48) 75.99,77.48 75.26,77.48 75.05,77.28 74.21,77.28 74.12,77.19 PU3254.K1
EC_ROP_SLP_SUS*: length 139.6
  TOP w0.079: 65.19,77.72 65.58,77.33 66.12,77.33 66.66,77.87 PR53.1 66.98,77.87 67.05,77.8 67.62,77.8 67.82,78 68.12,78 68.51,77.6 v4(68.51,77.13)
  TOP w0.102: PR83.2 46.3,47.93 PR78.2 46.41,47.9 46.68,48.17 47.3,48.17 51,44.46 56.74,44.46 57.14,44.86 62.74,44.86 64.67,46.79 64.97,46.79 65.35,47.18 65.87,47.18 66.49,46.56 66.49,44.86 64.96,43.33 v1(64.96,42.65) 64.96,41.88 68.42,38.42 68.42,38.1 69.13,37.39 69.13,36.08 71.07,34.15 74.12,34.15 74.47,33.79 v1(75.19,33.79) 75.91,33.79 75.99,33.71 77.88,33.71 79.13,32.47 83.38,32.47 84.96,30.89 87.72,30.89 91.09,34.27 91.09,37.77 92.37,39.05 92.37,41.69 93.08,42.4 v1(93.08,42.43) ; v1(63.58,74.17) 63.85,74.17 64.21,74.53 64.21,75.03 64.11,75.14 64.11,76.32 64.94,77.15 64.94,77.65 PR77.2 65.19,77.72
  IN2 w0.079: v4(68.51,77.13) 69.05,77.13 69.31,76.88 69.67,76.88 70.29,77.5 70.63,77.5 71.43,76.7 71.43,76.65 72,76.08 72.06,76.08 72.51,75.63 72.58,75.63 72.99,75.22 73.48,75.22 v4(73.49,75.23) ; v1(63.58,74.17) 63.58,73.33 63.96,72.96 63.96,70.3 63.42,69.76 63.42,68.97 62.73,68.28 62.73,62.7 61.42,61.38 61.42,60.43 61.8,60.05 62.68,60.05 63.14,60.51 64.02,60.51 64.68,61.17 65.8,61.17 66.51,60.46 66.51,59.49 65.98,58.96 65.52,58.96 64.12,57.55 64.12,53.62 63.79,53.29 63.79,48.58 62.74,47.54 62.74,43.43 63.07,43.1 64.52,43.1 v1(64.96,42.65)
  BOTTOM w0.079: PU3254.J12 68.47,77.18 v4(68.51,77.13) ; PU3254.R2 73.47,75.21 v4(73.49,75.23)
  BOTTOM w0.102: R5027.2 90.49,42.04 90.67,41.87 RAP3040.1 91.32,41.87 91.75,42.3 92.96,42.3 v1(93.08,42.43) 93.08,43.07 92.17,43.98 92.17,45.83 91.97,46.03 90.46,46.03 R5026.2
EC_RST: length 4.3
  TOP w0.102: R5151.2 153.87,19.82 v1(153.71,19.67) 152.66,19.67 R1C10.1 151.88,20.1 151.1,20.1 150.96,20.23 U83.10
EC_RST*: length 63.1
  TOP w0.102: v1(64.31,64.24) 65.38,63.17 76.82,63.17 77.42,62.58 77.42,58.98 77.96,58.44 78.51,58.44 79.02,57.93 79.24,57.93 79.41,57.77 81.9,57.77 82.46,57.21 82.67,57 83.27,56.4 83.74,56.4 84.27,55.87 84.27,53.07 81.7,50.5 v1(81.7,49.73) 81.7,48.96 80.37,47.62 80.37,47.12 81.2,46.29 81.2,45.91 81.45,45.65 RPM3427.1 81.68,45.6 v1(81.68,44.93)
  IN1 w0.079: v4(72.45,76.21) 73.29,76.21 74.74,74.76 75.33,74.76 75.82,74.26 75.82,73.55 75.2,72.93 v1(75.2,71.52)
  IN2 w0.079: v1(75.2,71.52) 75.2,71.14 74.64,70.58 71.84,70.58 71.75,70.49 68.24,70.49 67.5,69.75 67.5,67.57 66.02,66.1 65.23,66.1 64.31,65.17 v1(64.31,64.24)
  BOTTOM w0.079: v4(72.45,76.21) 72.47,76.23 PU3254.L4
  BOTTOM w0.102: v1(81.68,44.93) 81.71,44.96 EUPM3247.B41
EC_RTCRST: length 9.3
  BOTTOM w0.102: EUPM3247.A58 88.59,40.29 88.69,40.19 RPM3562.1 90.27,39.81 91.05,39.81 91.79,39.07 QPM3360.2 93.44,38.51 QPM3391.2 93.44,36.48 v1(93.36,36.48)
EC_SCI*: length 36.1
  IN1 w0.079: v1(92.02,51.39) 91.43,51.39 89.26,49.22 88.25,49.22 87.35,50.12 83.97,50.12 83.29,49.43 82.74,49.43 81.24,47.93 v1(81.24,47.72)
  IN2 w0.079: v1(92.02,51.39) 94.4,51.39 94.64,51.16 97.98,51.16 98.51,51.69 99.57,51.69 100.25,52.36 100.25,52.81 100.86,53.42 101.42,53.42 102.81,52.03 105.28,52.03 105.91,52.66 108.06,52.66 v3(108.55,53.14)
  BOTTOM w0.102: RAP1014.2 92.95,49.85 92.84,49.96 92.84,50.57 v1(92.02,51.39) ; EUPM3247.A38 81.46,47.5 v1(81.24,47.72) ; v3(108.55,53.14) 108.55,53.05 U80.N9
EC_SHD_CS0*: length 2.8
  BOTTOM w0.102: EUPM3247.B52 87.65,45.04 87.98,45.37 RPM3452.2
EC_SMB_CLK: length 109.2
  TOP w0.102: PD1.1 68.97,19.16 v1(68.2,19.16) 67.43,19.16 67.18,19.41 67.18,20.72 PC8.1 67.8,22.16 v1(68.04,22.16) 68.55,22.66 68.55,24.49 v1(68.37,24.67) ; RPM3475.1 88.36,36.74 v1(88.44,36.66)
  IN2 w0.079: v1(97.6,24.49) 97.6,26.03 95.93,27.7 95.93,28.2 90.92,33.21 90.92,33.74 89.78,34.89 89.03,34.89 87.7,36.21 87.7,36.51 87.85,36.66 v1(88.44,36.66)
  BOTTOM w0.102: v1(68.04,22.16) 67.64,22.56 PR7.1 ; v1(88.44,36.66) 88.74,36.96 88.74,37.67 88.61,37.79 EUPM3247.A63 ; UCP4007.8 82.83,15.64 82.09,16.39 82.09,17.33 83.56,18.8 86.53,18.8 87.37,17.97 87.47,17.97 87.54,18.04 UCP4006.10 89.25,18.04 89.65,18.44 89.65,18.98 93.09,22.41 96.01,22.41 97.6,24.01 v1(97.6,24.49) 97.3,24.49 97.25,24.44 93.03,24.44 90.01,21.42 84.11,21.42 82.63,22.89 77.24,22.89 76.38,23.76 69.28,23.76 v1(68.37,24.67) 68.57,24.87 68.57,28.79 66.09,31.28 57.37,31.28 55.31,33.33 53.38,33.33 53.08,33.03 53.08,32.16 52.39,31.48 52.1,31.48 PR44.1
EC_SMB_CLK_B1: length 2.2
  BOTTOM w0.102: PJ2.4 67.39,22.06 PR7.2 66.69,22.11 v1(66.59,22.21)
EC_SMB_SDA: length 107
  TOP w0.102: RPM3476.1 87.08,37.63 87.03,37.63 v1(86.6,38.06) ; v1(69.05,24.67) 68.9,24.52 68.9,22.33 v1(68.72,22.16) 67.91,21.34 PC9.1 68.91,21.12 PD2.1
  IN2 w0.079: v1(86.6,38.06) 87.37,37.29 87.37,36.08 88.89,34.56 89.64,34.56 90.59,33.6 90.59,33.08 95.6,28.07 95.6,27.56 97.18,25.98 v1(97.18,25.05)
  BOTTOM w0.102: UCP4007.7 83.67,16.29 83.38,16 82.98,16 82.44,16.54 82.44,17.18 83.71,18.45 86.38,18.45 87.22,17.61 87.47,17.61 87.54,17.54 UCP4006.9 89.25,17.54 90.01,18.3 90.01,18.83 93.24,22.05 96.16,22.05 98.04,23.93 98.04,24.64 97.62,25.05 v1(97.18,25.05) 96.93,24.8 92.89,24.8 89.86,21.78 84.26,21.78 82.78,23.25 77.39,23.25 76.52,24.11 69.61,24.11 v1(69.05,24.67) 68.93,24.8 68.93,28.94 66.24,31.63 57.51,31.63 55.46,33.69 53.23,33.69 52.72,33.18 52.72,32.31 52.25,31.83 51.47,31.83 PR45.1 ; EUPM3247.B66 86.91,38.04 86.9,38.06 v1(86.6,38.06) ; PR6.1 69.01,22.57 68.72,22.28 v1(68.72,22.16)
EC_SMB_SDA_B1: length 2.3
  BOTTOM w0.102: PJ2.3 69.39,22.05 PR6.2 69.36,22.16 v1(70.12,22.16)
EC_SMI*: length 35.2
  TOP w0.102: v1(91.88,47.42) 91.94,47.48 93.27,47.48 93.59,47.8 v1(93.59,48.5)
  IN1 w0.079: v1(86.22,38.54) 86.74,38.54 87.26,39.07 87.26,41.01 86.81,41.46 85.84,41.46 85.58,41.72 85.58,42.05 85.81,42.28 88.52,42.28 90.24,44 90.24,44.89 91.88,46.53 v1(91.88,47.42) ; v3(105.92,52.14) 105.92,51.74 105.15,50.96 103.95,50.96 103.7,51.21 102.96,51.21 101.84,50.09 94.88,50.09 94.2,49.41 94.2,49.11 v1(93.59,48.5)
  BOTTOM w0.102: U80.L6 106.25,51.81 v3(105.92,52.14) ; RAP1016.2 93.95,48.85 v1(93.59,48.5) ; v1(86.22,38.54) EUPM3247.B65
EC_SPI_CLK: length 31
  BOTTOM w0.102: UPM3253.6 97.27,31.53 97.17,31.43 97.17,31.05 97.07,30.94 94.8,30.94 94.7,30.84 94.7,30.64 94.8,30.54 96.14,30.54 96.24,30.44 96.24,30.22 96.14,30.12 94.99,30.12 94.89,30.02 94.89,29.81 94.99,29.71 96.14,29.71 96.24,29.61 96.24,29.41 96.14,29.31 94.61,29.31 94.51,29.2 94.51,29 94.61,28.9 96.13,28.9 96.23,28.8 96.23,28.58 96.13,28.48 94.35,28.48 94.05,28.78 94.05,30.03 93.95,30.13 93.69,30.13 93.59,30.03 93.59,29.52 93.51,29.44 92.47,29.44 92.37,29.55 92.37,29.82 92.47,29.92 92.86,29.92 92.97,30.02 92.97,30.22 92.86,30.33 92.45,30.33 92.35,30.43 92.35,30.67 92.45,30.77 92.83,30.77 92.93,30.87 92.93,31.12 92.83,31.22 92.42,31.22 92.35,31.3 92.35,31.49 92.93,32.07 92.93,33.18 91.84,34.27 v1(90.95,34.27) 88.85,34.27 88.54,33.96 88.54,33.65 RPM3579.2
EC_SPI_CLK_R: length 3.8
  BOTTOM w0.102: RPM3462.2 87.98,33.59 87.72,33.84 v1(87.72,34.12) 87.72,35.01 86.71,36.02 EUPM3247.B1
EC_SPI_CS*: length 1.7
  BOTTOM w0.102: RPM3578.2 UPM3253.1
EC_SPI_CS*_R: length 27.5
  IN2 w0.079: v1(87.59,47.21) 87.59,47.21 89.32,45.47 89.32,44.91 89.87,44.36 89.87,43.01 91.47,41.41 91.47,40.84 92.59,39.71 92.94,39.71 93.44,39.22 93.44,38.64 95.5,36.58 95.5,35.42 97.63,33.28 97.63,32.42 v1(100.58,29.47)
  BOTTOM w0.102: v1(100.58,29.47) 100.5,29.4 100.33,29.4 v1(99.74,28.81) RPM3463.2 ; v1(87.59,47.21) 86.72,47.21 86.46,46.95 EUPM3247.A48
EC_SPI_HOLD*: length 4.9
  TOP w0.102: RPM3473.2 96.62,28.58 97.2,28.58 97.45,28.84 97.45,29.67 v1(96.87,30.26)
  BOTTOM w0.102: UPM3253.7 v1(96.87,30.26)
EC_SPI_MISO: length 1.7
  BOTTOM w0.102: UPM3253.2 89,30.26 RPM3581.2
EC_SPI_MISO_R: length 30.3
  IN2 w0.079: v1(87.16,47.65) 87.7,47.65 88.02,47.33 88.02,47.03 89.5,45.55 89.5,44.98 90.05,44.44 90.05,43.09 91.65,41.49 91.65,40.91 92.67,39.89 93.02,39.89 93.62,39.29 93.62,38.72 95.68,36.66 95.68,35.51 97.86,33.33 97.86,32.44 100.2,30.1 100.67,30.1 101.01,29.76 v1(101.01,29.04)
  BOTTOM w0.102: v1(87.16,47.65) 86.7,47.65 85.96,46.91 EUPM3247.A47 ; RPM3461.2 99.16,27.2 v1(101.01,29.04)
EC_SPI_MOSI: length 31.2
  TOP w0.102: RPM3580.2 89.44,35.8 v1(89.69,35.8)
  BOTTOM w0.102: v1(89.69,35.8) 89.96,35.52 89.96,34.93 90.21,34.68 90.66,34.68 90.76,34.78 90.76,35.11 90.86,35.21 91.06,35.21 91.16,35.11 91.16,34.78 91.26,34.68 91.47,34.68 91.57,34.78 91.57,35.11 91.67,35.21 91.87,35.21 91.98,35.11 91.98,34.78 92.08,34.68 92.31,34.68 92.86,35.24 93.01,35.24 93.15,35.09 93.15,34.95 92.52,34.31 92.52,34.17 92.66,34.03 92.8,34.03 93.49,34.71 93.63,34.71 93.77,34.57 93.77,34.42 93.09,33.74 93.09,33.59 93.24,33.45 93.38,33.45 94.06,34.13 94.21,34.13 94.35,33.99 94.35,33.85 93.67,33.16 93.67,33.02 93.81,32.88 93.95,32.88 94.64,33.56 94.78,33.56 94.92,33.42 94.92,33.27 94.24,32.59 94.24,31.99 94.14,31.88 93.92,31.88 93.82,31.99 93.82,32.16 93.72,32.27 93.44,32.27 93.34,32.16 93.34,30.64 93.44,30.54 93.77,30.54 93.87,30.64 93.87,31.25 93.97,31.35 94.68,31.35 94.79,31.45 94.79,32.49 94.89,32.6 95.09,32.6 95.19,32.49 95.19,31.45 95.29,31.35 95.5,31.35 95.6,31.45 95.6,32.16 95.7,32.26 95.9,32.26 96,32.16 96,31.45 96.11,31.35 96.67,31.35 96.77,31.45 96.77,31.68 96.67,31.78 96.51,31.78 96.41,31.88 96.41,32.52 96.69,32.8 UPM3253.5
EC_SPI_MOSI_R: length 3.3
  TOP w0.102: v1(86.57,37.43) 86.57,36.88 RPM3460.2
  BOTTOM w0.102: v1(86.57,37.43) 86.69,37.54 EUPM3247.B67
EC_USBA_ILIM_SEL: length 112.4
  TOP w0.102: v1(94.88,19.87) 94.7,19.69 92.98,19.69 89.09,23.58 88.36,23.58 84.91,27.03 83.15,27.03 80.82,29.37 73.54,29.37 72.83,30.08 69.77,30.08 68.54,31.32 61.41,31.32 58.13,34.59 58.13,39.89 57.55,40.48 55.81,40.48 55.14,41.16 49.56,41.16 48.37,39.96 40.51,39.96 40.11,40.37 36.36,40.37 34.96,38.98 34.59,38.6 R5100.1 30.34,35.98 30.04,35.69 30.04,35.12 R5101.2
  BOTTOM w0.102: v1(94.88,19.87) 95.57,20.56 97.2,20.56 99.81,23.17 99.81,24.94 99.59,25.17 99.59,27.04 101.41,28.87 101.41,29.35 100.83,29.93 100.18,29.93 99.05,31.06 99.05,33.14 98.97,33.22 96.79,33.22 96.06,32.49 95.64,32.49 95.31,32.82 95.31,33.35 93.2,35.47 90.9,35.47 90.14,36.23 89.5,36.23 89.12,35.85 89.12,35.59 89.38,35.33 R5104.2
EC_USBPD_RST*: length 148.9
  TOP w0.102: U95.7 33.89,53.74 32.96,54.67 R1084.2 33.62,54.9 33.74,55.02 C1.1 34.57,54.58 v1(34.57,54.46)
  IN2 w0.079: v1(98.8,24.03) 98.1,24.03 97.85,23.78 97.29,23.78 95.96,25.12 95.96,26.34 94.99,27.31 94.99,27.81 89.79,33.01 89.28,33.01 88.35,33.94 87.99,33.94 85.9,36.03 85.9,37.9 85.58,38.22 84.75,38.22 84.37,38.6 84.37,43.32 84.03,43.65 81.19,43.65 80.69,44.15 80.69,46.64 80.82,46.77 80.82,47.26 v1(80.83,47.27) ; v1(34.57,54.46) 35.22,55.11 38.08,55.11 38.47,55.51 41.37,55.51 42.09,54.78 42.09,54.05 41.17,53.12 41.17,51.72 43.65,49.23 45.51,49.23 46.88,47.86 48.86,47.86 49.12,47.61 49.12,46.77 48.49,46.15 48.49,43.72 52.89,39.33 54.99,39.33 55.89,38.42 58.2,38.42 59.21,37.41 59.39,37.41 64.59,32.21 69.07,32.21 69.3,31.98 69.3,29.12 71.84,26.58 71.84,24.93 77.39,19.38 84.2,19.38 88.64,14.94 v1(90.57,14.94)
  BOTTOM w0.102: CN17.45 98.33,11.91 98.22,12.02 97.1,12.02 95.32,10.24 92.36,10.24 90.57,12.03 v1(90.57,13.49) v1(90.57,14.94) 90.67,15.04 90.67,18.4 93.67,21.39 96.51,21.39 98.8,23.68 v1(98.8,24.03) ; EUPM3247.A37 80.96,47.14 v1(80.83,47.27)
EC_VCCSFR_OC: length 4.5
  BOTTOM w0.102: v1(100.91,90.74) 100.33,90.74 PR80.1 PR81.1 PR79.1 100.05,87.98 100.39,87.65 PU13.9
EC_XTAL_IN: length 9
  TOP w0.102: v1(79.68,44.93) 79.75,45 79.75,45.75 v1(79.32,46.18) 79.01,46.49 79.01,47.61 78.44,48.18 RPM3453.1 78.44,49.05 78.46,49.06 C831.1 78.88,49.56 78.98,49.66 78.98,50.1 78.88,50.2 78.66,50.2 78.55,50.3 78.55,50.99 78.45,51.09 X8.2
  BOTTOM w0.102: EUPM3247.B37 79.71,44.96 v1(79.68,44.93)
EC_XTAL_OUT: length 9.2
  TOP w0.102: v1(79.84,44.33) 80.23,44.72 v1(80.23,45.3) 80.23,46.26 79.49,47 79.49,47.81 79.22,48.08 RPM3453.2 79.22,48.81 79.46,49.05 C832.1 79.46,50.34 X8.1
  BOTTOM w0.102: v1(79.84,44.33) 80.21,44.7 EUPM3247.B38
ECGND: length 5.5
  BOTTOM w0.102: v1(72.18,40.5) 72.22,40.54 RPM3431.1 73.74,40.54 CPM3434.1 CPM3437.1 75.49,40.6 76.12,40.6 76.42,40.29 EUPM3247.A23
ECRXD_SERVOTXD: length 40.5
  IN2 w0.079: v1(84.16,47.27) 84.67,46.75 84.98,46.75 87.18,44.55 87.18,43.22 87.36,43.04 87.36,42.6 87.62,42.35 87.62,40.04 88.33,39.33 88.33,38.98 88.75,38.56 88.9,38.56 90.82,36.64 90.82,35.76 91.3,35.28 91.63,35.28 96.13,30.77 96.13,30.01 96.59,29.55 97.57,29.55 101.03,26.08 v1(101.03,25.84)
  BOTTOM w0.102: v1(101.03,25.84) 101.42,25.45 101.42,16.82 101.13,16.53 CN17.32 ; v1(84.16,47.27) 83.96,47.07 EUPM3247.A43
ECTXD_SERVORXD: length 73.2
  IN2 w0.079: v1(111.6,23.5) 109.22,23.5 107.81,24.91 102.06,24.91 101.76,24.61 100.39,24.61 99.62,25.38 99.05,25.38 97.76,24.09 97.43,24.09 96.24,25.28 96.24,26.45 95.27,27.42 95.27,27.93 90.26,32.94 90.26,33.46 89.5,34.22 88.1,34.22 86.18,36.15 86.18,38.03 85.41,38.79 85.41,43.42 84.89,43.94 84.23,43.94 v1(83.76,44.41)
  BOTTOM w0.102: CN17.33 100.73,10.43 102.38,8.78 v1(106.84,8.78) 111.31,8.78 112.9,10.37 112.9,18.55 111.83,19.62 111.83,20.12 112.51,20.81 112.51,21.37 112.18,21.7 111.85,21.7 111.52,22.03 111.52,23.43 v1(111.6,23.5) ; v1(83.76,44.41) 83.93,44.58 83.93,45.11 84.21,45.39 EUPM3247.B46
EDP_AUX_DN*: length 126.8
  IN1 w0.079: v3(129.5,48.28) 129.3,48.47 129.3,48.57 129.36,48.62 129.67,48.62 129.87,48.43 129.87,47.92 128.92,46.97 128.92,45.2 127.57,43.85 127.57,42.68 127.19,42.31 125.39,42.31 123.49,40.4 120.21,40.4 118.25,38.44 118.25,30.92 116.29,28.96 114.51,28.96 113.61,28.06 103.88,28.06 102.35,26.53 99.31,26.53 98.44,25.67 93.78,25.67 91.23,23.12 78.25,23.12 77.23,24.15 68.06,24.15 63.59,28.61 63.59,29.91 59.39,34.12 57.4,34.12 55.39,36.13 54,36.13 46.85,43.27 46.13,43.27 43.99,45.42 43.99,46.59 41.45,49.13 41.45,50.98 40.51,51.92 40.51,53.56 40.71,53.75 40.71,54.43 40.84,54.57 40.96,54.57 v1(41.1,54.43)
  BOTTOM w0.102: v1(41.1,54.43) 40.78,54.74 40.78,55.13 40.93,55.27 C8L6.2 ; U80.E45 129.27,48.5 v3(129.5,48.28)
EDP_AUX_DP: length 126.7
  IN1 w0.079: v3(129.5,48.99) 129.71,48.78 129.79,48.78 130.06,48.51 130.06,47.84 129.11,46.9 129.11,45.12 127.75,43.77 127.75,42.6 127.27,42.12 125.47,42.12 123.56,40.22 120.29,40.22 118.44,38.36 118.44,30.85 116.37,28.78 114.59,28.78 113.68,27.87 103.95,27.87 102.43,26.35 99.38,26.35 98.52,25.48 93.86,25.48 91.31,22.94 78.18,22.94 77.15,23.96 67.98,23.96 63.41,28.53 63.41,29.84 59.31,33.93 57.32,33.93 55.31,35.94 53.92,35.94 46.77,43.09 46.05,43.09 43.8,45.34 43.8,46.51 41.26,49.05 41.26,50.91 40.33,51.84 40.33,53.64 40.52,53.83 40.52,54.21 v1(40.3,54.43)
  BOTTOM w0.102: v1(40.3,54.43) 40.57,54.7 40.57,55.11 40.41,55.27 C7L15.2 ; v3(129.5,48.99) 129.2,48.99 U80.F45
EDP_AUXN_C_DN: length 6.8
  BOTTOM w0.102: C8L6.1 40.78,56.51 40.78,57.84 41.34,58.39 42.56,58.39 43.76,59.59 43.76,59.98 43.9,60.13 J8L1.16
EDP_AUXP_C_DP: length 6.9
  BOTTOM w0.102: C7L15.1 40.57,56.52 40.57,57.93 41.25,58.61 42.47,58.61 43.54,59.68 43.54,59.98 43.4,60.13 J8L1.15
EDP_BKLEN_OUT: length 8.8
  BOTTOM w0.102: U111.4 46.38,54.63 47.21,55.46 47.21,56.07 v1(46.47,56.8) 46.4,56.88 46.4,58.71 46.63,58.94 47.6,58.94 47.84,59.17 48.52,59.85 48.73,59.85 48.9,60.02 J8L1.26
EDP_COMP: length 12.9
  IN2 w0.127: v3(133.15,48.28) 133.64,47.8 134.62,47.8 135.74,46.67 136.52,46.67 139.24,43.95 139.87,43.95 141.79,42.03 v1(141.79,41.59)
  BOTTOM w0.102: RAP1013.2 142.32,41.59 v1(141.79,41.59)
  BOTTOM w0.254: U80.E52 v3(133.15,48.28)
EDP_HPD: length 92.9
  IN1 w0.079: v3(108.43,52.19) 108.43,51.83 107.97,51.37 106.51,51.37 104.49,49.35 104.49,46.89 102.14,44.54 101.76,44.54 99.77,42.55 99.77,41.92 98.94,41.09 97.88,41.09 97.7,41.28 v1(97.38,41.28) 96.44,40.34 95.63,40.34 93.86,38.57 93.86,37 88.18,31.31 87.77,31.31 87.38,30.93 85.1,30.93 84.79,31.23 84.01,31.23 83.49,31.76 75.86,31.76 74.52,33.1 73.45,33.1 71.92,34.63 70.55,34.63 69.08,36.1 67.03,36.1 62.41,40.72 60.31,40.72 59.8,41.24 59.22,41.24 57.38,43.07 53.67,43.07 52.28,44.46 52.28,46.84 49.95,49.17 49.95,50.41 49.44,50.92 49.44,53.21 49.55,53.32 49.55,53.62 49.22,53.96 48.69,53.96 45.51,57.14 v1(45.31,57.14)
  BOTTOM w0.102: U80.L10 108.85,51.77 v3(108.43,52.19) ; RAP1455.1 97.5,41.15 v1(97.38,41.28) ; v1(45.31,57.14) 45.47,57.14 45.81,57.48 C783.1 R788.2
EDP_TX_DN*<0>: length 128.8
  IN1 w0.079: v1(38.8,54.41) 39.01,54.21 39.01,53.72 39.29,53.44 39.29,51.97 40.5,50.76 40.5,48.88 43.01,46.36 43.01,45.22 45.79,42.44 46.51,42.44 53.67,35.28 55.06,35.28 57.05,33.29 59.02,33.29 62.6,29.7 62.6,28.18 67.49,23.29 76.83,23.29 77.83,22.29 91.57,22.29 92.98,23.7 97.66,23.7 99.21,25.26 102.36,25.26 104.32,27.21 114.17,27.21 115.04,28.07 116.63,28.07 119.08,30.53 119.08,38.1 120.53,39.55 123.91,39.55 125.38,41.02 127.39,41.02 128.41,42.04 128.41,42.91 128.49,42.98 128.67,42.98 v1(128.85,42.8)
  BOTTOM w0.076: 130.2,45.24 130.2,45.29 130.18,45.32 130.18,46.64 130.47,46.93 U80.C47
  BOTTOM w0.102: 130.2,45.24 130.2,44.9 129.62,44.32 129.62,43.31 129.28,42.97 129.02,42.97 v1(128.85,42.8) ; v1(38.8,54.41) 39.04,54.65 39.04,56.58 C7L13.2
EDP_TX_DN*<1>: length 128.7
  IN1 w0.079: v3(127.07,43.44) 126.91,43.28 125.22,43.28 123.26,41.32 119.91,41.32 117.61,39.02 117.61,31.27 115.99,29.65 114.17,29.65 113.23,28.72 102.18,28.72 100.83,27.37 99.11,27.37 98.06,26.32 93.52,26.32 91.06,23.87 88.94,23.87 88.63,24.17 86.33,24.17 85.95,23.78 78.51,23.78 77.49,24.81 69.81,24.81 69.25,25.36 68.29,25.36 64.33,29.32 64.33,30.11 59.67,34.76 57.67,34.76 55.64,36.79 54.24,36.79 46.9,44.13 46.45,44.13 45.8,44.79 45.8,45.88 42.56,49.11 42.56,50.78 41.16,52.18 41.16,52.79 42.26,53.89 42.26,54.8 41.67,55.39 37.91,55.39 37.45,54.92 37.45,54.52 v1(37.25,54.33)
  BOTTOM w0.076: U80.D46 129.26,47.41 129.09,47.24 129.05,47.15 129.05,47.02 129,46.86 128.91,46.54 128.91,46.3 128.95,46.21 128.95,46.02 128.91,45.92 128.91,45.52
  BOTTOM w0.102: 128.91,45.52 127.57,44.17 127.57,43.5 127.44,43.37 127.14,43.37 v3(127.07,43.44) ; C7L11.2 37.49,54.83 37.49,54.57 v1(37.25,54.33)
EDP_TX_DP<0>: length 128.8
  IN1 w0.079: v1(39.54,54.41) 39.19,54.07 39.19,53.8 39.47,53.52 39.47,52.04 40.68,50.83 40.68,48.95 43.2,46.44 43.2,45.29 45.86,42.63 46.58,42.63 53.74,35.47 55.14,35.47 57.13,33.47 59.09,33.47 62.79,29.78 62.79,28.25 67.57,23.48 76.91,23.48 77.91,22.48 91.5,22.48 92.91,23.88 97.58,23.88 99.14,25.44 102.29,25.44 104.24,27.4 114.1,27.4 114.96,28.26 116.55,28.26 118.9,30.6 118.9,38.17 120.46,39.73 123.83,39.73 125.31,41.21 127.31,41.21 128.23,42.12 128.23,42.98 128.41,43.17 128.7,43.17 128.85,43.31 v1(128.85,43.54)
  BOTTOM w0.076: 130.01,45.24 130.01,46.4 129.97,46.44 129.7,46.44 129.61,46.54 129.61,46.66 129.7,46.76 U80.C46
  BOTTOM w0.102: v1(39.54,54.41) 39.25,54.7 39.25,56.58 C7L14.2 ; v1(128.85,43.54) 128.85,43.37 129.05,43.16 129.2,43.16 129.43,43.39 129.43,44.4 130.01,44.98 130.01,45.24
EDP_TX_DP<1>: length 128.7
  IN1 w0.079: v3(127.02,42.83) 127.02,43.01 126.93,43.1 125.3,43.1 123.33,41.13 119.98,41.13 117.79,38.94 117.79,31.19 116.06,29.46 114.24,29.46 113.31,28.53 102.25,28.53 100.91,27.19 99.19,27.19 98.14,26.14 93.59,26.14 91.14,23.68 88.86,23.68 88.55,23.99 86.41,23.99 86.02,23.6 78.44,23.6 77.41,24.62 69.73,24.62 69.17,25.18 68.21,25.18 64.14,29.24 64.14,30.03 59.6,34.58 57.59,34.58 55.56,36.61 54.17,36.61 46.83,43.95 46.38,43.95 45.61,44.71 45.61,45.8 42.38,49.04 42.38,50.7 40.97,52.11 40.97,52.87 42.07,53.96 42.07,54.72 41.59,55.2 37.99,55.2 37.64,54.85 37.64,54.44 37.75,54.33 v1(37.99,54.33)
  BOTTOM w0.076: U80.C45 129.53,47.08 129.62,46.99 129.62,46.91 129.47,46.76 129.22,46.76 129.12,46.66 129.08,46.52 129.08,46.33 129.11,46.24 129.11,45.99 129.08,45.89 129.08,45.61 129.09,45.59 129.09,45.54 129.09,45.44 129.05,45.41 129.05,45.39 129.05,45.38 129.05,45.38
  BOTTOM w0.102: C7L12.2 37.7,54.78 37.7,54.62 v1(37.99,54.33) ; v3(127.02,42.83) 127.35,43.16 127.52,43.16 127.76,43.39 127.76,44.09 128.33,44.66 129.05,45.38
EDP_TXN0_C_DN: length 5.7
  BOTTOM w0.102: J8L1.12 41.9,60.12 42.21,59.81 42.21,59.47 41.97,59.22 40.85,59.22 40.16,58.54 39.39,58.54 38.68,57.83 C7L13.1
EDP_TXN1_C_DN: length 6.7
  BOTTOM w0.102: C7L11.1 37.54,56.54 37.54,57.8 38.94,59.2 39.99,59.2 40.51,59.72 40.51,59.95 40.4,60.06 J8L1.9
EDP_TXP0_C_DP: length 5.7
  BOTTOM w0.102: J8L1.13 42.4,59.94 42.43,59.91 42.43,59.38 42.05,59.01 40.94,59.01 40.25,58.33 39.47,58.33 39.29,58.14 39.29,57.92 39.38,57.83 C7L14.1
EDP_TXP1_C_DP: length 6.7
  BOTTOM w0.102: J8L1.10 40.9,60.04 40.72,59.86 40.72,59.63 40.07,58.99 39.03,58.99 37.76,57.71 37.76,56.49 C7L12.1
EDRAM_EDM: length 4.4
  BOTTOM w0.102: U80.AY71 145.82,67.3 RAP1325.2
EDRAM_OPIO_RCOMP: length 3.1
  TOP w0.254: v3(141.64,50.07) 141.45,50.07 140.84,50.68 140.58,50.68 140,51.26 R47.1
  BOTTOM w0.203: v3(141.64,50.07) 141.5,50.07 U80.H66
EMMC<0>: length 7.4
  BOTTOM w0.102: USM2006.A3 64.04,46.08 64.93,46.97 66.85,46.97 66.92,46.9 67.56,46.9 v1(67.66,47) 68.16,47.5 RSM2143.2 69.33,47.5 69.43,47.4 R5126.1
EMMC<1>: length 8.2
  BOTTOM w0.102: R5127.1 69.58,49.79 RSM2144.2 68.77,49.79 68.09,49.11 66.42,49.11 63.9,46.58 USM2006.A4
EMMC<2>: length 9.8
  BOTTOM w0.102: R5128.1 69.46,51.95 RSM2145.2 68.39,51.95 v1(67.71,51.26) 65.88,49.44 64.76,49.44 64.19,48.86 64.19,47.52 63.75,47.08 USM2006.A5
EMMC<3>: length 8.7
  BOTTOM w0.076: USM2006.B2 62.84,45.58 63.08,45.34 63.27,45.34 63.42,45.18 63.42,44.98 63.36,44.92 63.36,44.88
  BOTTOM w0.102: 63.36,44.88 63.36,44.67 63.83,44.2 67.12,44.2 68.14,45.22 68.15,45.22 v1(68.17,45.22) RSM2146.2 69.31,45.22 69.46,45.37 R5129.1
EMMC<4>: length 9.2
  BOTTOM w0.076: USM2006.B3 62.94,45.83 63.3,45.83
  BOTTOM w0.102: R5130.1 69.46,45.91 RSM2147.2 67.15,45.91 65.68,44.43 63.92,44.43 63.59,44.77 63.59,45.54 63.3,45.83
EMMC<5>: length 8.2
  BOTTOM w0.076: 63.57,46.34 62.92,46.34 USM2006.B4
  BOTTOM w0.102: R5131.1 69.71,48.19 RSM2148.2 v1(68.17,48.19) 68.12,48.19 68.09,48.17 65.8,48.17 63.98,46.34 63.57,46.34
EMMC<6>: length 8.8
  BOTTOM w0.076: 63.62,46.84 62.92,46.84 USM2006.B5
  BOTTOM w0.102: 63.62,46.84 63.83,46.84 67.03,50.04 v1(68.14,50.04) 68.46,50.35 RSM2149.2 69.31,50.35 69.41,50.45 R5132.1
