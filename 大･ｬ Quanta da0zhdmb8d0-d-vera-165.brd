# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+V3P3A_EC_SPI on TOP (solid shape): 97.17,29.24 97.17,28.94 96.97,28.74 96.55,28.74 96.5,28.68 96.49,28.68 96.03,28.23 95.39,28.23 95.32,28.15 95.32,27.74 95.55,27.52 96,27.52 96.11,27.41 96.11,27.06 95.85,26.8 93.59,26.8 92.58,27.82 92.58,28.66 93.31,29.4 95.01,29.4 95.27,29.14 96.06,29.14 96.14,29.22 96.17,29.26 96.39,29.47 96.94,29.47
+V3P3A_R950 on TOP (solid shape): 44.72,51.47 44.72,51.37 44.72,51.37 44.72,50.58 44.72,50.58 44.72,50.09 44.71,50.05 44.69,50.03 44.65,49.99 44.63,49.94 44.61,49.9 44.6,49.84 44.59,49.79 44.6,49.74 44.61,49.69 44.63,49.64 44.65,49.59 44.69,49.55 44.71,49.53 44.72,49.5 44.72,48.88 44.57,48.72 43.35,48.72 43.1,48.47 43.1,47.68 43.02,47.61 41.84,47.61 41.01,48.44 41.01,48.92 40.99,48.95 40.99,49.44 41.09,49.54 42.89,49.54 43.02,49.66 43.02,50.58 44.52,50.58 44.52,51.37 44.32,51.37 44.32,50.58 43.02,50.58 43.02,51.06 43.6,51.65 44.54,51.65
+V3P3A_RTC on BOTTOM (solid shape): 98.13,79.24 98.14,79.15 98.14,78.53 98.13,78.49 98.12,78.45 98.12,78.41 97.68,77.96 97.68,77.33 97.63,77.27 97.4,77.27 97.27,77.4 97.27,79.36 97.53,79.61 97.76,79.61
+V3P3A_TPM on TOP (solid shape): 64.1,60.31 64.1,58.38 63.85,58.12 63.13,58.12 62.91,58.2 62.69,58.12 61.99,58.12 61.71,58.4 61,58.4 60.95,58.45 60.95,58.61 60.98,58.63 61.69,58.63 61.74,58.68 61.94,58.68 62.04,58.58 62.08,58.58 62.08,58.58 62.83,58.58 62.87,58.58 63.11,58.58 63.21,58.68 63.21,58.94 62.96,59.19 62.96,60.21 63.21,60.46 63.95,60.46
+V3P3A_TPM on TOP (solid shape): 56.91,59.7 56.91,59.44 56.86,59.39 56.05,59.39 55.95,59.29 55.69,59.29 55.64,59.23 55.62,59.23 55.4,58.99 55.47,58.66 55.47,58.66 55.29,58.48 54.75,58.48 54.64,58.59 54.62,58.62 54.68,58.88 54.57,59.09 54.56,59.11 54.56,59.13 54.56,59.66 54.57,59.7 54.61,59.71 55.12,59.71 55.18,59.77 55.24,59.77 55.42,59.95 56.66,59.95
+V3P3A_TPM on TOP (solid shape): 56.91,56.07 56.91,54.49 57.14,54.26 57.3,54.26 57.38,54.25 57.47,54.26 59.02,54.26 59.56,54.8 59.56,55.76 59.61,55.81 59.76,55.81 59.8,55.77 59.8,54.53 60.42,53.91 60.42,53.21 60.19,52.99 57.63,52.99 57.63,53.03 57.26,53.34 56.92,53.01 56.89,52.94 56.82,52.92 56,52.92 54.2,54.72 54.2,55.89 54.35,56.04 54.78,56.04 54.93,55.89 55.28,55.89 55.47,55.84 55.65,55.89 55.85,55.89 56.08,56.12 56.86,56.12
+V3P3A_TPM on BOTTOM (solid shape): outline of 102 points within 54.83,55.2 64.06,60.49
+V3P3A_WIFI on TOP (solid shape): 220.01,29.22 220.01,27.72 219.85,27.57 217.62,27.57 217.49,27.69 217.49,28.62 217.51,28.64 217.51,29.24 217.54,29.27 219.96,29.27
+V3P3A_WIFI on TOP (solid shape): 191.76,22.77 191.76,22.26 191.64,22.13 190.04,22.13 189.93,22.03 189.93,21.29 187.9,19.26 186.61,19.26 186.48,19.39 186.48,20.94 186.61,21.06 187.67,21.06 188.16,21.55 188.16,22.59 188.64,23.07 191.46,23.07
+V3P3A_WIFI on TOP (solid shape): 198.26,22.42 198.26,17.21 199,16.46 199,13.62 196.61,11.23 195.01,11.23 194.86,11.39 194.86,14.08 195.09,14.31 196.82,14.31 197.22,14.71 197.22,15.78 196.64,16.37 196.64,18.5 196.03,19.11 195.65,19.11 195.17,19.59 195.17,22.36 195.22,22.41 196.16,22.41 196.28,22.54 198.14,22.54
+V3P3A_WIFI on BOTTOM (solid shape): 199,29.01 199,26.98 199,26.98 199,19.79 198.72,19.51 198.72,19.44 198.7,19.41 198.7,11.13 198.06,10.5 194.79,10.5 194.23,11.06 194.23,11.34 195.7,11.34 195.7,11.56 194.23,11.56 194.23,11.84 195.7,11.84 195.7,11.84 195.8,11.84 195.8,14.18 197.17,15.55 197.17,18.07 195.88,19.36 195.88,23.37 195.92,23.45 196.01,23.47 196.41,23.62 196.36,24.06 196.36,25.1 195.88,25.59 195.88,28.46 195.78,28.56 195.7,28.56 195.7,28.56 194.2,28.56 194.1,28.66 194.1,28.84 195.7,28.84 195.7,29.06 194.1,29.06 194.1,29.83 194.15,29.88 198.14,29.88
+V3P3A_WIFI on IN1 (solid shape): outline of 1073 points within 190.34,19.59 220.46,29.29
+V3P3DSW_EC on TOP (solid shape): 31.08,46.9 31.08,45.91 30.42,45.25 29.56,45.25 28.54,46.26 28.54,46.77 28.75,46.97 31.01,46.97
+V3P3DSW_EC on TOP (solid shape): 38.45,45.37 38.45,43.72 37.94,43.21 37.05,43.21 36.92,43.34 36.92,43.72 37.05,43.85 37.69,43.85 37.81,43.98 37.81,45.03 37.84,45.17 37.81,45.3 37.81,45.37 37.94,45.5 38.32,45.5
+V3P3DSW_EC on TOP (solid shape): 45.28,45.58 45.28,45.37 45.24,45.29 45.16,45.27 45,45.25 44.85,45.17 43.73,45.17 43.48,44.91 42.36,44.91 42.33,44.94 42.33,45.37 42.38,45.42 43.53,45.42 43.78,45.68 44.21,45.68 44.37,45.83 45.03,45.83
+V3P3DSW_EC on TOP (solid shape): 34.89,58.07 35.15,57.82 35.15,57.18 35.02,57.06 32.99,57.06 32.61,56.68 32.61,54.69 32.7,54.6 32.7,54.57 33.04,54.23 33.04,53.75 33.03,53.67 33.04,53.59 33.04,52.69 33.01,52.66 32.76,52.66 32.73,52.69 32.73,53.24 32.73,53.75 31.72,54.77 31.72,57.69 32.1,58.07 32.97,58.07
+V3P3DSW_EC on TOP (solid shape): 37.18,55.3 37.18,54.85 36.92,54.59 36.92,54.46 36.92,54.45 36.95,54.15 37.2,53.98 37.21,53.97 37.32,53.87 37.32,53.84 37.32,53.83 37.48,53.42 37.92,53.48 37.94,53.5 37.96,53.5 39.46,53.5 39.59,53.37 39.59,51.6 39.46,51.47 38.91,51.47 38.19,52.18 37.79,52.18 37.79,52.18 37.25,52.18 37.23,52.2 37.23,52.53 37.08,52.69 36.75,52.69 36.73,52.7 36.73,53.24 36.72,53.24 36.72,53.3 36.19,53.83 36.19,54.46 36.19,54.54 36.64,55 36.64,55.28 36.77,55.41 37.08,55.41
+V3P3DSW_EC on BOTTOM (solid shape): 95.27,12.81 95.27,12.1 94.99,11.82 92.55,11.82 92.35,12.02 92.35,12.54 92.82,13.01 95.06,13.01
+V3P3DSW_EC on BOTTOM (solid shape): 101.87,13.19 101.87,12.02 101.86,11.98 101.82,11.97 101.73,11.97 101.73,11.92 101.71,11.88 101.67,11.87 101.63,11.87 101.63,10.78 101.67,10.78 101.71,10.76 101.73,10.72 101.73,10.66 101.67,10.6 101.49,10.6 101.39,10.7 101.39,10.75 101.42,10.78 101.43,10.78 101.43,11.87 101.41,11.89 101.41,11.92 101.41,11.95 101.43,11.96 101.55,12.48 101.02,12.54 100.96,12.52 100.89,12.54 100.8,12.6 100.7,12.63 100.68,12.63 100.2,13.11 100.2,13.65 100.35,13.8 101.26,13.8
+V3P3DSW_EC on IN2 (solid shape): 93.39,12.49 93.59,12.49 93.94,12.14 93.96,12.1 93.94,12.07 93.71,11.83 92.49,11.83 92.4,11.92 92.4,12.45 92.6,12.66 93.23,12.66
+V3P3DSW_EC on IN2 (solid shape): outline of 488 points within 28.92,44.99 48.4,55.79
+V3P3DX_EDP_FUSE on BOTTOM (solid shape): outline of 85 points within 42.11,56.01 45.56,61.58
+V3P3S on TOP (solid shape): 39.06,59.37 39.06,57.08 38.98,57.01 37.15,57.01 36.24,57.92 36.24,59.24 36.64,59.65 38.78,59.65
+V3P3S on TOP (solid shape): 22.43,26.01 22.91,26.01 23.28,25.64 23.28,25.15 23.13,25 22.22,25 21.94,25.28 21.25,25.28 21.18,25.36 21.18,26.35 21.25,26.42 22.01,26.42
+V3P3S on TOP (solid shape): 23.86,52.64 23.86,51.77 24.88,50.75 24.88,50.48 25.72,49.64 26.12,49.64 26.17,49.64 26.38,49.64 26.84,49.18 26.84,48.24 26.32,47.72 26.3,47.73 26.17,47.73 26.05,47.68 25.75,47.68 25.69,47.72 25.61,47.73 25.6,47.73 24.48,48.85 24.48,49.54 24.3,49.72 23.74,49.72 23.4,50.06 23.4,51.14 23.27,51.26 23.33,51.64 23,51.85 22.98,51.85 22.9,51.93 22.9,52.69 23.03,52.81 23.68,52.81
+V3P3S on BOTTOM (solid shape): 101.8,42.78 101.8,42.13 101.17,41.51 100.31,41.51 99.98,41.18 99.43,41.18 99.36,41.26 99.36,41.66 99.46,41.77 100.02,41.77 100.4,42.15 100.8,42.15 100.98,42.32 100.98,42.76 101.06,42.83 101.74,42.83
+V3P3S on BOTTOM (solid shape): 39,61.37 39.04,61.36 39.05,61.32 39.05,60.05 39.25,60.05 39.25,61.32 39.26,61.36 39.3,61.37 39.51,61.37 39.54,61.35 39.54,59.72 39.45,59.63 38.77,59.63 37.11,57.98 37.11,57.88 37.05,57.82 36.42,57.82 36.2,58.03 36.2,59.35 36.68,59.84 38.51,59.84 38.62,59.95 38.65,59.95 38.65,59.98 38.73,60.05 38.75,60.05 38.75,61.32 38.76,61.36 38.8,61.37
+V3P3S on IN1 (solid shape): outline of 118 points within 15.28,25.03 23.26,39.15
+V3P3S on IN2 (solid shape): outline of 1497 points within 14.44,37.23 43.91,63.96
+V3P3S_AUDIO_VDDMIC on TOP (solid shape): 23.34,10.68 23.49,10.68 23.59,10.57 23.59,10.12 23.49,10.02 21.96,10.02 21.86,10.12 21.86,10.5 22.14,10.78 22.14,11.06 22.4,11.31 22.71,11.31
+V3P3S_AUDIO_VDDMIC on TOP (solid shape): 22.19,23.32 23.08,23.32 23.31,23.1 23.31,22.66 22.98,22.33 22.24,22.33 22.19,22.28 22.19,22.23 22.18,22.21 22.1,22.06 22.1,21.9 22.11,21.87 22.04,21.8 21.61,21.8 21.6,21.81 21.6,21.87 21.48,21.99 21.47,22 21.45,22.08 21.4,22.15 21.4,22.44 21.15,22.69 21.15,23.5 21.25,23.6 21.91,23.6
+V3P3S_AUDIO_VDDMIC on IN1 (solid shape): 23.13,12.05 23.13,10.52 22.9,10.29 22.27,10.29 21.96,10.6 21.96,12.15 22.12,12.3 22.88,12.3
+V3P3S_AUDIO_VDDMIC on IN1 (solid shape): outline of 166 points within 20.21,19.69 24.1,23.2
+V3P3S_HDMI on TOP (solid shape): 21.38,40.17 21.38,38.92 21.38,38.92 21.38,38.53 20.67,37.82 20.67,36.69 20.52,36.53 19.58,36.53 19.22,36.89 19.22,37.8 19.97,38.55 19.97,40.13 20.19,40.34 21.2,40.34
+V3P3S_HDMI on TOP (solid shape): 23.12,50.87 23.12,50.12 23.14,50.12 23.14,49.98 23.59,49.53 23.59,47.82 23.56,47.81 23.33,47.48 23.56,47.15 23.59,47.14 23.59,47.07 23.39,46.87 22.34,46.87 22.27,46.95 22.27,48.22 22.3,48.29 22.36,48.32 22.7,48.71 22.3,49.03 22.27,49.02 22.09,49.21 22.09,50.93 22.24,51.09 22.9,51.09
+V3P3S_HDMI on BOTTOM (solid shape): 20.52,50.1 20.52,49.41 20.44,49.33 17.11,49.33 17.09,49.36 17.09,49.84 17.8,50.55 18.1,50.55 18.13,50.58 20.03,50.58
+V3P3S_HDMI on IN1 (solid shape): outline of 460 points within 16.78,36.51 23.33,50.93
+V3P3S_R on TOP (solid shape): 20.67,27.06 20.67,21.75 20.54,21.62 20.01,21.62 19.93,21.7 19.93,22.64 19.7,22.87 16.53,22.87 16.48,22.92 16.48,23.53 16.6,23.66 19.4,23.66 19.78,24.04 19.78,27.16 19.89,27.27 19.94,27.29 20.44,27.29
+V3P3S_R955 on TOP (solid shape): 26.28,55.13 26.28,54.03 26.15,53.91 25.75,53.91 25.58,53.74 25.58,53.09 25.8,52.88 25.8,52.64 25.61,52.45 25.58,52.45 24.99,51.85 24.33,51.85 24.25,51.93 24.25,52.97 24.35,53.07 24.35,53.28 24.35,53.28 24.35,53.78 24.6,54.03 24.62,54.04 24.66,54.07 24.7,54.1 24.73,54.15 24.74,54.17 24.81,54.24 24.81,54.24 24.82,54.26 26.1,54.26 26.1,55.05 25.91,55.05 25.91,54.26 24.82,54.26 24.83,54.27 24.83,54.87 25.24,55.28 26.13,55.28
+V5_LDO on TOP (solid shape): 59.5,64.45 59.5,63.25 59.1,62.85 58.13,62.85 57.73,63.25 57.73,64.09 58.39,64.75 59.2,64.75
+V5_LDO on TOP (solid shape): 24.73,55.1 24.73,54.31 24.25,53.83 24.25,53.32 24.17,53.25 23.59,53.25 23.49,53.35 23.49,53.96 23.33,54.11 23.33,54.59 23.35,54.63 23.39,54.64 23.97,54.64 23.99,54.66 24.1,54.77 24.1,55.1 24.2,55.2 24.63,55.2
+V5_LDO on TOP (solid shape): 47.19,54.24 47.19,53.35 46.91,53.07 46.9,53.06 46.71,52.69 47,52.4 47.02,52.4 47.1,52.32 47.1,52.14 47.06,52.1 45.86,52.1 45.73,51.96 45.01,51.96 44.92,52.05 44.92,54.29 45.08,54.44 46.98,54.44
+V5_LDO on TOP (solid shape): 79.66,60.08 80.74,60.08 80.82,60 80.82,59.46 80.82,59.42 80.81,59.41 80.79,59.39 80.77,59.38 79.95,59.38 79.92,59.4 79.91,59.42 79.72,59.65 79.42,59.64 79.41,59.63 79.15,59.63 78.83,59.95 78.28,59.95 77.97,59.65 77.72,59.65 77.69,59.66 77.67,59.7 77.67,60.97 77.86,61.16 78.58,61.16
+V5_LDO on TOP (solid shape): 81.45,62.67 81.45,62.42 81.37,62.34 80.33,62.34 80.2,62.47 80.2,62.51 80.14,62.66 80,62.72 79.7,62.72 79.64,62.71 79.58,62.68 79.57,62.67 79.26,62.67 79.24,62.64 79.21,62.64 79.09,62.52 79.08,62.52 78.85,62.3 78.88,61.99 78.88,61.6 78.76,61.48 78.39,61.48 78.24,61.62 78.24,61.95 78.4,62.11 78.4,62.64 78.81,63.05 80.19,63.05 80.35,63.2 80.92,63.2
+V5_LDO on BOTTOM (solid shape): 25.85,54.08 25.85,53.55 25.54,53.25 25.26,53.25 24.1,54.41 24.1,55.05 24.25,55.2 24.73,55.2
+V5_LDO on BOTTOM (solid shape): 45.81,54.14 45.81,53.46 45.52,53.17 45.52,52.78 45.08,52.33 44.54,52.33 44.19,52.69 44.19,53.58 44.92,54.31 45.64,54.31
+V5_LDO on BOTTOM (solid shape): 99.26,92.5 99.97,92.5 99.97,92.09 99.89,91.93 99.89,91.76 99.89,91.74 99.88,91.72 99.74,91.57 98.93,91.57 98.8,91.7 98.9,92.02 98.7,92.28 98.7,92.36 98.9,92.57 99.26,92.57
+V5_LDO on IN1 (solid shape): 78.94,61.67 78.94,60.59 78.02,59.67 77.02,59.67 76.11,60.59 75.81,60.59 75.61,60.79 75.61,61.35 76.06,61.8 78.16,61.8 78.38,62.03 78.58,62.03
+V5_LDO on IN1 (solid shape): 59.68,64.33 59.69,64.29 59.68,64.26 59.67,63.84 60.06,63.7 60.09,63.7 60.12,63.69 60.39,63.41 60.39,63.15 60.42,63.13 60.42,62.85 60.19,62.62 59.61,62.62 58.06,64.17 58.06,64.68 58.36,64.98 59.02,64.98
+V5A on TOP (solid shape): 206.67,11.82 206.67,11.06 206.52,10.9 204.46,10.9 204.34,11.03 204.34,11.82 204.39,11.87 206.62,11.87
+V5A on TOP (solid shape): 22.7,58.45 22.7,58.25 22.42,57.97 21.68,57.97 21.28,57.56 20.87,57.56 20.82,57.61 20.82,58.38 20.97,58.53 22.62,58.53
+V5A on TOP (solid shape): 31.59,34.32 31.59,32.74 31.36,32.51 30.48,32.51 30.23,32.76 30.23,33.39 30.72,33.88 30.72,34.26 30.91,34.45 31.46,34.45
+V5A on TOP (solid shape): 32.86,27.59 32.86,26.83 32.73,26.7 32.73,25.69 32.48,25.43 31.97,25.43 31.64,25.77 31.64,25.86 31.34,26.16 31.34,27.12 31.93,27.72 32.73,27.72
+V5A on TOP (solid shape): 29.56,15.53 29.56,14.89 29.92,14.53 29.92,13.62 29.8,13.5 28.67,13.5 28.52,13.65 28.52,14.74 28.41,14.84 28.41,15.53 28.54,15.65 29.43,15.65
+V5A on TOP (solid shape): 28.29,57.79 28.29,56.9 28.19,56.8 27.6,56.8 27.37,56.57 27.37,55.84 27.27,55.74 26.56,55.74 26.51,55.79 26.51,56.75 26.92,57.16 26.92,57.71 27.1,57.89 28.19,57.89
+V5A on TOP (solid shape): 86.38,89.01 86.38,84.62 85.51,83.75 79.12,83.75 78.18,84.7 78.18,86.57 77.98,86.76 77.98,88.6 78.27,88.89 84.04,88.89 84.26,89.11 86.28,89.11
+V5A on TOP (solid shape): 193.52,41.75 193.52,41.29 193.64,41.17 193.64,40.95 193.43,40.74 193.22,40.74 192.61,41.36 192.07,41.36 192,41.43 192,41.79 192.08,41.87 192.86,41.87 192.86,41.87 193.4,41.87
+V5A on TOP (solid shape): 178.83,22.03 178.83,18.47 178.4,18.04 176.83,18.04 176.65,18.22 176.65,20.3 176.57,20.38 175.91,20.38 175.86,20.43 175.86,20.76 175.58,21.04 175.58,22.32 175.58,22.32 175.58,22.82 175.61,22.84 178.02,22.84
+V5A on TOP (solid shape): 203.62,19.69 203.62,19.46 204.08,19.01 204.08,18.58 203.98,18.47 203.98,16.62 203.91,16.55 203.77,16.55 203.76,16.56 203.64,16.62 203.51,16.64 202.72,16.64 202.62,16.54 202.33,16.54 202.1,16.77 202.1,19.41 202.63,19.95 203.37,19.95
+V5A on TOP (solid shape): 161.9,30.71 162.39,30.71 162.4,30.7 162.4,30.54 162.39,30.51 162.35,30.49 161.9,30.49 161.87,30.46 161.7,30.46 161.37,30.79 160.5,30.79 160.15,30.44 159.29,30.44 158.12,29.27 157.4,29.27 157.21,29.46 157.21,29.74 157.4,29.93 157.75,29.93 158.97,31.14 161.47,31.14
+V5A on TOP (solid shape): 199.71,36.69 199.79,36.68 199.88,36.68 200.21,36.35 200.75,36.35 200.78,36.34 200.8,36.3 200.8,36.06 200.74,36 200.36,36 200.1,36.27 199.64,36.27 199.6,36.31 198.97,36.31 198.93,36.35 198.12,36.35 198.1,36.37 198.1,36.52 198.12,36.55 199.45,36.55 199.59,36.69 199.61,36.71 199.64,36.71
+V5A on TOP (solid shape): 204.18,27.34 204.18,26.07 204.56,25.69 205.83,25.69 206.32,26.17 206.71,26.17 206.75,26.15 206.77,26.12 206.77,25.35 206.97,25.35 206.97,26.12 206.98,26.15 207.02,26.17 207.1,26.17 207.15,26.12 207.15,25.13 206.14,24.11 206.14,23.71 206.04,23.6 203.98,23.6 203.93,23.66 203.93,24.04 203.04,24.93 203.04,27.34 203.33,27.63 203.89,27.63
+V5A on TOP (solid shape): 52.56,70.57 52.56,70.48 52.56,69.87 52.56,69.87 52.56,69.59 52.32,69.35 52.32,68.56 52.16,68.41 44.85,68.41 41.09,64.65 39.36,64.65 38.32,63.61 36.85,63.61 36.42,63.18 33.05,63.18 32.31,63.91 32.31,65.35 31.72,65.95 31.72,66.71 31.82,66.81 32,66.81 32.45,66.35 32.45,66.17 32.53,66.1 32.53,66.09 32.74,65.89 33.03,65.91 33.04,65.92 33.14,65.92 33.29,66.07 33.29,66.68 33.44,66.84 38.98,66.84 39.48,67.33 39.48,67.37 39.65,67.54 39.65,71.21 39.84,71.41 51.72,71.41
+V5A on TOP (solid shape): 176.88,39.73 176.88,37.93 178.27,36.53 182.62,36.53 184.96,34.2 184.96,30.85 184.95,30.84 184.93,30.71 184.95,30.59 184.96,30.58 184.96,30.24 184.95,30.23 184.93,30.1 184.95,29.98 184.96,29.97 184.96,25.68 183.85,24.57 182.44,24.57 182.19,24.82 182.19,28.91 182.8,29.52 182.8,31.56 182.8,31.58 182.81,31.6 182.91,31.84 182.81,32.09 182.8,32.1 182.8,32.12 182.8,33.43 181.45,34.78 181.42,34.78 181.15,35.06 176.47,35.06 173.32,38.21 171.62,38.21 171.34,38.49 171.34,39.4 171.8,39.86 176.75,39.86
+V5A on TOP (solid shape): outline of 88 points within 208.58,23.86 215.05,28.33
+V5A on BOTTOM (solid shape): 28.54,27.03 28.54,26.58 28.41,26.45 24.38,26.45 24.25,26.58 24.25,26.86 24.48,27.08 28.49,27.08
+V5A on BOTTOM (solid shape): 83.96,88.67 83.96,83.28 83.17,82.49 79.04,82.49 78.27,83.26 78.27,88.63 78.42,88.79 83.84,88.79
+V5A on BOTTOM (solid shape): 25.21,51.14 25.21,49.06 24.96,48.8 24.27,48.8 24.17,48.9 24.17,51.08 24.17,51.14 24.07,51.24 22.24,51.24 22.09,51.39 22.09,52.08 22.37,52.36 23.99,52.36
+V5A on BOTTOM (solid shape): 35,37.77 35.01,37.74 35,37.7 32.1,34.8 32.1,34.32 31.59,33.82 31.59,32.08 31.07,31.56 31.03,31.56 31.01,31.58 30.36,31.58 30.23,31.55 30.11,31.49 29.86,31.49 29.83,31.51 29.81,31.54 29.81,33.05 30.45,33.69 30.45,34.45 34.27,38.28 34.49,38.28
+V5A on BOTTOM (solid shape): 172.4,39.65 172.4,37.88 172.32,37.8 171.16,37.8 171.11,37.85 170.4,37.85 170.36,37.9 170.36,38.1 170.38,38.12 171.1,38.12 171.11,38.12 171.15,38.16 171.2,38.16 171.35,38.31 171.35,39.54 170.88,40 170.71,40 170.61,40.02 170.52,40 170.07,40 169.69,39.63 169.69,38.8 169.67,38.78 169.43,38.78 169.42,38.8 169.42,39.8 169.96,40.34 171.72,40.34
+V5A on BOTTOM (solid shape): outline of 407 points within 200.79,11.03 213.02,25.71
+V5A on IN1 (solid shape): outline of 268 points within 24.3,14.13 32.22,33.76
+V5A on IN1 (solid shape): outline of 523 points within 114.85,9.18 178.91,19.77
+V5A on SVCC (solid shape): outline of 163 points within 174.21,8.73 234.72,27.59
+V5A on SVCC (solid shape): outline of 155 points within 28.8,8.63 118.47,85.38
+V5A on IN2 (solid shape): outline of 1101 points within 21.51,50.78 39.21,66.45
+V5A_AUDIO_SPKVDD_L on TOP (solid shape): 30.54,20.4 31.52,20.4 31.54,20.38 31.54,20.12 31.51,20.1 30.52,20.1 30.5,20.07 30.5,19.92 30.52,19.9 31.51,19.9 31.56,19.85 31.56,19.57 30.7,18.7 29.94,18.7 29.81,18.58 29.81,16.29 29.68,16.16 28.92,16.16 28.8,16.29 28.8,18.58 29.3,19.08 29.3,19.97 29.43,20.1 29.81,20.1 30.12,20.4 30.54,20.4
+V5A_AUDIO_SPKVDD_R on TOP (solid shape): 34.76,26.32 34.76,25.43 34.64,25.31 33.49,25.31 33.24,25.56 33.24,26.32 33.37,26.45 34.64,26.45
+V5A_AUDIO_SPKVDD_R on TOP (solid shape): 35.67,20.38 36.65,20.38 36.67,20.35 36.67,20.12 36.66,20.09 36.62,20.07 35.67,20.07 35.67,19.87 36.62,19.87 36.66,19.86 36.67,19.82 36.67,19.59 36.03,18.96 36.03,16.92 35.65,16.54 35.65,16.16 35.4,15.91 35.02,15.91 34.89,16.04 34.89,19.72 35.55,20.38 35.67,20.38
+V5A_AUDIO_SPKVDD_R on IN1 (solid shape): 40.07,25.59 40.07,24.72 39.9,24.54 38.68,24.54 38.02,25.2 34.43,25.2 34.1,25.53 34.1,26.4 34.26,26.55 39.11,26.55
+V5A_AUDIO_SPKVDD_R on IN2 (solid shape): outline of 145 points within 34.16,16.49 36.34,26.6
+V5A_USBC on TOP (solid shape): 20.54,59.29 20.54,55.66 20.29,55.41 20.04,55.41 20.03,55.41 19.91,55.43 19.78,55.41 19.77,55.41 19.17,55.41 18.92,55.66 18.56,55.66 18.52,55.67 18.51,55.71 18.51,55.86 18.52,55.9 18.56,55.91 18.9,55.91 18.99,55.91 19.29,56.21 19.32,56.22 19.67,56.52 19.42,56.92 19.41,56.92 19.09,57.23 19.09,58.02 18.97,58.15 18.56,58.15 18.52,58.16 18.51,58.2 18.51,58.35 18.55,58.4 18.9,58.4 18.9,58.4 18.99,58.4 19.02,58.4 19.04,58.38 19.25,58.21 19.52,58.24 19.53,58.25 19.63,58.25 20.02,58.64 20.02,59.3 20.11,59.39 20.44,59.39
+V5S_FAN on TOP (solid shape): 207.38,30.82 207.38,29.52 207.15,29.29 207.15,27.57 207.1,27.52 207.02,27.52 206.98,27.53 206.97,27.57 206.97,28.31 206.77,28.31 206.77,27.57 206.75,27.53 206.71,27.52 206.42,27.52 206.24,27.69 206.24,29.57 206,29.81 206,30.81 206.14,30.94 207.26,30.94
+V5S_FAN_C on BOTTOM (solid shape): 186.96,70.14 186.96,68.89 188.69,67.17 188.69,63.81 188.51,63.63 187.27,63.63 187.22,63.69 187.22,65.54 187.09,65.67 186.23,65.67 186.02,65.87 186.02,68.51 185.95,68.59 185.31,68.59 185.23,68.66 185.23,70.16 185.34,70.26 186.83,70.26
+V5S_HDMI on TOP (solid shape): 113.91,10.29 113.91,9.2 113.68,8.97 111.88,8.97 111.63,9.23 111.63,10.24 111.98,10.6 113.61,10.6
+V5S_HDMI on TOP (solid shape): 44.52,35.64 44.52,34.73 44.19,34.4 42.89,34.4 42.13,35.16 42.13,35.82 42.26,35.95 44.21,35.95
+V5S_HDMI on TOP (solid shape): 212.11,29.42 212.11,28.35 211.6,27.85 209.47,27.85 209.14,27.52 209.02,27.52 208.98,27.53 208.97,27.57 208.97,28.31 208.77,28.31 208.77,27.57 208.75,27.53 208.71,27.52 208.58,27.52 208.57,27.53 208.57,28.32 209.42,29.17 209.97,29.17 210.48,29.67 211.85,29.67
+V5S_HDMI on BOTTOM (solid shape): 24.5,48.29 24.5,47.71 24.58,47.63 24.58,47.38 24.38,47.18 23.59,47.18 23.44,47.33 23.44,47.73 23.54,47.84 23.81,47.84 23.81,48.11 23.82,48.11 23.82,48.39 23.92,48.5 24.3,48.5
+V5S_HDMI on IN1 (solid shape): 43.2,35.62 43.2,35.44 42.82,35.06 41.98,35.06 40.73,36.3 40.73,36.69 40.97,36.92 41.91,36.92
+V5S_HDMI on IN1 (solid shape): 212.16,29.29 212.16,28.61 211.78,28.23 210.23,28.23 209.8,28.66 209.8,29.29 210.08,29.57 211.88,29.57
+V5S_HDMI on IN1 (solid shape): 24.43,48.06 24.51,48.03 24.53,47.95 24.7,47.58 25.1,47.6 25.23,47.48 25.22,47.45 25.22,47.32 25.27,47.19 25.27,43.04 30.98,37.32 32.58,37.32 32.73,37.17 32.73,36.38 32.43,36.08 27.39,36.08 22.56,40.9 22.56,43.99 23.23,44.66 23.23,45.31 23.27,45.39 23.35,45.41 23.74,45.77 23.35,46.12 23.27,46.15 23.23,46.22 23.23,47.58 23.72,48.06
+V5S_HDMI on IN1 (solid shape): outline of 160 points within 110.79,9.38 114.04,17.48
+V5S_HDMI_C on BOTTOM (solid shape): 24.07,51.04 24.07,49.04 23.54,48.51 23.54,48.01 23.36,47.84 22.83,47.84 22.68,47.99 22.68,48.54 22.68,48.55 22.7,48.67 22.68,48.8 22.68,48.81 22.68,49.18 22.68,49.18 22.7,49.31 22.68,49.43 22.68,49.44 22.68,51.09 22.7,51.11 24,51.11
+VBATA on TOP (solid shape): 36.01,62.52 36.01,61.58 35.86,61.42 33.93,61.42 33.69,61.67 33.69,62.53 33.85,62.69 35.83,62.69
+VBATA on TOP (solid shape): 56.23,21.62 56.23,19.97 55.47,19.21 52.29,19.21 52.04,19.46 52.04,21.5 52.54,22 55.85,22
+VBATA on TOP (solid shape): 62.63,96.67 62.63,95.82 62.43,95.61 60.7,95.61 60.42,95.89 60.42,96.63 60.66,96.87 62.43,96.87
+VBATA on TOP (solid shape): 200.19,35.92 200.19,35.66 200.05,35.52 199.87,35.52 199.84,35.53 199.81,35.54 199.41,35.93 198.95,35.93 198.93,35.95 198.12,35.95 198.1,35.97 198.1,36.13 198.12,36.15 199.96,36.15
+VBATA on TOP (solid shape): 72.48,89.11 72.48,88.76 73.54,87.7 73.54,87.06 73.66,86.94 74.12,86.94 74.18,86.89 74.18,86.1 74.15,86.07 73,86.07 71.14,87.93 71.14,89.09 71.29,89.24 72.36,89.24
+VBATA on TOP (solid shape): outline of 188 points within 64.76,63.69 87.34,82.86
+VBATA on BOTTOM (solid shape): 63.45,96.67 63.45,95.78 63.29,95.61 60.7,95.61 60.42,95.89 60.42,96.63 60.66,96.87 63.25,96.87
+VBATA on BOTTOM (solid shape): 198.51,36.53 199.14,36.53 199.54,36.13 200.06,36.13 200.2,35.99 200.2,35.6 200.12,35.51 199.55,35.51 199.32,35.74 198.12,35.74 198.07,35.79 198.07,36.48 198.12,36.53 198.5,36.53
+VBATA on BOTTOM (solid shape): 58.89,32.8 58.89,32.14 58.76,32 57.58,32 55.61,33.97 55.58,33.99 53.1,33.99 53.08,33.97 52.39,33.28 50.69,33.28 50.49,33.08 50.49,32.88 50.39,32.77 49.4,32.77 49.27,32.9 49.27,34.22 50.17,35.12 56.57,35.12
+VBATA on BOTTOM (solid shape): 58.87,23.12 58.87,22.13 58.39,21.65 58.39,19.87 57.14,18.63 53.84,18.63 52.93,17.71 52.93,16.34 52.88,16.29 51.2,16.29 50.35,15.44 40.85,15.44 40.15,16.14 40.15,18.96 40.2,19.01 49.26,19.01 49.85,19.6 49.85,20.87 50.4,21.43 52.34,21.43 53.12,22.21 54.81,22.21 55.31,22.72 55.31,22.89 55.59,23.17 58.82,23.17
+VBATA on BOTTOM (solid shape): 175.28,37.21 175.28,36.14 176.55,34.88 179.73,34.88 180.11,35.25 180.11,36.67 180.28,36.84 181.23,36.84 182.37,35.69 184.85,35.69 185.18,35.36 185.18,33.31 184.75,32.88 181.26,32.88 180.1,31.72 174.4,31.72 174.1,31.42 174.1,30.32 172.87,29.1 168.78,29.1 167.78,28.1 166.74,28.1 166.61,28.23 166.61,30.63 166.91,30.92 169.53,30.92 169.82,31.2 171.27,31.2 171.52,31.46 171.52,32.47 172.41,33.35 172.41,34.25 172.72,34.56 173.69,34.56 173.94,34.81 173.94,37.19 174.07,37.33 175.16,37.33
+VBATA on BOTTOM (solid shape): outline of 124 points within 57.02,63.97 69.26,73.24
+VBATA on IN1 (solid shape): outline of 399 points within 71.06,79.81 78.66,89.24
+VBATA on IN1 (solid shape): outline of 1291 points within 56.84,64.12 85.03,96.87
+VBATA on SVCC (solid shape): outline of 151 points within 52.67,8.73 181.2,70.26
+VBATA on IN2 (solid shape): outline of 158 points within 74.08,78.27 76.58,81.01
+VBATA on IN2 (solid shape): outline of 563 points within 57.07,70.9 66.08,96.87
+VBATA_C on TOP (solid shape): 34.84,60.82 34.84,58.76 34.61,58.53 33.39,58.53 33.24,58.68 33.24,60.82 33.42,60.99 34.66,60.99
+VBATA_C on BOTTOM (solid shape): 37.56,62.54 37.56,61.35 37.55,61.35 37.55,60.08 37.54,60.04 37.5,60.03 37.3,60.03 37.26,60.04 37.25,60.08 37.25,61.35 37.05,61.35 37.05,60.08 37.04,60.04 37,60.03 36.8,60.03 36.76,60.04 36.75,60.08 36.75,61.35 36.55,61.35 36.55,60.08 36.54,60.04 36.5,60.03 36.09,60.03 35.96,60.15 35.81,60.15 35.8,60.16 35.45,60.16 35.27,59.85 35.27,59.83 35.26,59.81 35.02,59.57 35.02,56.78 34.89,56.65 32.94,56.65 32.73,56.85 32.73,61.6 33.83,62.69 37.41,62.69
+VBATT on TOP (solid shape): 63.39,23.99 63.39,21.83 63.25,21.69 62.53,21.69 61.79,22.43 61.79,23.25 62.6,24.06 63.32,24.06
+VBATT on BOTTOM (solid shape): 64.44,30.17 64.44,25.37 64.2,25.13 63.64,25.13 63.21,24.7 63.21,22.15 62.64,21.59 62.64,19.8 62.34,19.49 59.43,19.49 59.02,19.9 59.02,21.57 59.38,21.93 59.38,30.09 59.52,30.23 64.37,30.23
+VCCAMPHYPLL_1P0 on BOTTOM (solid shape): 108.45,39.81 108.45,38.84 107.43,37.83 107.43,33.03 107.36,32.95 105.78,32.95 105.77,32.97 105.72,33.04 105.65,33.09 105.64,33.11 105.63,33.14 105.63,38.64 106.36,39.37 106.43,39.4 106.5,39.36 106.89,39.27 107.12,39.61 107.12,39.83 107.14,39.87 107.17,39.89 108.37,39.89
+VCCAMPHYPLL_1P0_R on BOTTOM (solid shape): 105.3,33.9 105.3,33.12 105.1,32.87 105.19,32.56 105.22,32.48 105.19,32.41 105.08,32.24 105.09,32.04 105.08,31.95 104.99,31.9 104.36,31.9 104.26,32 104.26,32.86 103.69,33.43 103.69,33.76 103.92,34 105.2,34
+VCCCORE on TOP (solid shape): outline of 1425 points within 120.55,30.49 146.92,62.72
+VCCCORE on BOTTOM (solid shape): 121.68,46.27 121.71,46.27 121.72,46.25 121.75,46.22 121.79,46.19 121.79,46.02 121.71,45.94 121.68,45.83 121.68,45.74 121.91,45.51 122.14,45.74 122.14,45.78 122.17,45.8 122.81,45.8 122.81,45.74 123.04,45.51 123.27,45.74 123.27,45.83 123.26,45.86 123.25,45.9 123.25,46.12 123.41,46.27 123.78,46.27 123.91,46.15 123.91,45.49 123.53,45.11 123.45,45.11 122.78,44.43 122.78,42.4 122.71,42.33 120.71,42.33 120.4,42.02 119.52,42.02 119.45,42.1 119.45,44 120.96,45.51 120.96,46.12 121.11,46.27
+VCCCORE on BOTTOM (solid shape): outline of 178 points within 124.86,28.4 159.2,40.56
+VCCCORE on BOTTOM (solid shape): outline of 545 points within 121.56,60.28 126.81,62.74
+VCCCORE on BOTTOM (solid shape): outline of 612 points within 120.78,49.31 128.3,52.48
+VCCCORE on SVCC (solid shape): 128.65,59.76 128.69,59.73 128.74,59.72 129.38,59.72 129.38,55.08 129.02,54.72 129.38,54.36 129.38,51.09 129.4,50.99 129.45,50.91 129.9,50.46 129.91,50.19 130.04,49.97 131,49 131.09,48.68 131.41,48.6 132.43,47.57 132.43,44.49 132.47,44.29 132.58,44.12 139.56,37.14 139.73,37.03 139.93,36.99 146.7,36.99 147.44,36.25 147.6,36.14 147.8,36.1 163.77,36.1 164.05,35.82 164.05,32.43 163.8,32.09 164.05,31.74 164.05,27.68 163.71,27.34 152.58,27.34 151.08,28.84 150.91,28.95 150.71,28.99 137.97,28.99 137.29,29.67 137.2,30 136.87,30.1 136.72,30.24 136.56,30.35 136.36,30.39 134.45,30.39 134.23,30.46 134.01,30.39 121.46,30.39 119.86,31.99 119.86,41.73 120.72,42.6 120.83,42.77 120.87,42.96 120.87,46.13 120.8,46.39 120.62,46.57 120.62,50.84 120.68,51.04 120.62,51.23 120.62,51.87 121.05,52.3 121.11,52.39 121.13,52.49 121.13,61.12 121.51,61.12 121.56,61.13 121.6,61.16 121.69,61.25 127.17,61.25
+VCCCORE on IN2 (solid shape): outline of 3525 points within 120.73,33.59 149.95,61.04
+VCCDUSB_1P0 on TOP (solid shape): 113.57,56.04 113.57,55.7 113.36,55.5 113.13,55.5 112.93,55.7 112.27,55.7 112.24,55.73 112.24,56.21 112.3,56.26 113.34,56.26
+VCCFHV on IN2 (solid shape): outline of 476 points within 92.96,61.3 107.86,65.39
+VCCGT on TOP (solid shape): 199.1,44.74 199.1,44.4 199,44.29 198.75,44.29 198.49,44.03 197.76,44.03 197.63,44.17 197.63,44.52 197.71,44.6 198.17,44.6 198.4,44.83 199.01,44.83
+VCCGT on TOP (solid shape): outline of 2301 points within 128.31,40.44 177.47,62.08
+VCCGT on BOTTOM (solid shape): outline of 1274 points within 128.51,48.17 192.35,59.39
+VCCGT on SVCC (solid shape): 137.62,59.72 137.74,59.6 137.89,59.54 138.59,58.84 138.53,58.52 138.67,58.22 138.8,58.09 138.97,57.98 139.16,57.94 164.9,57.94 165.12,57.87 165.34,57.94 165.58,57.94 165.8,57.87 166.02,57.94 166.24,57.94 166.46,57.87 166.68,57.94 166.92,57.94 167.1,57.89 167.28,57.94 167.54,57.94 167.76,57.87 167.98,57.94 168.23,57.94 168.45,57.87 168.67,57.94 168.86,57.94 169.08,57.87 169.3,57.94 169.52,57.94 169.74,57.87 169.96,57.94 170.13,57.94 170.35,57.87 170.57,57.94 170.77,57.94 170.99,57.87 171.21,57.94 174.76,57.94 176.5,56.21 176.5,49.52 172.58,45.6 172.47,45.44 172.43,45.24 172.43,38.22 171.33,37.12 148.01,37.12 147.27,37.86 147.1,37.97 146.9,38.01 140.13,38.01 133.44,44.69 133.44,47.78 133.43,47.91 133.38,48.04 133.39,48.51 132.92,48.52 132.57,48.87 132.47,49.07 132.27,49.17 130.76,50.68 130.53,50.82 130.26,50.82 129.89,51.19 129.89,55.18 130.23,55.54 129.89,55.89 129.89,59.72
+VCCGT on IN2 (solid shape): outline of 2549 points within 129.63,47.66 174.85,60.92
+VCCMPHYGTAON_1P0 on TOP (solid shape): outline of 1936 points within 90.9,46.6 113.8,53.65
+VCCMPHYGTAON_1P0 on BOTTOM (solid shape): 112.62,53.55 112.73,53.55 112.77,53.51 112.83,53.48 112.91,53.38 112.91,53.37 112.97,53.18 113.11,53.05 113.13,53.03 113.13,52.81 112.61,52.28 112.54,52.25 112.47,52.28 112.24,52.33 112.05,52.2 112.04,52.17 111.9,52.17 111.89,52.2 111.76,52.31 111.59,52.33 111.56,52.33 111.36,52.53 111.36,53.75 111.56,53.95 112.22,53.95
+VCCPAZIO on TOP (solid shape): 114.61,71.72 114.61,70.28 114.87,70.02 114.87,68.71 115.3,68.27 115.3,66.39 115.45,66.24 115.45,65.81 115.45,65.78 115.43,65.57 115.53,65.39 115.56,65.32 115.53,65.24 115.42,64.99 115.52,64.74 115.55,64.67 115.42,64.36 115.55,64.04 115.42,63.72 115.55,63.4 115.42,63.09 115.55,62.77 115.42,62.45 115.55,62.13 115.52,62.06 115.43,61.78 115.62,61.45 115.59,61.37 115.4,61.19 115.37,61.18 115.03,61.16 114.87,60.86 114.84,60.79 114.77,60.76 114.37,60.76 114.34,60.77 114.32,60.81 114.32,60.99 114.79,61.45 114.8,61.46 114.83,61.46 115.18,61.66 115.12,62.06 115.12,62.2 115.22,62.45 115.12,62.7 115.1,62.73 115.09,62.78 115.09,63.39 115.1,63.44 115.12,63.47 115.22,63.72 115.09,64.04 115.22,64.36 115.09,64.67 115.12,64.74 115.21,65.06 115.01,65.32 114.99,65.32 114.96,65.37 114.96,67.97 114.37,68.56 114.37,69.63 114.01,69.99 114.01,71.79 114.06,71.84 114.5,71.84
+VCCPDSW_3P3 on TOP (solid shape): outline of 446 points within 103.85,60.66 113.78,73.06
+VCCPGPPC on IN2 (solid shape): outline of 140 points within 109.57,55.48 112.84,57.11
+VCCPGPPF on IN2 (solid shape): 106.21,59.39 106.23,59.38 106.25,59.36 106.5,59.16 106.8,59.26 106.88,59.29 106.95,59.26 107.26,59.16 107.5,59.36 107.52,59.38 107.55,59.39 108.13,59.39 108.16,59.39 108.18,59.37 108.45,59.18 108.76,59.3 108.83,59.33 108.91,59.3 109.18,59.18 109.45,59.31 109.53,59.35 109.61,59.31 109.92,59.18 110.2,59.37 110.22,59.39 110.25,59.39 111.68,59.39 112.21,58.86 112.21,58.2 112.08,58.07 111.85,58.07 111.7,58.22 111.7,58.55 111.47,58.78 109.99,58.78 109.76,58.87 109.53,58.78 109.35,58.78 109.15,58.85 108.95,58.78 108.7,58.78 108.47,58.87 108.23,58.78 107.95,58.78 107.86,58.8 107.76,58.78 107.46,58.78 107.22,58.87 106.98,58.78 106.77,58.78 106.54,58.85 106.33,58.75 106.32,58.74 106.3,58.73 105.58,58.73 105.48,58.83 105.48,59.29 105.58,59.39
+VCCPGPPG on IN2 (solid shape): 111.57,58.5 111.57,58.15 111.49,58.06 110.22,58.06 109.77,57.61 109.44,57.61 109.42,57.62 109.41,57.63 109.16,57.74 108.91,57.63 108.89,57.62 108.87,57.61 108.82,57.61 108.8,57.62 108.78,57.63 108.53,57.75 108.28,57.63 108.26,57.62 108.24,57.61 108.19,57.61 108.17,57.62 108.15,57.63 107.9,57.75 107.64,57.63 107.63,57.62 107.6,57.61 107.58,57.61 107.55,57.63 107.31,57.74 107.06,57.63 107.04,57.62 107.02,57.61 106.97,57.61 106.94,57.63 106.7,57.74 106.45,57.63 106.43,57.62 106.41,57.61 105.94,57.61 105.78,57.77 105.78,58.1 105.99,58.3 106.3,58.3 106.32,58.3 106.34,58.29 106.57,58.19 106.81,58.29 106.82,58.3 106.84,58.3 106.91,58.3 106.94,58.3 106.95,58.28 107.22,58.16 107.49,58.28 107.51,58.3 107.53,58.3 107.55,58.3 107.58,58.29 107.58,58.28 107.83,58.14 108.1,58.24 108.16,58.27 108.23,58.25 108.49,58.16 108.73,58.28 108.75,58.3 108.77,58.3 108.88,58.3 108.9,58.3 108.92,58.29 109.15,58.19 109.39,58.29 109.4,58.3 109.42,58.3 109.54,58.3 109.9,58.24 110.09,58.55 110.12,58.63 110.19,58.66 111.42,58.66
+VCCPRIM_1P0 on TOP (solid shape): outline of 1594 points within 91.41,57.28 115.29,61.65
+VCCPRIM_1P0 on IN2 (solid shape): outline of 196 points within 112.6,53.92 115.21,57.76
+VCCPRIM_3P3 on TOP (solid shape): 115.82,71.33 115.82,70.15 115.45,69.79 115.45,68.88 115.85,68.47 115.85,66.54 116.44,65.96 116.45,65.92 116.34,65.64 116.45,65.39 116.47,65.32 116.45,65.24 116.34,64.99 116.44,64.74 116.47,64.67 116.34,64.36 116.47,64.04 116.34,63.72 116.47,63.4 116.44,63.33 116.34,63.12 116.4,62.89 116.41,62.82 116.38,62.76 116.25,62.46 116.41,62.08 116.38,62.01 116.32,61.94 116.28,61.86 116.3,61.6 116.49,61.41 116.5,61.41 116.52,61.38 116.52,61.32 116.39,61.18 116.28,61 116.27,60.8 116.27,60.79 116.27,60.08 115.97,59.77 115.74,59.77 115.69,59.82 115.68,59.82 115.63,59.87 115.63,61.13 115.87,61.36 115.87,61.43 115.88,61.46 115.9,61.48 116.13,61.74 116.04,62.06 116.01,62.13 116.14,62.45 116.01,62.77 116.14,63.09 116.01,63.4 116.14,63.72 116.01,64.04 116.14,64.36 116.01,64.67 116.04,64.74 116.14,64.99 116.03,65.24 116,65.32 116.03,65.39 116.13,65.71 115.91,65.97 115.9,65.98 115.87,66.01 115.45,66.44 115.45,68.32 115.1,68.67 115.1,71.22 115.28,71.41 115.74,71.41
+VCCPRIM_CORE on TOP (solid shape): 116.87,56.11 116.87,54.9 116.72,54.74 115.8,54.74 115.65,54.89 115.65,56.06 115.8,56.21 116.77,56.21
+VCCPRIM_CORE on TOP (solid shape): 95.25,53.77 95.34,53.72 95.35,53.63 95.35,53.43 95.45,53.26 95.47,53.24 95.47,53.22 95.47,52.66 95.22,52.4 94.64,52.4 94.41,52.17 94.35,52.17 93.96,51.77 92.32,51.77 92.25,51.85 92.25,52.53 92.42,52.71 93.21,52.71 93.31,52.82 93.34,52.83 93.36,52.83 93.72,52.92 93.81,53.27 93.81,53.3 93.82,53.32 94.26,53.77
+VCCPRIM_CORE on BOTTOM (solid shape): 116.66,55.5 116.66,54.94 116.51,54.79 115.78,54.79 115.67,54.89 115.39,54.89 115.09,55.2 114.89,55.2 114.78,55.3 114.78,55.5 114.86,55.58 115.79,55.58 116.11,55.9 116.26,55.9
+VCCPRIM_CORE on SVCC (solid shape): 115.65,56.42 115.87,56.34 116.09,56.42 117.06,56.42 117.06,54.37 116.12,53.43 116.06,53.34 116.04,53.24 116.04,50.68 115.89,50.53 115.6,50.43 115.5,50.14 115.41,50.05 115.15,50.05 114.92,49.92 108.6,43.59 104.18,43.59 103.83,43.92 103.47,43.59 102.4,43.59 102.11,43.75 101.82,43.59 96.32,43.59 93.69,46.22 93.69,48.16 93.95,48.5 93.69,48.84 93.69,52.9 93.82,53.12 93.76,53.36 94.92,54.52 105,54.52 105.25,54.58 105.44,54.77 111.11,54.77 111.36,54.66 111.6,54.77 111.71,54.77 111.97,54.66 112.22,54.8 112.28,54.84 112.33,54.9 112.62,54.9 112.67,54.91 112.71,54.94 113.27,55.5 113.5,55.6 113.6,55.83 114.19,56.42
+VCCPRIM_CORE on IN2 (solid shape): outline of 261 points within 113.75,54.64 117.17,59.95
+VCCPRTC_3P3 on TOP (solid shape): 112.98,70.77 112.98,69.34 113.6,68.72 113.76,68.62 113.96,68.6 113.98,68.59 114.76,67.81 114.76,65.37 114.73,65.32 114.72,65.31 114.52,65.06 114.61,64.74 114.64,64.67 114.51,64.36 114.64,64.04 114.51,63.72 114.61,63.47 114.63,63.43 114.64,63.38 114.64,62.79 114.63,62.74 114.61,62.7 114.54,62.31 114.87,62.09 114.89,62.09 114.91,62.08 114.92,62.08 115.04,61.95 115.04,61.75 114.91,61.62 114.67,61.62 114.65,61.62 114.4,61.62 114.32,61.66 114.3,61.74 114.29,61.91 114.21,62.06 114.18,62.13 114.31,62.45 114.18,62.77 114.31,63.09 114.18,63.4 114.31,63.72 114.18,64.04 114.31,64.36 114.18,64.67 114.31,64.99 114.18,65.31 114.21,65.38 114.3,65.68 114.12,65.94 114.08,65.97 114.08,66.48 114.11,66.52 114.12,66.53 114.28,66.83 114.12,67.12 114.11,67.13 114.08,67.17 114.08,67.19 112.63,68.65 112.6,68.65 112.08,69.17 111.09,69.17 110.33,69.93 110.33,71.03 110.46,71.15 112.6,71.15
+VCCPRTCPRIM_3P3 on TOP (solid shape): outline of 412 points within 100.1,61.29 112.35,74.19
+VCCSA on TOP (solid shape): 193.56,31.93 193.56,31.57 193.94,31.2 193.94,31.2 194.12,31.01 194.12,30.71 193.95,30.53 193.73,30.53 193.59,30.67 193.59,30.79 193,31.38 193,31.93 193.08,32.01 193.48,32.01
+VCCSA on TOP (solid shape): outline of 508 points within 114.39,34.48 120.56,60.71
+VCCSA on BOTTOM (solid shape): 118.59,61.09 118.59,60.07 118.29,59.77 117.07,59.77 116.92,59.92 116.92,60.58 116.97,60.63 116.97,60.65 116.98,60.66 117.03,60.75 117.05,60.84 117.15,60.82 117.25,60.84 117.61,60.52 117.96,60.84 118.27,60.91 118.32,61.22 118.34,61.24 118.44,61.24
+VCCSA on BOTTOM (solid shape): outline of 122 points within 115.81,22.77 149.98,39.61
+VCCSA on BOTTOM (solid shape): outline of 425 points within 116.7,49.28 120.91,51.89
+VCCSA on SVCC (solid shape): 119.13,61.16 119.17,61.13 119.22,61.12 120.62,61.12 120.62,52.59 120.18,52.16 120.13,52.07 120.11,51.97 120.11,51.26 120.02,51.04 120.11,50.81 120.11,46.57 119.92,46.39 119.85,46.13 119.85,43.17 118.99,42.3 118.88,42.14 118.84,41.94 118.84,33.77 118.5,33.43 116.17,33.43 115.95,33.51 115.73,33.43 115.36,33.43 115.14,33.51 114.92,33.43 110.6,33.43 110.26,33.68 109.92,33.43 109.52,33.43 109.31,33.64 109.31,42.88 111.12,44.68 111.43,44.77 111.52,45.08 115.64,49.2 115.77,49.43 115.77,49.69 115.99,49.91 116.06,49.97 116.12,50.04 116.48,50.4 116.54,50.48 116.55,50.58 116.55,50.77 116.88,51.1 116.55,51.43 116.55,53.13 116.95,53.19 117,53.59 117.49,54.08 117.55,54.17 117.57,54.27 117.57,59.21 117.55,59.31 117.49,59.39 116.55,60.34 116.55,61.37 118.91,61.37
+VCCSA on IN2 (solid shape): outline of 211 points within 116.92,50.79 120.58,60.42
+VCCSRAM_1P0 on TOP (solid shape): outline of 937 points within 101.41,52.35 115.75,58.52
+VDDQ_MEM on TOP (solid shape): outline of 12581 points within 79.47,66.02 174.4,95.49
+VDDQ_MEM on BOTTOM (solid shape): 81.55,94.24 81.55,92.29 80.59,91.32 67.71,91.32 66.54,92.49 66.54,94.98 66.92,95.36 80.43,95.36
+VDDQ_MEM_SOC on TOP (solid shape): outline of 964 points within 116.06,61.49 132.75,77.31
+VDDQ_MEM_SOC on BOTTOM (solid shape): 130.38,70.64 130.38,70.18 130.23,70.03 130.23,69.57 130.13,69.47 130.13,68.91 129.97,68.76 129.87,68.76 129.72,68.91 129.72,69.17 129.82,69.27 129.82,70.64 129.87,70.69 130.33,70.69
+VDDQ_MEM_SOC on BOTTOM (solid shape): 103.24,87 103.24,85.99 103.07,85.81 102.58,85.81 102.46,85.68 102.46,85.38 101.95,84.87 101.39,84.87 101.26,85 101.26,86.5 101.28,86.54 101.31,86.55 102.08,86.55 102.08,86.75 101.31,86.75 101.28,86.76 101.26,86.8 101.26,86.85 101.36,86.95 102.1,86.95 102.3,87.16 103.09,87.16
GND on TOP (solid shape): 36.95,52.38 36.95,46.79 36.9,46.74 31.36,46.74 31.31,46.79 31.31,52.38 31.36,52.43 36.9,52.43
GND on TOP (solid shape): 46.32,29.29 46.32,28.33 46.19,28.2 45.1,28.2 44.49,28.81 44.49,29.57 44.57,29.65 45.97,29.65
GND on TOP (solid shape): 59.57,83.47 59.57,79.7 59.4,79.54 58.76,79.54 58.63,79.66 58.63,83.53 58.73,83.62 59.42,83.62
GND on TOP (solid shape): 59.65,84.83 59.65,84.65 59.47,84.47 56.46,84.47 56.34,84.58 56.34,84.93 56.64,85.24 59.25,85.24
GND on TOP (solid shape): 60.75,59.57 60.75,55.99 60.7,55.94 57.12,55.94 57.09,55.96 57.09,59.57 57.14,59.62 60.7,59.62
GND on TOP (solid shape): 64.87,23.43 64.87,22.28 64.31,21.72 63.75,21.72 63.55,21.92 63.55,23.91 63.63,23.99 64.31,23.99
GND on TOP (solid shape): 107.14,78.9 107.14,77.2 107.08,77.14 103.84,77.14 103.76,77.22 103.76,78.88 103.85,78.97 107.07,78.97
GND on TOP (solid shape): 122.86,60.12 122.86,59.11 122.4,58.65 122.2,58.65 122,58.85 122,60.12 122.02,60.15 122.83,60.15
GND on TOP (solid shape): 132.81,41.38 132.81,39.68 132.48,39.35 131.67,39.35 131.51,39.5 131.51,41.36 131.67,41.51 132.68,41.51
GND on TOP (solid shape): 175.61,89.87 175.61,87.89 175.23,87.51 174.31,87.51 173.98,87.84 173.98,89.92 174.21,90.15 175.33,90.15
GND on TOP (solid shape): 178.2,82.53 178.2,81.01 178.02,80.83 177.06,80.83 176.83,81.06 176.83,82.48 177.08,82.74 178,82.74
GND on TOP (solid shape): 194.73,13.98 194.73,11.31 194.66,11.23 194.23,11.23 193.41,12.05 193.41,14.05 193.51,14.16 194.56,14.16
GND on TOP (solid shape): 194.94,22.28 194.94,19.26 194.81,19.13 193.46,19.13 193.34,19.26 193.34,21.6 194.15,22.41 194.81,22.41
GND on TOP (solid shape): 197.78,38.79 197.78,35.31 197.73,35.26 194.25,35.26 194.23,35.29 194.23,38.79 194.28,38.84 197.73,38.84
GND on TOP (solid shape): 205.99,16.72 205.99,15.27 205.83,15.12 204.39,15.12 204.31,15.2 204.31,16.7 204.41,16.8 205.91,16.8
GND on TOP (solid shape): 84.55,63.16 84.55,62.22 84.14,61.82 83.47,61.82 82.97,62.31 82.09,62.31 82.01,62.39 82.01,63.13 82.28,63.39 84.32,63.39
GND on TOP (solid shape): 102.7,73.27 102.7,71.09 102.59,70.98 101.57,70.98 101.49,71.05 101.49,72.45 101.94,72.89 101.94,73.35 102.09,73.51 102.47,73.51
GND on TOP (solid shape): 127.89,63.83 127.89,63.31 127.42,62.85 126.64,62.85 126.51,62.97 126.51,63.23 126.61,63.33 126.88,63.33 127.48,63.93 127.79,63.93
GND on TOP (solid shape): 134.88,91.11 134.88,88.52 134.72,88.37 133.89,88.37 133.76,88.5 133.76,90.33 133.91,90.48 133.91,90.6 134.55,91.24 134.75,91.24
GND on TOP (solid shape): 17.87,30.18 17.87,29.78 18.13,29.52 18.71,29.52 18.81,29.42 18.81,28.96 18.66,28.81 16.12,28.81 15.74,29.19 15.74,30.08 15.94,30.28 17.77,30.28
GND on TOP (solid shape): 23.08,64.68 23.08,59.72 23.41,59.39 23.41,58.99 23.26,58.83 20.9,58.83 20.79,58.94 20.79,64.8 20.89,64.9 22.08,64.9 22.13,64.94 22.81,64.94
GND on TOP (solid shape): 53.05,18.7 53.05,16.99 54.06,15.99 54.84,15.99 55.22,15.6 55.22,14.85 54.64,14.27 51.75,14.27 51.08,14.94 51.08,18.51 51.53,18.96 52.8,18.96
GND on TOP (solid shape): 122.33,53.18 122.33,52.17 122.26,52.09 121.42,52.09 121.39,52.12 121.39,52.83 121.45,52.88 121.64,52.88 121.8,53.03 121.8,53.27 121.9,53.37 122.15,53.37
GND on TOP (solid shape): 125.85,53.22 125.85,53.04 125.93,52.97 126.16,52.97 126.37,52.76 126.37,52.5 126.32,52.45 125.17,52.45 125.06,52.56 125.06,52.97 125.41,53.32 125.75,53.32
GND on TOP (solid shape): 127.27,71.61 127.27,70.65 127.37,70.54 127.81,70.54 127.86,70.49 127.86,70.09 127.75,69.98 127.17,69.98 126.92,70.24 126.92,71.61 126.97,71.66 127.22,71.66
GND on TOP (solid shape): 127.27,40.77 127.27,39.05 126.74,38.51 125.37,38.51 125.33,38.53 125.32,38.56 125.32,40.93 125.44,41.05 126.99,41.05
GND on TOP (solid shape): 141.53,55.18 141.53,54.17 141.51,54.15 141.12,54.15 141.09,54.19 141.09,54.9 140.95,55.04 140.49,55.04 140.44,55.1 140.44,55.3 140.49,55.35 141.35,55.35
GND on TOP (solid shape): 29.57,33.04 29.62,32.98 29.68,32.93 30.07,32.55 30.07,30.46 29.68,30.08 28.01,30.08 27.27,30.82 27.27,33.31 27.65,33.69 28.92,33.69
GND on TOP (solid shape): 123.16,74.25 123.16,70.91 123.13,70.88 123.13,69.55 122.95,69.38 122.42,69.38 122.19,69.6 122.19,74.2 122.34,74.35 123.06,74.35
GND on TOP (solid shape): 125.86,59.44 125.86,59.06 125.28,58.48 125.23,58.43 124.63,58.43 124.6,58.45 124.6,58.84 124.65,58.88 124.65,59.46 124.68,59.49 125.8,59.49
GND on TOP (solid shape): 27.42,55 27.42,53.82 26.83,53.22 26.39,53.22 26.29,53.12 25.87,53.12 25.77,53.22 25.77,53.68 25.85,53.75 26.46,53.75 26.54,53.83 26.54,55 26.61,55.07 27.35,55.07
GND on TOP (solid shape): 72.57,70.21 72.57,67.19 72.55,67.17 72.55,66.78 72.39,66.61 71.19,66.61 70.97,66.84 70.97,69.86 71.42,70.31 72.46,70.31
GND on TOP (solid shape): 126.1,36.19 126.1,35.8 125.4,35.09 125.4,34.4 125.24,34.24 123.69,34.24 122.98,33.54 122.47,33.54 121.85,34.16 121.85,36.92 121.96,37.04 125.25,37.04
GND on TOP (solid shape): 139.52,55.25 139.52,54.99 139.42,54.89 138.68,54.89 138.63,54.85 138.63,54.85 138.44,54.66 138.44,54.05 138.42,54.03 138.14,54.03 138.14,55.33 138.19,55.38 139.39,55.38
GND on TOP (solid shape): 148.36,87.84 148.36,86.36 148.24,86.24 147.37,86.24 147.25,86.36 147.25,86.64 147.04,86.85 146.59,86.85 146.53,86.9 146.53,87.39 146.65,87.51 147.53,87.51 147.93,87.91 148.29,87.91
GND on TOP (solid shape): 154.18,84.33 154.18,83.92 154.05,83.8 153.85,83.8 153.52,83.47 153.52,82.48 153.42,82.37 153.21,82.37 153.06,82.53 153.06,83.49 153.7,84.13 153.7,84.31 153.82,84.43 154.08,84.43
GND on TOP (solid shape): 163.96,69.88 163.96,69.67 164.21,69.42 165.18,69.42 165.28,69.32 165.28,69.07 165.23,69.01 164.87,69.01 164.72,68.86 164.21,68.86 163.45,69.62 163.45,69.88 163.6,70.03 163.81,70.03
GND on TOP (solid shape): 214.56,29.55 214.59,29.53 214.61,29.5 214.61,28.85 214.5,28.74 213.1,28.74 212.97,28.86 212.97,29.27 213.07,29.37 213.96,29.37 214.14,29.55
GND on TOP (solid shape): 34.71,17.76 34.71,16.04 34.87,15.88 34.87,15.46 34.77,15.37 33.83,15.37 33.42,15.78 33.42,17.13 33.39,17.16 33.39,17.96 33.6,18.17 34.31,18.17
GND on TOP (solid shape): 124.07,62.06 124.07,61.27 124.02,61.22 123.51,61.22 123.37,61.08 123.37,60.78 123.22,60.63 123.01,60.63 122.86,60.78 122.86,61.96 123,62.1 124.03,62.1
GND on TOP (solid shape): 161.94,57.92 161.94,55.86 161.79,55.71 157.73,55.71 157.32,55.3 152.93,55.3 152.85,55.38 152.85,56.95 152.95,57.06 157.42,57.06 157.9,57.54 159.25,57.54 159.76,58.05 161.82,58.05
GND on TOP (solid shape): 164.62,76.13 164.62,75.16 164.72,75.06 164.72,74.5 164.19,73.97 163.34,73.97 163.26,74.05 163.26,75.17 162.77,75.66 162.77,76.22 162.83,76.28 162.94,76.28 164.47,76.28
GND on TOP (solid shape): 79.88,96.87 79.91,96.85 79.93,96.82 79.93,95.89 79.67,95.64 66.92,95.64 66.62,95.33 66.62,95.08 66.5,94.96 66.05,94.96 65.65,95.36 65.65,96.63 65.89,96.87
GND on TOP (solid shape): 106.3,89.64 106.91,89.64 107.06,89.49 107.06,88.52 106.91,88.37 106.1,88.37 105.89,88.57 105.89,89.59 105.69,89.79 105.29,89.79 105.23,89.74 104.68,89.74 104.62,89.79 104.62,90.3 104.68,90.35 105.59,90.35
GND on TOP (solid shape): 116.8,50.63 116.8,50.23 117.02,50.01 117.02,49.51 116.82,49.3 116.61,49.3 116.46,49.46 116.46,49.71 116.47,49.72 116.47,49.89 116.25,50.11 116.25,50.32 116.07,50.5 116.07,50.72 116.1,50.75 116.68,50.75
GND on TOP (solid shape): 121.08,41.43 121.12,41.38 121.12,34.5 122.32,33.31 123.21,33.31 123.79,33.89 125.42,33.89 125.52,33.79 125.52,30.54 125.44,30.46 121.78,30.46 119.12,33.13 119.12,41.18 119.37,41.44 121.05,41.44
GND on TOP (solid shape): 125.78,90.02 125.78,88.52 125.68,88.42 125.68,87.91 125.66,87.89 125.4,87.89 125.38,87.91 125.38,88.27 125.27,88.37 124.82,88.37 124.67,88.52 124.67,89.51 124.82,89.66 125.02,89.66 125.43,90.07 125.73,90.07
GND on TOP (solid shape): 132.89,83.22 132.89,82.66 132.45,82.22 131.85,82.22 131.75,82.32 131.29,82.32 131.24,82.37 131.24,82.6 131.27,82.63 131.65,82.63 131.8,82.78 132.16,82.78 132.41,83.04 132.41,83.24 132.56,83.39 132.72,83.39
GND on TOP (solid shape): 136.44,50.52 136.44,50.31 136.59,50.17 136.98,50.17 137.04,50.12 137.04,49.41 136.93,49.3 136.68,49.3 136.63,49.35 136.63,49.72 136.39,49.96 135.87,49.96 135.8,50.04 135.8,50.6 135.82,50.62 136.34,50.62
GND on TOP (solid shape): 142.13,57.06 142.13,56.92 142.38,56.67 142.76,56.67 142.79,56.64 142.79,56.14 142.77,56.11 142.27,56.11 142.22,56.16 142.22,56.29 141.97,56.54 141.84,56.54 141.61,56.77 141.61,57.09 141.72,57.2 141.99,57.2
GND on TOP (solid shape): 147.75,89.82 147.75,89.54 147.98,89.31 148.85,89.31 149.02,89.13 149.02,88.83 148.85,88.65 148.01,88.65 147.88,88.78 147.88,88.93 147.45,89.36 146.56,89.36 146.53,89.38 146.53,89.93 146.57,89.97 147.6,89.97
GND on TOP (solid shape): 178.4,24.59 178.4,23.02 178.38,22.99 174.26,22.99 174.11,23.15 174.11,23.88 174.21,23.99 175.51,23.99 175.58,24.06 175.58,24.22 175.58,24.22 175.58,24.73 175.58,24.73 175.58,24.87 175.84,25.13 177.87,25.13
GND on TOP (solid shape): 82.64,78.39 82.64,76.98 82.08,76.42 81.77,76.11 80.97,76.11 80.71,76.36 80.22,76.36 80.22,76.36 79.98,76.36 79.79,76.56 79.79,77.82 80.38,78.42 80.38,79.08 80.59,79.28 81.75,79.28
GND on TOP (solid shape): 132.95,50.25 133.38,50.25 133.39,50.24 133.7,50.24 133.75,50.2 133.75,49.78 133.28,49.3 133.02,49.3 132.92,49.41 132.92,49.78 132.79,49.91 132.22,49.91 132.15,49.98 132.15,50.47 132.21,50.52 132.68,50.52
GND on TOP (solid shape): 105.06,83.67 105.08,83.65 105.11,83.62 105.14,83.59 105.14,83.48 105.28,83.35 105.92,83.35 105.94,83.37 106.28,83.37 106.4,83.24 106.4,83.04 106.25,82.88 105.23,82.88 104.68,83.44 104.68,83.64 104.78,83.75 104.98,83.75
GND on TOP (solid shape): 120.63,51.16 120.63,50.83 120.74,50.71 120.74,49.94 120.62,49.82 120.62,48.93 120.57,48.88 120.41,48.88 120.32,48.97 120.32,49.46 119.91,49.88 119.91,51 120.17,51.26 120.53,51.26
GND on TOP (solid shape): 122.25,51.23 122.46,51.03 122.46,50.88 122.18,50.61 122.18,49.91 122.44,49.65 122.44,49.48 122.28,49.32 122.05,49.32 121.9,49.48 121.9,49.63 121.6,49.93 121.6,50.49 121.61,50.49 121.95,50.83 121.95,51.69 122,51.74 122.25,51.74
GND on TOP (solid shape): 125.77,72.83 125.77,69.07 125.51,68.81 124.89,68.81 124.74,68.96 124.74,69.22 124.91,69.39 124.91,69.4 125.03,69.51 125.03,71.85 125.1,71.93 125.11,71.93 125.11,72.85 125.19,72.93 125.67,72.93
GND on TOP (solid shape): 155.73,80.93 155.73,80.72 155.6,80.6 155.4,80.6 155.25,80.75 155.25,80.86 155.12,80.98 154.65,80.98 154.55,80.88 154.55,80.53 154.07,80.04 153.71,80.04 153.64,80.12 153.64,80.68 154.24,81.28 155.37,81.28
GND on TOP (solid shape): 33.47,25.08 33.47,24.19 33.32,24.04 32.68,24.04 32.53,23.88 32.38,23.88 32.2,24.06 32.2,24.33 32.25,24.52 32.2,24.7 32.2,24.82 32.63,25.26 33.29,25.26
GND on TOP (solid shape): 55.29,73.19 55.29,72.84 55.26,72.79 55.2,72.8 55.2,72.8 54.55,72.8 54.36,72.61 54.36,72.31 54.26,72.22 53.66,72.22 53.54,72.35 53.54,73.24 53.76,73.46 55.01,73.46
GND on TOP (solid shape): 101.31,35.29 101.31,35.22 102.07,35.22 102.11,35.21 102.13,35.17 102.13,34.58 100.83,33.28 100.53,33.28 100.23,32.99 100.23,32.61 100.04,32.42 99.43,32.42 99.18,32.67 99.18,34.93 99.56,35.31 101.29,35.31
GND on TOP (solid shape): 16.98,14.82 16.98,13.88 17.37,13.5 17.37,11.72 17.24,11.59 15.74,11.59 15.59,11.74 15.59,12.35 15.49,12.45 14.8,12.45 14.67,12.58 14.67,14.28 14.75,14.36 15.77,14.36 16.3,14.89 16.91,14.89
