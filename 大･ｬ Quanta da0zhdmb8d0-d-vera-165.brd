# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CKE<1>: length 50.7
  IN1 w0.097: v3(169.55,76.84) 169.55,76.83 169.16,76.43 168.52,76.43 168.36,76.28 168.36,74.98 168.2,74.82 159.61,74.82 158.56,73.77 154.79,73.77 154.7,73.68 154.7,73.01 154.6,72.92 150.91,72.92 150.81,72.82 150.81,72.63 150.91,72.53 154.6,72.53 154.7,72.44 154.7,72.19 154.6,72.1 148.78,72.1 148.29,71.61 148.29,70.46 147.93,70.09 139.78,70.09 v3(137.65,72.21)
  BOTTOM w0.076: U80.BB56 135.43,68.62 135.49,68.68 135.49,69.45 137.09,71.05 137.09,71.81 137.49,72.21 v3(137.65,72.21)
  BOTTOM w0.132: USM2000.K4 169.55,76.83 v3(169.55,76.84)
M_A_CKE<2>: length 51
  IN2 w0.097: v3(144.35,89.99) 144.35,89.21 144.48,89.08 144.48,88.78 144.57,88.68 145.12,88.68 145.22,88.58 145.22,88.39 145.12,88.29 144.57,88.29 144.48,88.2 144.48,88 144.57,87.91 145.12,87.91 145.22,87.81 145.22,87.62 145.12,87.52 144.57,87.52 144.48,87.42 144.48,87.23 144.57,87.13 145.12,87.13 145.22,87.04 145.22,86.85 145.12,86.75 144.57,86.75 144.48,86.65 144.48,86.46 144.57,86.36 145.12,86.36 145.22,86.27 145.22,86.07 145.12,85.98 144.57,85.98 144.48,85.88 144.48,85.69 144.57,85.59 145.12,85.59 145.22,85.49 145.22,85.3 145.12,85.2 144.57,85.2 144.48,85.11 144.48,84.91 144.57,84.82 145.12,84.82 145.22,84.72 145.22,84.53 145.12,84.43 144.57,84.43 144.48,84.34 144.48,84.14 144.57,84.05 145.12,84.05 145.22,83.95 145.22,83.76 145.12,83.66 144.57,83.66 144.48,83.56 144.48,78.69 v3(142.6,76.81)
  BOTTOM w0.076: U80.AW56 135.22,66.67 135.22,66.88 135.17,66.93 135.17,67.23 135.2,67.29 135.2,67.3 135.2,67.47 135.17,67.55 135.17,67.87 135.22,67.98 135.22,68.19 135.17,68.31 135.17,68.61 135.32,68.76 135.32,69.66 136.89,71.23 136.89,71.99 137.52,72.62 137.98,72.62 138.18,72.82 138.18,72.84 138.38,73.05 138.71,73.05 140.03,74.37 140.03,74.49 140.29,74.74 140.32,74.74 140.54,74.96 140.54,75 140.72,75.17 140.76,75.17 140.98,75.39 140.98,75.69 140.97,75.7 140.97,75.78
  BOTTOM w0.114: 140.97,75.78 140.8,75.95
  BOTTOM w0.132: v3(144.35,89.99) 144.02,89.99 143.84,90.17 143.84,90.4 v1(144.33,90.89) 144.35,90.91 153.34,90.91 153.5,90.76 153.5,89.98 153.3,89.78 153.3,88.86 USM2001.K3 ; v3(142.6,76.81) 141.34,76.81 140.8,76.27 140.8,75.95
M_A_CKE<3>: length 50.3
  IN2 w0.097: v3(142.09,76.2) 141.76,75.87 141.76,75.57 141.86,75.47 141.99,75.47 144.91,78.39 144.91,82.83 146.28,84.2 146.28,84.58 146.44,84.74 148.17,84.74 148.27,84.83 148.27,85.38 148.44,85.55 149.68,85.55 149.78,85.65 149.78,85.87 149.68,85.96 147.84,85.96 147.69,85.81 147.69,85.24 147.59,85.14 145.65,85.14 145.51,85.28 145.51,89.99 145.43,90.07 144.91,90.07 144.81,89.97 v3(144.81,89.54)
  BOTTOM w0.076: v3(142.09,76.2) 141.63,75.75 141.63,75.44 139.41,73.21 139.41,72.74 135.98,69.32 135.98,68.54 135.85,68.23 135.85,68.22 135.7,67.86 135.7,67.58 135.43,67.31 U80.AY56
  BOTTOM w0.132: v3(144.81,89.54) 144.81,90.25 145.09,90.54 151.49,90.54 152,90.03 152,88.28 152.18,88.1 152.62,88.1 USM2001.K4
M_A_CLK_DDR_DN*<0>: length 57.8
  IN2 w0.102: v3(134.07,65.63) 134.47,65.22 134.47,64.85 134.9,64.42 135.1,64.42 135.55,63.97 135.55,62.26 135.91,61.9 138.81,61.9 139.01,62.1 140.13,62.1 140.26,62.23 143.61,62.23 144.06,62.68 144.06,66.3 144.69,66.93 145.27,66.93 145.83,67.5 147.46,67.5 151.97,72.01 151.97,72.85 153.41,74.29 155.57,74.29 156.64,75.36 156.95,75.36 157.94,74.36 158.09,74.36 158.23,74.51 158.23,74.65 157.24,75.65 157.24,75.96 157.5,76.22 157.81,76.22 158.81,75.23 158.95,75.23 159.09,75.37 159.09,75.51 158.1,76.51 158.1,76.82 158.4,77.12 158.72,77.12 158.91,76.93 159.05,76.93 159.2,77.08 159.2,77.22 159,77.41 159,77.72 159.27,77.99 159.58,77.99 159.73,77.83 159.88,77.83 160.02,77.98 160.02,78.12 159.87,78.27 159.87,78.59 160.84,79.56 165.97,79.56 166.41,80 v3(168.51,80)
  BOTTOM w0.147: USM2000.J2 168.94,78.46 168.94,79.58 v3(168.51,80)
  BOTTOM w0.153: U80.AU53 v3(134.07,65.63)
M_A_CLK_DDR_DN*<1>: length 57.8
  IN2 w0.076: v3(152.51,89.8) 152.73,89.8 152.85,89.68 152.85,89.54 152.72,89.42 152.14,89.42 151.95,89.61 151.95,90.08 151.97,90.1
  IN2 w0.102: v3(134.99,65.63) 135.21,65.85 135.21,65.99 135.21,67.31 135.92,68.02 135.92,69.32 136.76,70.16 136.76,72.78 137.72,73.75 137.9,73.75 138.48,74.33 138.48,76.18 139.8,77.49 139.8,78.1 140.98,79.29 142.49,79.29 142.6,79.39 142.6,79.71 142.49,79.82 141.71,79.82 141.4,80.12 141.4,80.5 141.62,80.72 142.47,80.72 142.57,80.82 142.57,81.03 142.47,81.13 141.62,81.13 141.4,81.35 141.4,81.72 141.62,81.94 142.47,81.94 142.57,82.04 142.57,82.24 142.47,82.35 141.62,82.35 141.4,82.57 141.4,82.94 141.62,83.16 142.47,83.16 142.57,83.26 142.57,83.46 142.47,83.57 141.62,83.57 141.4,83.79 141.4,84.16 141.62,84.38 142.47,84.38 142.57,84.48 142.57,84.68 142.47,84.78 141.62,84.78 141.4,85.01 141.4,87.85 141.71,88.16 141.78,88.16 141.88,88.26 141.88,88.48 141.78,88.58 141.69,88.58 141.4,88.87 141.4,89.34 141.62,89.56 141.84,89.56 141.95,89.67 141.95,89.87 141.84,89.97 141.62,89.97 141.4,90.19 141.4,90.56 141.62,90.78 141.84,90.78 141.95,90.88 141.95,91.09 141.84,91.19 141.48,91.19 141.26,91.41 141.26,92 141.48,92.22 142.52,92.22 142.9,91.85 143.13,91.85 143.47,92.19 143.78,92.19 144.12,91.85 144.35,91.85 144.69,92.19 145,92.19 145.34,91.85 145.57,91.85 145.9,92.19 146.22,92.19 146.55,91.86 146.79,91.86 147.12,92.19 147.44,92.19 147.77,91.86 148.01,91.86 148.41,92.26 148.73,92.26 150.33,90.66 151.67,90.66 151.97,90.35 151.97,90.1
  BOTTOM w0.147: USM2001.J2 152.33,89.63 v3(152.51,89.8)
  BOTTOM w0.153: U80.AU55 v3(134.99,65.63)
M_A_CLK_DDR_DP<0>: length 57.8
  IN2 w0.102: v3(134.07,64.99) 134.07,64.98 134.82,64.23 135.03,64.23 135.36,63.89 135.36,62.16 135.81,61.71 137.8,61.71 137.87,61.64 138.22,61.64 138.29,61.71 138.89,61.71 139.09,61.91 140.23,61.91 140.35,62.03 143.7,62.03 144.26,62.59 144.26,66.22 144.77,66.73 145.35,66.73 145.92,67.3 147.55,67.3 152.18,71.93 152.18,72.77 153.5,74.09 155.66,74.09 156.72,75.15 156.87,75.15 157.86,74.16 158.17,74.16 158.44,74.42 158.44,74.74 157.44,75.73 157.44,75.87 157.58,76.02 157.73,76.02 158.72,75.02 159.03,75.02 159.3,75.29 159.3,75.6 158.3,76.59 158.3,76.74 158.49,76.92 158.63,76.92 158.82,76.73 159.14,76.73 159.4,76.99 159.4,77.3 159.21,77.5 159.21,77.64 159.35,77.78 159.49,77.78 159.65,77.63 159.96,77.63 160.22,77.89 160.22,78.21 160.07,78.36 160.07,78.5 160.92,79.35 166.05,79.35 166.5,79.8 167.96,79.8 168.05,79.7 168.05,79.66 168.28,79.43 v3(168.51,79.43)
  BOTTOM w0.147: USM2000.J3 168.58,77.61 168.26,77.93 168.26,78.22 168.51,78.47 v3(168.51,79.43)
  BOTTOM w0.153: U80.AT53 v3(134.07,64.99)
M_A_CLK_DDR_DP<1>: length 57.8
  IN2 w0.076: 151.77,90.1 151.77,90.09 151.77,89.53 152.07,89.24 152.58,89.24 152.65,89.16 v3(152.65,88.88)
  IN2 w0.102: 151.77,90.1 151.77,90.27 151.58,90.45 150.24,90.45 148.64,92.05 148.5,92.05 148.1,91.65 147.68,91.65 147.35,91.98 147.21,91.98 146.88,91.65 146.46,91.65 146.13,91.98 145.99,91.98 145.65,91.65 145.25,91.65 144.91,91.98 144.77,91.98 144.43,91.65 144.03,91.65 143.69,91.98 143.55,91.98 143.21,91.65 142.81,91.65 142.44,92.02 141.57,92.02 141.47,91.92 141.47,91.49 141.57,91.39 141.93,91.39 142.15,91.17 142.15,90.8 141.93,90.58 141.71,90.58 141.61,90.48 141.61,90.27 141.71,90.17 141.93,90.17 142.15,89.95 142.15,89.58 141.93,89.36 141.71,89.36 141.61,89.26 141.61,88.95 141.77,88.79 141.87,88.79 142.09,88.57 142.09,88.18 141.87,87.96 141.8,87.96 141.61,87.77 141.61,85.09 141.71,84.99 142.55,84.99 142.77,84.77 142.77,84.4 142.55,84.18 141.71,84.18 141.61,84.07 141.61,83.87 141.71,83.77 142.55,83.77 142.77,83.55 142.77,83.18 142.55,82.96 141.71,82.96 141.61,82.85 141.61,82.65 141.71,82.55 142.55,82.55 142.77,82.33 142.77,81.96 142.55,81.74 141.71,81.74 141.61,81.64 141.61,81.43 141.71,81.33 142.55,81.33 142.77,81.11 142.77,80.74 142.55,80.52 141.71,80.52 141.61,80.42 141.61,80.21 141.79,80.02 142.58,80.02 142.8,79.8 142.8,79.31 142.58,79.08 141.07,79.08 140,78.02 140,77.41 138.69,76.09 138.69,74.24 137.99,73.54 137.81,73.54 136.96,72.69 136.96,70.07 136.12,69.24 136.12,67.94 135.41,67.23 135.41,65.99 135.41,65.8 135.41,65.8 135.41,65.13 135.27,64.99 v3(134.98,64.99)
  BOTTOM w0.147: USM2001.J3 152.65,88.86 v3(152.65,88.88)
  BOTTOM w0.153: U80.AT55 v3(134.98,64.99)
M_A_CS*<0>: length 80
  IN1 w0.076: v3(129.5,65.63) 128.95,65.08 128.95,62.43 129.62,61.77 133.42,61.77 133.69,62.04 133.69,65.81
  IN1 w0.097: 133.69,65.81 134.16,66.27 134.25,66.27 136.16,68.18 136.16,73.82 137.21,74.88 137.21,77.78 138.85,79.42 146.26,79.42 146.92,78.76 150.44,78.76 150.55,78.87 157.79,78.87 161.09,82.17 161.85,82.17 162.33,82.65 162.33,83.76 162.76,84.19 163.03,84.19 163.25,84.41 v3(163.25,84.9)
  IN2 w0.097: v3(153.95,88.88) 153.95,88.86 154.35,88.47 159.48,88.47 163.04,84.9 v3(163.25,84.9) 163.25,84.88 166.82,81.31 168.66,81.31 168.99,80.97 169.06,80.97 170.2,79.83 v3(170.2,77.64)
  BOTTOM w0.076: U80.AU45 v3(129.5,65.63)
  BOTTOM w0.132: v3(170.2,77.64) 170.2,77.63 USM2000.L3 ; USM2001.L3 153.95,88.86 v3(153.95,88.88)
M_A_CS*<1>: length 79.9
  IN1 w0.076: 134.44,63.5 134.44,62.22 133.74,61.52 129.31,61.52 128.1,62.73 128.1,65.14 v3(128.58,65.63)
  IN1 w0.097: 134.44,63.5 134.44,63.55 134.59,63.71 134.59,65.95 136.44,67.8 136.44,73.65 137.5,74.71 137.5,77.59 138.87,78.96 146.08,78.96 146.57,78.47 150.71,78.47 150.8,78.56 158.04,78.56 161.34,81.87 162.1,81.87 162.79,82.55 v3(162.79,83.58)
  IN2 w0.097: v3(170.18,76.86) 169.81,77.23 169.4,77.23 169.14,77.49 169.14,78.59 169.27,78.72 169.27,80.26 168.55,80.99 165.38,80.99 v3(162.79,83.58) 162.55,83.82 162.55,83.96 158.82,87.69 154.34,87.69 v3(153.95,88.08)
  BOTTOM w0.127: U80.AU43 v3(128.58,65.63)
  BOTTOM w0.132: USM2001.L4 153.95,88.06 v3(153.95,88.08) ; USM2000.L4 170.18,76.8 v3(170.18,76.86)
M_A_DQ<0>: length 39.9
  BOTTOM w0.076: 146.2,61.43 144.5,61.43 144.48,61.46 144.47,61.46 144.34,61.59 144.15,61.59 U80.AL71 ; 170.84,67.93 170.84,68.25 170.82,68.28 170.82,68.58 170.88,68.65 170.88,68.9 171.06,69.08 171.06,69.86 170.94,69.98 170.94,71.47 USM2000.N10
  BOTTOM w0.152: 170.84,67.93 170.89,67.88 170.89,67.25 169.29,65.64 167.4,65.64 166.81,66.23 159.59,66.23 156.23,69.6 152.84,69.6 149.81,66.56 149.81,62.26 148.86,61.31 146.32,61.31 146.2,61.43
M_A_DQ<1>: length 42.5
  BOTTOM w0.076: USM2000.M10 170.53,71.27 170.78,71.03 170.78,69.87 170.9,69.74 170.9,69.23 170.61,68.94 170.61,68.42 170.5,68.31 ; 149.46,62.4 148.68,61.62 147.06,61.62 146.01,62.67 145.09,62.67 145.07,62.69 144.77,62.69 144.75,62.67 144.64,62.67 144.47,62.49 143.98,62.49 143.98,62.49 143.97,62.49 143.97,62.5 143.92,62.5 143.92,62.5 143.91,62.5 143.9,62.51 143.74,62.51 143.73,62.5 143.73,62.5 143.72,62.5 143.67,62.5 143.67,62.49 143.32,62.49 143.32,62.5 143.27,62.5 143.27,62.5 143.02,62.5 143.02,62.5 142.46,62.5 142.2,62.24 U80.AL68
  BOTTOM w0.152: 149.46,62.4 149.46,66.7 152.71,69.95 156.52,69.95 159.89,66.58 166.95,66.58 167.54,65.99 169.15,65.99 170.5,67.33 170.5,68.31
M_A_DQ<2>: length 39.5
  BOTTOM w0.076: 147.96,62.92 147.63,62.59 147.15,62.59 146.37,63.37 144.46,63.37 144.44,63.35 143.94,63.35 143.9,63.31 143.55,63.3 143.41,63.17 143.28,63.17 143.22,63.11 142.67,63.11 142.63,63.07 142.45,63.07 U80.AN68 ; USM2000.M9 170.35,72.51 170.04,72.2 169.59,72.2 169.47,72.08 169.47,71.81 169.48,71.81 169.48,71.61 169.47,71.61 169.47,71.58 169.32,71.43 168.93,71.43 168.83,71.33 168.83,71.04 168.84,71.03 168.84,70.79 168.83,70.78 168.83,69.8 168.27,69.24 168.12,69.24 167.87,68.99
  BOTTOM w0.102: 167.87,68.99 167.85,68.97
  BOTTOM w0.152: 167.85,68.97 166.93,68.05 161.03,68.05 157.76,71.32 152.02,71.32 147.96,67.27 147.96,62.92
M_A_DQ<3>: length 39.7
  BOTTOM w0.076: 149.04,62.48 148.44,61.88 147.03,61.88 146.03,62.88 144.66,62.88 144.64,62.86 144.49,62.86 144.3,62.66 144.29,62.66 144.29,62.66 144.06,62.66 144.06,62.66 144.04,62.66 144.04,62.66 143.99,62.66 143.96,62.69 143.68,62.69 143.65,62.66 143.61,62.66 143.6,62.66 143.39,62.66 143.39,62.66 143.34,62.66 143.33,62.68 143.29,62.68 143.15,62.81 U80.AN69 ; 170.2,68.49 170.27,68.56 170.27,69.15 170.17,69.26 170.17,69.81 170.27,69.91 170.27,69.94 170.28,69.95 170.28,70.39 170.53,70.64 USM2000.M11
  BOTTOM w0.152: 149.04,62.48 149.04,66.89 152.44,70.29 156.85,70.29 160.22,66.92 167.1,66.92 167.69,66.33 168.98,66.33 170.2,67.56 170.2,68.49
M_A_DQ<4>: length 38.1
  BOTTOM w0.076: 146.3,60.97 146.01,61.26 144.35,61.26 144.28,61.33 144.05,61.33 144.04,61.34 143.98,61.34 143.91,61.41 143.68,61.41 U80.AL70 ; USM2000.N11 171.18,70.56 171.44,70.31 171.44,68.71 171.56,68.59 171.56,68.24 171.25,67.93
  BOTTOM w0.152: 146.3,60.97 149.09,60.97 150.52,62.4 150.52,63.45 150.67,63.6 150.98,63.6 151.13,63.45 v1(151.13,63.05) 151.13,62.51 151.32,62.32 155.93,62.32 157.8,64.19 157.8,65.39 158.29,65.89 166.67,65.89 167.26,65.3 169.44,65.3 171.25,67.12 171.25,67.93
M_A_DQ<5>: length 41.1
  BOTTOM w0.076: 145.84,61.03 144.13,61.03 144,61.17 143.98,61.17 143.97,61.18 143.67,61.18 143.67,61.18 143.48,61.18 143.07,61.59 U80.AL69 ; 171.74,67.86 171.74,68.67 171.64,68.77 171.64,69.75 171.59,69.8 171.59,70.37 171.41,70.55 171.41,70.77 171.43,70.79 171.43,71.92 171.76,72.25 171.96,72.25 172.09,72.39 172.09,72.62 171.8,72.91 170.94,72.91 USM2000.M8
  BOTTOM w0.152: 145.84,61.03 146.24,60.63 149.23,60.63 150.59,61.98 156.1,61.98 158.14,64.02 158.14,65.25 158.44,65.55 166.53,65.55 167.12,64.96 169.69,64.96 171.74,67.01 v1(171.74,67.28) 171.74,67.86
M_A_DQ<6>: length 38.6
  BOTTOM w0.076: 148.33,62.79 147.96,62.42 147.05,62.42 146.26,63.21 144.53,63.21 144.5,63.19 144.02,63.19 143.96,63.13 143.71,63.13 U80.AN70 ; 168.24,68.97 169,69.73 169,70 168.99,70.01 168.99,70.21 169,70.21 169,70.8 168.99,70.81 168.99,71.01 169,71.01 169,71.09 169.16,71.25 169.47,71.25 169.65,71.43 169.65,71.6 169.64,71.61 169.64,71.81 169.65,71.82 169.65,71.85 169.76,71.96 170.12,71.96 170.37,72.21 170.9,72.21 171,72.31 171,72.32 USM2000.N9
  BOTTOM w0.152: 148.33,62.79 148.33,67.15 152.16,70.98 157.42,70.98 160.69,67.71 166.97,67.71 168.24,68.97
M_A_DQ<7>: length 40.4
  BOTTOM w0.076: U80.AN71 144.25,63.02 144.57,63.02 144.6,63.04 146.16,63.04 147.06,62.15 148.18,62.15 148.68,62.65 ; 169.86,68.48 170.06,68.67 170.06,69.04 170,69.09 170,69.88 170.13,70 170.13,70.71 170.2,70.79 170.2,71.78 170.45,72.03 171.08,72.03 171.57,72.51 USM2000.P9
  BOTTOM w0.152: 148.68,62.65 148.68,67.02 152.3,70.64 157.17,70.64 160.54,67.26 167.29,67.26 167.88,66.67 168.77,66.67 169.86,67.76 169.86,68.48
M_A_DQ<8>: length 35.5
  IN2 w0.114: v3(147.19,63.59) 148.06,63.59 150.4,61.25 158.02,61.25 160.38,63.61 160.38,63.77 160.17,63.99 160.17,64.15 160.33,64.31 160.49,64.31 160.7,64.1 160.87,64.1 161.03,64.26 161.03,64.42 160.81,64.63 160.81,64.79 160.98,64.96 161.14,64.96 161.35,64.74 161.51,64.74 161.74,64.97 161.74,65.14 161.44,65.44 161.44,65.61 161.6,65.77 161.76,65.77 162.07,65.46 162.23,65.46 162.39,65.62 162.39,65.78 162.08,66.09 162.08,66.25 162.25,66.41 162.41,66.41 162.71,66.11 162.88,66.11 163.04,66.27 163.04,66.43 162.73,66.74 162.73,66.9 162.89,67.06 163.05,67.06 163.36,66.75 163.52,66.75 163.68,66.92 163.68,67.08 163.38,67.38 163.38,67.55 163.54,67.71 163.7,67.71 164.01,67.4 164.17,67.4 164.33,67.56 164.33,67.72 164.02,68.03 164.02,68.19 164.19,68.35 164.35,68.35 164.65,68.05 164.82,68.05 v1(165.33,68.56)
  BOTTOM w0.076: v3(147.19,63.59) 147.08,63.7 144.31,63.7 144.3,63.69 144,63.69 143.98,63.7 143.94,63.7 143.7,63.94 U80.AR70
  BOTTOM w0.152: 165.66,70 165.33,69.67 v1(165.33,68.56)
  BOTTOM w0.153: USM2000.E11 165.66,70.59 165.66,70
M_A_DQ<9>: length 35.8
  IN2 w0.114: v3(147.47,62.96) 149.49,60.94 158.81,60.94 162.15,64.27 162.31,64.27 162.34,64.24 162.5,64.24 162.67,64.4 162.67,64.56 162.63,64.6 162.63,64.76 162.79,64.92 162.95,64.92 163.19,64.69 163.35,64.69 163.51,64.85 163.51,65.01 163.28,65.24 163.28,65.4 163.44,65.57 163.6,65.57 163.83,65.33 164,65.33 164.16,65.49 164.16,65.66 163.92,65.89 163.92,66.05 164.09,66.21 164.25,66.21 164.48,65.98 164.64,65.98 164.8,66.14 164.8,66.3 164.57,66.54 164.57,66.7 164.73,66.86 164.89,66.86 165.13,66.63 165.29,66.63 165.45,66.79 165.45,66.95 165.22,67.18 165.22,67.34 165.38,67.51 165.54,67.51 165.77,67.27 165.94,67.27 166.1,67.43 166.1,67.6 165.86,67.83 165.86,67.99 v3(166.45,68.57)
  BOTTOM w0.076: 166.26,69.9 166.26,70.54 166.31,70.59 ; v3(147.47,62.96) 147.25,62.96 146.67,63.54 144.39,63.54 144.37,63.52 143.77,63.52 143.65,63.64 143.38,63.64 143.28,63.74 142.75,63.74 U80.AR68
  BOTTOM w0.152: 166.26,69.9 166.45,69.72 v3(166.45,68.57)
  BOTTOM w0.153: USM2000.F11 166.31,70.59
M_A_DQ<10>: length 32.3
  IN2 w0.114: v1(158.76,71.38) 158,71.38 157.55,71.83 157.33,71.83 157.22,71.72 157.22,71.03 157.1,70.92 156.87,70.92 156.76,71.03 156.76,71.72 156.65,71.83 156.42,71.83 156.3,71.72 156.3,71.03 156.19,70.92 155.96,70.92 155.85,71.03 155.85,71.72 155.73,71.83 155.5,71.83 155.39,71.72 155.39,71.03 155.27,70.92 155.05,70.92 154.93,71.03 154.93,71.72 154.82,71.83 153.9,71.83 149.75,67.68 149.75,67.03 149.11,66.38 146.89,66.38 v3(146.41,65.91)
  BOTTOM w0.076: USM2000.F8 166.63,73.62 166.06,74.19 161.64,74.19 161.62,74.17 161.57,74.17 161.5,74.1
  BOTTOM w0.089: v3(146.41,65.91) 145.86,65.35 144.64,65.35 144.56,65.27 U80.AU71
  BOTTOM w0.152: v1(158.76,71.38) v1(159.44,72.06) 159.44,72.26 161.27,74.1 161.5,74.1
M_A_DQ<11>: length 36
  IN2 w0.114: v3(146.87,64.88) 149.62,64.88 152.16,62.34 155.76,62.34 160.21,66.78 v3(160.21,72.26)
  BOTTOM w0.076: U80.AU68 142.2,64.75 142.19,64.74 142.19,64.47 142.34,64.32 142.65,64.32 142.71,64.37 143,64.37 143.02,64.35 143.28,64.35 143.28,64.35 143.33,64.35 143.34,64.37 143.65,64.37 143.67,64.35 143.71,64.35 143.72,64.35 143.93,64.35 143.93,64.35 143.98,64.35 143.99,64.37 144.63,64.37 144.75,64.25 145.08,64.25 145.55,64.71 146.39,64.71 146.55,64.88 v3(146.87,64.88) ; 162.03,73.99 165.95,73.99 166.39,73.54 166.39,72.75 USM2000.F9
  BOTTOM w0.152: v3(160.21,72.26) 160.21,72.51 161.45,73.74 161.79,73.74 162.03,73.99
M_A_DQ<12>: length 33.9
  IN2 w0.114: v3(161.69,72.73) 161.98,72.44 162.03,72.44 163.55,70.93 163.55,70.62 162.96,70.03 162.96,67.89 156.64,61.57 151.01,61.57 148.6,63.98 146.6,63.98 146.45,64.13 146.29,64.13 v3(146.27,64.11)
  BOTTOM w0.076: U80.AR71 144.46,63.94 144.52,63.89 145.28,63.89 ; 162.36,73.41 162.56,73.61 165.48,73.61 165.6,73.5 165.6,73.23 165.41,73.04 165.41,72.87 165.33,72.79 USM2000.D9
  BOTTOM w0.089: 145.28,63.89 145.42,63.89 145.64,64.11 v3(146.27,64.11)
  BOTTOM w0.152: v3(161.69,72.73) 162.36,73.41
M_A_DQ<13>: length 34.5
  IN2 w0.114: v3(161,72.66) 161,72.25 160.87,72.13 160.87,66.43 156.35,61.9 151.88,61.9 149.45,64.33 147.31,64.33 v3(147.24,64.41)
  BOTTOM w0.076: v3(147.24,64.41) 147.14,64.5 145.64,64.5 145.21,64.07 144.59,64.07 144.46,64.2 144.05,64.2 144.04,64.19 143.99,64.19 143.98,64.18 143.66,64.18 143.65,64.19 143.6,64.19 143.59,64.2 143.4,64.2 143.39,64.19 143.35,64.19 143.35,64.19 142.99,64.19 U80.AR69 ; 161.86,73.4 162.25,73.8 165.86,73.8 166.24,73.41 166.24,72.76 USM2000.E9
  BOTTOM w0.152: 161.86,73.4 161.7,73.4 161.3,73.01 161.3,72.97 v3(161,72.66)
M_A_DQ<14>: length 30.5
  IN2 w0.114: v3(158.77,72.19) 158.61,72.02 157.89,72.02 157.7,72.21 153.69,72.21 149.44,67.96 149.44,67.4 148.71,66.67 146.53,66.67 v3(145.79,65.93)
  BOTTOM w0.076: 161.25,74.41 166.2,74.41 166.88,73.73 166.88,72.29 166.67,72.08 166.35,72.08 USM2000.E10
  BOTTOM w0.089: v3(145.79,65.93) 145.79,65.92 145.42,65.55 145.32,65.55 145.32,65.55 143.89,65.55 143.79,65.45 143.68,65.45 143.66,65.42 143.65,65.42 U80.AU70
  BOTTOM w0.102: 160.99,74.41 161.25,74.41
  BOTTOM w0.152: v3(158.77,72.19) 160.99,74.41
M_A_DQ<15>: length 31.3
  IN2 w0.114: v3(145.36,66.35) 145.57,66.35 146.19,66.96 148.42,66.96 149.13,67.67 149.13,68.14 153.56,72.57 v1(158.16,72.57)
  BOTTOM w0.076: USM2000.F10 167.04,72.12 167.04,74.04 166.49,74.59 162.67,74.59 162.55,74.71 161.84,74.71
  BOTTOM w0.089: v3(145.36,66.35) 145.23,66.22 145.23,65.95 145.03,65.74 144.94,65.74 144.93,65.74 143.72,65.74 143.59,65.6 143.18,65.6 U80.AU69
  BOTTOM w0.152: 161.84,74.71 161.55,74.71 161.52,74.74 160.32,74.74 v1(160.12,74.54) v1(158.16,72.57)
M_A_DQ<16>: length 35.7
  IN1 w0.114: v3(139.93,59.7) 139.54,60.09 139.14,60.09 138.9,59.86 138.9,59.45 139.77,58.58 147.66,58.58 148.96,59.87 156.78,59.87 163.26,66.35 163.26,70.01 163.82,70.57 v3(164.36,70.57)
  BOTTOM w0.076: v3(139.93,59.7) U80.AF65
  BOTTOM w0.152: USM2000.C11 164.36,70.59 v3(164.36,70.57)
M_A_DQ<17>: length 34.6
  IN1 w0.114: v3(162.03,71.29) 162.54,70.78 162.54,66.22 156.53,60.22 148.59,60.22 147.31,58.94 140.05,58.94 v3(139.3,59.7)
  BOTTOM w0.076: v3(139.3,59.7) U80.AF64
  BOTTOM w0.102: 162.45,71.44 163.76,71.44 USM2000.B10
  BOTTOM w0.152: 162.45,71.44 162.17,71.44 v3(162.03,71.29)
M_A_DQ<18>: length 33.3
  IN1 w0.114: v3(139.91,61.53) 139.93,61.53 140.67,62.27 141.85,62.27 142.45,62.87 142.67,62.87 143.33,63.53 143.33,65.81 144.71,67.19 145.88,67.19 147.83,69.14 148.53,69.14 149.67,70.27 155.15,70.27 155.46,70.59 156.17,70.59 156.49,70.27 156.87,70.27 157.28,70.68 158.84,70.68 159.19,71.02 159.19,72.57 160.58,73.96 163.43,73.96 163.71,73.68 v3(163.71,72.97)
  BOTTOM w0.152: USM2000.B8 163.71,72.99 v3(163.71,72.97)
  BOTTOM w0.153: U80.AK65 139.98,61.46 139.96,61.46 v3(139.91,61.53)
M_A_DQ<19>: length 33.8
  IN1 w0.114: v3(139.27,61.53) 139.3,61.53 139.69,61.93 139.89,61.93 140.47,62.5 141.65,62.5 142.06,62.92 142.06,63.63 142.93,64.49 142.93,65.84 144.83,67.74 145.7,67.74 146.96,69 147.16,69 147.73,69.57 148.44,69.57 150.43,71.57 156.48,71.57 156.76,71.85 156.76,72.15 157.2,72.6 157.51,72.6 157.94,73.03 158.89,73.03 160.16,74.3 163.76,74.3 164.36,73.7 v3(164.36,72.97)
  BOTTOM w0.152: v3(164.36,72.97) 164.36,72.99 USM2000.C8 ; U80.AK64 v3(139.27,61.53)
M_A_DQ<20>: length 31.6
  IN1 w0.114: v3(162.11,70.52) 162.11,69.55 162.13,69.53 162.13,66.32 156.4,60.59 148.28,60.59 147.51,59.83 144.55,59.83 144.03,59.3 140.96,59.3 v3(140.57,59.7)
  BOTTOM w0.076: v3(140.57,59.7) U80.AF66
  BOTTOM w0.153: USM2000.B11 163.54,70.41 162.62,70.41 162.51,70.52 v3(162.11,70.52)
M_A_DQ<21>: length 31.7
  IN1 w0.114: v3(141.2,59.7) 143.9,59.7 144.5,60.29 147.21,60.29 147.83,60.91 156.11,60.91 161.3,66.09 161.3,70.63 v3(161.38,70.71)
  BOTTOM w0.076: v3(141.2,59.7) U80.AF67 ; USM2000.C10 164.19,71.21 162.72,71.21 162.4,70.89 161.56,70.89 161.5,70.82
  BOTTOM w0.152: 161.5,70.82 v3(161.38,70.71)
M_A_DQ<22>: length 31.7
  IN1 w0.114: v3(163.71,72.17) 163.66,72.12 162.67,72.12 162.54,72.24 160.94,72.24 160.1,71.4 160.1,69.96 159.51,69.37 157.02,69.37 156.78,69.61 151.13,69.61 148.01,66.49 148.01,62.69 147.83,62.52 146.78,62.52 146.34,62.96 144.16,62.96 142.97,61.77 141.84,61.77 141.62,61.55 141.4,61.55 141.32,61.63 141.32,61.65 v3(141.34,61.65)
  BOTTOM w0.152: U80.AK67 141.34,61.28 v3(141.34,61.65) ; v3(163.71,72.17) 163.71,72.19 USM2000.B9
M_A_DQ<23>: length 33.6
  IN1 w0.114: v3(164.36,72.17) 164.36,72.26 164.06,72.56 163.59,72.56 163.57,72.59 163.55,72.59 163.33,72.81 163.33,72.83 163.27,72.89 163.27,73.44 163.08,73.63 162.57,73.63 162.57,73.62 160.72,73.62 159.49,72.39 159.49,70.75 158.68,69.93 158.42,69.93 158.07,70.28 157.76,70.28 157.41,69.93 149.9,69.93 146.75,66.79 144.75,66.79 143.72,65.76 143.72,63.22 143.01,62.51 142.53,62.51 142.05,62.04 141.03,62.04 v3(140.54,61.55)
  BOTTOM w0.152: USM2000.C9 164.36,72.19 v3(164.36,72.17)
  BOTTOM w0.153: U80.AK66 140.62,61.46 140.61,61.46 v3(140.54,61.55)
M_A_DQ<24>: length 49.2
  BOTTOM w0.152: 143.71,58.72 143.86,58.57 143.99,58.57 144.19,58.37 145.3,57.26 152.4,57.26 152.84,57.7 156.98,57.7 159.36,60.08 170.08,60.08 176.55,66.55 176.55,72.35 174.81,74.09 173.99,74.09
  BOTTOM w0.153: 173.99,74.09 173.5,74.09 172.81,73.4 172.81,73.17 172.48,72.84 USM2000.R9 ; 143.71,58.72 U80.AF70
M_A_DQ<25>: length 51.4
  BOTTOM w0.152: 143.46,58.41 143.94,57.92 144.15,57.92 145.16,56.91 152.62,56.91 153.07,57.36 157.13,57.36 159.51,59.74 170.22,59.74 176.9,66.41 176.9,72.55 175,74.45 173.97,74.45
  BOTTOM w0.153: USM2000.R8 172.48,73.52 173.42,74.45 173.97,74.45 ; 143.46,58.41 143.19,58.68 142.55,58.68 U80.AF68
M_A_DQ<26>: length 47.4
  BOTTOM w0.076: 146.12,59.48 145.97,59.64 145.97,59.67 145.38,60.26 U80.AH71
  BOTTOM w0.152: 146.12,59.48 150.82,59.48 151.13,59.79 151.13,60.68 151.28,60.83 151.59,60.83 151.74,60.68 151.74,60.03 151.9,59.88 152.2,59.88 152.35,60.03 152.35,60.68 152.51,60.83 152.81,60.83 152.96,60.68 152.96,60.03 153.11,59.88 153.42,59.88 153.57,60.03 153.57,60.68 153.72,60.83 154.03,60.83 154.18,60.68 154.18,60.03 154.33,59.88 154.64,59.88 154.79,60.03 154.79,60.68 154.94,60.83 155.25,60.83 155.4,60.68 155.4,60.03 155.55,59.88 155.86,59.88 156.01,60.03 156.01,60.68 156.16,60.83 156.91,60.83 159.33,63.25 165.03,63.25 165.17,63.38 165.17,64.27 165.3,64.4 165.49,64.4 165.62,64.27 165.62,63.38 165.76,63.25 166.26,63.25 166.39,63.38 v1(166.39,63.53) 166.39,63.67 166.53,63.81 166.72,63.81 166.85,63.67 166.85,63.38 166.98,63.25 170.1,63.25 174.27,67.42 174.27,69.45 174,69.73 173.97,69.73 ; USM2000.T11 173.45,70.59
  BOTTOM w0.153: 173.97,69.73 173.72,69.73 173.45,69.99 173.45,70.59
M_A_DQ<27>: length 45.3
  BOTTOM w0.076: 146.1,58.29 145.49,58.89 144.88,58.89 144.39,59.38 144.01,59.38 143.97,59.34 143.67,59.34 143.61,59.41 143.38,59.41 143.33,59.35 143.32,59.35 143.27,59.35 143.27,59.34 143.02,59.34 142.96,59.41 142.4,59.41 142.2,59.61 U80.AH68
  BOTTOM w0.152: 146.1,58.29 151.71,58.29 152.16,58.73 156.56,58.73 158.94,61.11 169.66,61.11 175.39,66.85 175.39,71.51 174.92,71.99 174.63,71.99 174.61,72.01 174.46,72.01 174.46,72 174.12,72 174.11,72.01 174.03,72.01 173.97,72.07
  BOTTOM w0.153: 173.97,72.07 173.95,72.09 173.51,72.09 USM2000.T10
M_A_DQ<28>: length 45.8
  BOTTOM w0.152: U80.AF71 145.48,57.6 152.19,57.6 152.63,58.05 156.84,58.05 159.22,60.43 169.94,60.43 176.18,66.66 176.18,72.24 174.67,73.74 173.97,73.74
  BOTTOM w0.153: USM2000.T8 173.56,73.74 173.97,73.74
M_A_DQ<29>: length 45.6
  BOTTOM w0.076: 146,57.94 145.33,58.61 144.87,58.61 144.32,59.16 144.29,59.19 144,59.19 143.94,59.14 143.7,59.14 143.65,59.19 143.36,59.19 143.35,59.19 143.34,59.19 143.19,59.03 U80.AF69
  BOTTOM w0.152: 173.97,72.9 174.07,72.9 174.12,72.85 174.82,72.85 175.82,71.85 175.82,66.79 169.8,60.77 159.08,60.77 156.7,58.39 152.37,58.39 151.93,57.94 146,57.94
  BOTTOM w0.153: 173.97,72.9 173.53,72.9 USM2000.T9
M_A_DQ<30>: length 47.4
  BOTTOM w0.076: 145.73,60.27 145.5,60.5 144.32,60.5 144.3,60.52 144,60.52 143.96,60.47 143.71,60.47 U80.AH70
  BOTTOM w0.152: 173.2,68.56 173.8,68.56 173.95,68.41 173.95,67.59 173.25,66.89 173.04,66.89 173,66.93 172.79,66.93 172.57,66.71 172.57,66.49 172.61,66.46 172.61,66.24 172.39,66.03 172.18,66.03 172.14,66.06 171.93,66.06 171.71,65.85 171.71,65.63 v1(171.72,65.62) 171.75,65.6 171.75,65.38 171.53,65.17 171.31,65.17 171.28,65.2 171.06,65.2 170.85,64.98 170.85,64.77 170.88,64.73 170.88,64.52 170.69,64.33 170.39,64.33 170.22,64.16 166.78,64.16 166.2,64.75 164.73,64.75 164.59,64.61 164.59,63.73 164.46,63.59 164.27,63.59 164.14,63.73 164.14,64.61 164,64.75 163.81,64.75 163.68,64.61 163.68,63.73 163.55,63.59 163.36,63.59 163.22,63.73 163.22,64.61 163.09,64.75 162.9,64.75 162.77,64.61 162.77,63.73 162.63,63.59 162.44,63.59 162.31,63.73 162.31,64.61 162.17,64.75 161.92,64.75 161.77,64.59 161.77,63.75 161.62,63.59 159.05,63.59 156.64,61.18 150.92,61.18 150.68,60.94 150.68,60.1 150.4,59.83 146.17,59.83 145.73,60.27
  BOTTOM w0.153: USM2000.R11 172.27,70.91 172.19,70.83 172.19,70.71 172.38,70.52 172.65,70.52 172.8,70.37 172.8,69.13 173.05,68.89 173.05,68.72 173.2,68.56
M_A_DQ<31>: length 46.6
  BOTTOM w0.076: USM2000.R10 172.17,72.02 171.78,72.02 171.58,71.81 171.58,71.6 171.61,71.57 171.61,71.05 171.58,71.01 171.58,70.8 171.59,70.8 171.59,70.77 171.86,70.5 171.99,70.5 172.19,70.3 ; 145.75,60.68 143.99,60.68 143.98,60.68 143.93,60.68 143.92,60.67 143.56,60.67 143.47,60.58 143.17,60.58 U80.AH69
  BOTTOM w0.152: 172.19,69.01 172.32,68.87 172.32,68.46 172.79,67.99 172.79,67.41 169.88,64.5 166.93,64.5 166.34,65.09 161.56,65.09 161.42,64.96 161.42,64.07 161.29,63.94 161.1,63.94 160.97,64.07 160.97,64.96 160.83,65.09 160.64,65.09 160.51,64.96 160.51,64.07 160.38,63.94 160.19,63.94 160.05,64.07 160.05,64.96 159.92,65.09 159.73,65.09 159.6,64.96 159.6,64.07 159.46,63.94 159.27,63.94 159.14,64.07 159.14,64.96 159.01,65.09 158.75,65.09 158.6,64.94 v1(158.6,64.41) 158.6,63.79 156.32,61.52 150.78,61.52 149.42,60.17 146.26,60.17 145.75,60.68
  BOTTOM w0.153: 172.19,70.3 172.19,69.01
M_A_DQ<32>: length 33.2
  BOTTOM w0.076: 158.76,84.64 158.16,84.64 157.99,84.8 157.3,84.8 157.2,84.71 157.2,84.07 ; U80.BB65 140.49,68.51 140.49,68.9 141.74,70.14 143.07,70.14 143.1,70.12 144.47,70.12
  BOTTOM w0.152: 144.47,70.12 145.27,70.92 149.23,70.92 152.46,74.15 155.11,74.15 160.07,79.1 160.07,83.32 158.76,84.64
  BOTTOM w0.153: USM2001.T9 157.2,84.07
M_A_DQ<33>: length 38.2
  BOTTOM w0.076: USM2001.R8 156.41,84.73 156.41,84.87 157.13,85.58 158.96,85.58 ; 145.54,69.39 143.06,69.39 142.83,69.62 142.12,69.62 141.91,69.42 141.91,69.29 141.29,68.67 141.29,68.21 141.31,68.2 141.31,67.92 141.16,67.77 141.01,67.77 140.97,67.73 140.95,67.73 140.8,67.59 140.8,67.54 140.8,67.53 140.8,67.28 140.8,67.28 140.73,67.21 140.73,66.8 U80.AW65
  BOTTOM w0.152: 145.54,69.39 146,69.85 149.9,69.85 153,72.95 155.4,72.95 161.17,78.72 161.17,83.72 159.31,85.58 158.96,85.58
M_A_DQ<34>: length 33.6
  BOTTOM w0.076: U80.AW63 139.16,66.68 138.85,66.99 138.85,67.53 138.63,67.75 138.63,69.23 139.45,70.05 139.74,70.05 141.13,71.44 142.97,71.44
  BOTTOM w0.152: 142.97,71.44 144.55,73.02 147.7,73.02 150.25,75.57 150.25,77.08 v1(150.34,77.18) 150.48,77.31 151.31,77.31 151.45,77.18 152.74,77.18 153.21,77.65 153.21,78.35 152.86,78.71 152.86,80.23 153.01,80.38 153.26,80.38 153.43,80.21 153.43,78.9 153.54,78.79 153.76,78.79 153.9,78.94 153.9,80.27 154.01,80.38 154.36,80.38 154.52,80.23 154.52,79.84 154.67,79.69 155.46,79.69 155.68,79.91 155.7,79.91 155.7,80.25
  BOTTOM w0.153: USM2001.R11 155.93,81.85 155.93,80.48 155.7,80.25
M_A_DQ<35>: length 32
  BOTTOM w0.076: 143.73,70.75 141.39,70.75 140.01,69.38 139.57,69.38 139.33,69.13 139.33,68.3 139.28,68.18 139.28,68.04 139.34,67.81 139.34,67.68 139.26,67.47 139.26,67.21 U80.AY63
  BOTTOM w0.152: 158.34,82.31 158.41,82.39 158.57,82.39 158.68,82.28 158.68,81.27 158.54,81.13 158.4,81.13 158.29,81.03 158.29,79.44 157.4,78.54 157.12,78.54 156.72,78.14 v1(156.5,78.14) 156.11,78.53 155.89,78.53 155.67,78.31 155.67,76.81 155.41,76.55 155.41,76.16 154.64,75.39 152.05,75.39 148.65,71.99 144.97,71.99 143.73,70.75 ; USM2001.T10 157.2,82.62
  BOTTOM w0.153: 157.2,82.62 157.59,82.62 157.9,82.31 158.34,82.31
M_A_DQ<36>: length 34.2
  BOTTOM w0.076: 158.94,84.94 158.22,84.94 158.09,85.07 157.16,85.07 156.88,84.79 USM2001.T8 ; U80.BA65 140.39,67.91 140.53,68.05 140.53,68.05 140.54,68.05 140.67,68.33 140.67,68.75 140.7,68.78 140.7,68.84 141.81,69.96 143.02,69.96 143.07,69.91 144.76,69.91
  BOTTOM w0.152: 158.94,84.94 160.43,83.45 160.43,78.97 155.2,73.74 152.59,73.74 149.42,70.57 145.42,70.57 144.76,69.91
M_A_DQ<37>: length 37.1
  BOTTOM w0.076: 159.13,85.25 158.36,85.25 158.29,85.31 157.13,85.31 156.61,84.8 156.61,84.13 USM2001.R9 ; 145.28,69.66 143.07,69.66 142.94,69.79 141.93,69.79 140.86,68.72 140.86,68.35 140.64,67.89 140.64,67.64 140.64,67.64 140.64,67.6 140.63,67.6 140.63,67.58 140.5,67.44 140.47,67.44 140.39,67.36 U80.AY65
  BOTTOM w0.152: 145.28,69.66 145.82,70.2 149.65,70.2 152.78,73.33 155.3,73.33 160.78,78.82 160.78,83.59 159.13,85.25
M_A_DQ<38>: length 32.6
  BOTTOM w0.076: USM2001.R10 156.55,82.62 156.55,80.35 ; U80.BA63 139.06,67.97 138.8,68.24 138.8,69.16 139.46,69.82 139.86,69.82 141.23,71.2 143.21,71.2 143.56,71.55
  BOTTOM w0.152: 156.55,80.35 156.67,80.23 156.67,79.85 156.49,79.67 156.27,79.67 155.91,79.32 154.82,79.32 154.66,79.16 154.66,77.23 154.51,77.08 154.3,77.08 154.14,77.23 154.14,78.22 153.99,78.38 153.75,78.38 153.62,78.24 v1(153.62,76.91) 153.62,76.53 153.47,76.39 153.06,76.39 152.92,76.52 152.92,76.7 152.79,76.83 152.6,76.83 152.46,76.7 152.46,76.52 152.33,76.39 151.99,76.39 151.71,76.66 151.71,76.67 151.56,76.82 150.75,76.82 150.6,76.67 150.6,75.31 147.96,72.68 144.69,72.68 143.56,71.55
M_A_DQ<39>: length 32
  BOTTOM w0.076: 143.63,71.13 143.48,70.99 141.33,70.99 139.93,69.59 139.52,69.59 139.06,69.13 U80.BB63
  BOTTOM w0.152: 157.68,81.67 157.94,81.41 157.94,79.62 157.79,79.47 157.59,79.47 157.51,79.55 157.51,80.15 157.4,80.26 157.17,80.26 157.03,80.12 157.03,79.15 156.79,78.91 155.51,78.91 155.23,78.62 155.23,76.92 154.91,76.6 154.18,76.6 154.07,76.5 154.07,75.97 153.9,75.79 153.36,75.79 153.12,76.04 152.58,76.04 152.28,75.73 151.56,75.73 v1(151.54,75.76) 151.41,75.89 151.41,76.28 151.25,76.44 151.11,76.44 150.95,76.28 150.95,74.9 148.38,72.34 144.83,72.34 143.63,71.13
  BOTTOM w0.153: 157.68,81.67 157.05,81.67 156.88,81.84 USM2001.T11
M_A_DQ<40>: length 24.8
  BOTTOM w0.076: U80.BA61 138.04,68.04 138.09,68.1 138.23,68.1 138.3,68.17 138.3,69.37 139.48,70.55 139.63,70.55 141.02,71.94 ; USM2001.F11 150.45,82.21 150.45,82.47 150.34,82.59 150.12,82.59 150.06,82.52 150.06,81.91 150.16,81.8 150.16,81.59 150.05,81.48 150.05,80.72 150.59,80.18
  BOTTOM w0.102: 142.26,71.94 141.02,71.94
  BOTTOM w0.152: 150.59,80.18 150.59,79.84 150.78,79.65 150.78,79.5 151.36,78.92 151.36,78.62 150.91,78.17 150,78.17 149.32,77.49 149.32,76.11 147.36,74.15 144.47,74.15 142.26,71.94
M_A_DQ<41>: length 27.6
  BOTTOM w0.076: 150.95,80.66 150.95,80.93 150.72,81.17 150.72,83.27 150.61,83.38 150.18,83.38 150.03,83.23 150.03,83.03 150.12,82.94 USM2001.F10 ; 142.51,71.71 141.09,71.71 139.7,70.32 139.48,70.32 138.47,69.3 138.47,67.73 138.26,67.52 138.26,66.96 137.94,66.64 U80.AW61
  BOTTOM w0.152: 151.19,80.43 151.19,79.65 151.8,79.04 v1(151.8,78.73) 151.8,78.44 151.16,77.79 150.25,77.79 149.71,77.25 149.71,76.02 147.5,73.81 144.61,73.81 142.51,71.71
  BOTTOM w0.153: 150.95,80.66 151.19,80.43
M_A_DQ<42>: length 25.6
  BOTTOM w0.076: 140.63,73.24 140.63,73.22 136.61,69.2 136.61,68.51 U80.BB59 ; 146.65,85.34 148.74,85.34 148.77,85.36 149.07,85.36 149.09,85.34 149.23,85.34 149.41,85.16 149.41,84.06 USM2001.E9
  BOTTOM w0.152: 140.63,73.24 140.99,73.6 141.09,73.6 144.06,76.57 144.06,76.87 v1(145.91,78.72) 145.91,84.59 146.65,85.34
M_A_DQ<43>: length 29.3
  BOTTOM w0.076: 148.42,84.95 148.76,84.61 148.76,83.53 148.84,83.45 149.01,83.45 149.08,83.53 USM2001.D9 ; 141.47,72.62 140.89,72.62 139.53,71.26 139.48,71.26 137.81,69.59 137.81,68.84 137.6,68.63 137.6,68.27 137.64,68.19 137.64,67.99 137.6,67.9 137.6,67.89 137.6,67.89 137.6,67.88 137.6,67.65 137.64,67.53 137.64,67.28 137.57,67.18 137.57,66.61 137.41,66.46 U80.AW59
  BOTTOM w0.152: 141.47,72.62 144.12,75.26 144.45,75.26 v1(145.14,75.96) 148.14,78.95 148.14,79.61 147.5,80.26 146.91,80.26 146.26,80.91 146.26,84.33 146.87,84.95 148.42,84.95
M_A_DQ<44>: length 23.5
  BOTTOM w0.076: 140.99,72.21 139.56,70.78 139.48,70.78 138.14,69.44 138.14,68.51 U80.BB61 ; 149.49,80.28 149.49,81.53 149.57,81.62 149.76,81.62 149.84,81.7 149.84,81.8 149.8,81.85 149.6,81.85 149.53,81.92 149.53,81.97 149.7,82.14 USM2001.E11
  BOTTOM w0.102: 140.99,72.21 142.03,72.21
  BOTTOM w0.152: 142.03,72.21 142.06,72.21 144.35,74.5 147.22,74.5 148.79,76.07 v1(148.79,76.67) 148.79,77.49 149.23,77.93 149.23,78.34 149.37,78.48 149.86,78.48 149.93,78.55 150.62,78.55 150.78,78.7 150.78,78.97 150.12,79.63 149.68,79.63 149.49,79.82
  BOTTOM w0.153: 149.49,80.28 149.49,79.82
M_A_DQ<45>: length 26
  BOTTOM w0.076: USM2001.E10 149.8,83.01 149.8,83.37 149.73,83.45 149.55,83.45 149.38,83.28 149.38,82.88 149.36,82.85 149.36,82.73 149.41,82.67 149.62,82.67 149.7,82.6 149.7,82.47 149.61,82.38 149.41,82.38 149.34,82.31 149.34,82.2 149.37,82.18 149.37,81.63 149.34,81.59 149.34,80.69 149.08,80.43 ; 141.79,72.45 141.76,72.42 140.94,72.42 139.52,71 139.46,71 137.97,69.51 137.97,68.77 137.77,68.56 137.77,68.31 137.8,68.22 137.8,68.2 137.8,67.95 137.77,67.87 137.77,67.66 137.84,67.47 137.84,67.21 U80.AY61
  BOTTOM w0.152: 141.79,72.45 144.22,74.88 146.98,74.88 148.11,76.01 148.11,77.42 148.87,78.18 148.87,78.73 149.01,78.87 149.44,78.87 149.55,78.98 149.55,79.24 149.43,79.36 148.84,79.36 148.73,79.47 148.73,79.65 149.08,80
  BOTTOM w0.153: 149.08,80.43 149.08,80
M_A_DQ<46>: length 27.7
  BOTTOM w0.076: U80.BA59 136.5,68.16 136.44,68.31 136.44,69.29 139.96,72.8 139.96,73.05 ; USM2001.F8 150.38,84.63 150.15,84.87 149.8,84.87 149.73,84.94 149.73,85.12 149.82,85.21 150.16,85.21 150.23,85.27 150.23,85.41 150.04,85.59 146.4,85.59
  BOTTOM w0.152: 146.4,85.59 145.57,84.76 145.57,78.99 143.56,76.99 143.56,76.53 140.99,73.96 140.88,73.96 139.96,73.05
M_A_DQ<47>: length 29.5
  BOTTOM w0.076: U80.AY59 136.71,67.31 136.44,67.58 136.44,67.77 136.31,68.2 136.28,68.28 136.28,69.36 139.67,72.75 139.67,73.18 ; 145.95,85.81 150.18,85.81 150.62,85.37 150.62,83.99 USM2001.F9
  BOTTOM w0.152: 145.95,85.81 145.14,85 v1(145.14,84.98) 145.14,79.27 143.14,77.27 143.14,76.54 140.82,74.22 140.72,74.22 139.67,73.18
M_A_DQ<48>: length 30.7
  IN2 w0.114: v3(155.25,83.41) 157.01,83.41 157.74,82.68 157.74,79.26 154,75.52 152.21,75.52 150.62,73.93 150.62,73.06 148.65,71.09 147.19,71.09 142.82,66.73 142.82,65.57 142.24,64.98 141.39,64.98 v3(141.38,64.99)
  BOTTOM w0.076: v3(141.38,64.99) 141.04,64.64 U80.AT66
  BOTTOM w0.152: USM2001.P9 155.57,83.74 155.25,83.42 v3(155.25,83.41)
M_A_DQ<49>: length 30.3
  IN2 w0.114: v3(153.95,83.41) 153.96,83.41 154.35,83.02 156.5,83.02 156.68,82.84 156.68,80.85 157.23,80.3 157.23,79.3 153.77,75.85 151.77,75.85 150.3,74.38 150.3,73.69 148.06,71.46 146.97,71.46 143.15,67.64 142.57,67.64 141.78,66.86 141.78,65.88 141.54,65.63 v3(141.38,65.63)
  BOTTOM w0.076: v3(141.38,65.63) U80.AU66
  BOTTOM w0.152: v3(153.95,83.41) 153.95,83.42 154.27,83.74 USM2001.M9
M_A_DQ<50>: length 31.3
  IN2 w0.076: v3(140.47,63.64) 140.09,64.02 140.09,64.54 140.1,64.55 140.1,64.96 139.83,65.23
  IN2 w0.114: v3(155.25,81.81) 155.25,81.4 155.09,81.25 155.09,80.63 155.37,80.36 155.37,79.42 152.83,76.89 150.14,76.89 147.21,73.96 147.21,73.24 146.88,72.91 146.74,72.91 146.5,73.14 146.36,73.14 146.26,73.04 146.26,72.9 146.49,72.66 146.49,72.52 146.39,72.42 146.25,72.42 146.01,72.66 145.87,72.66 145.77,72.56 145.77,72.42 146.01,72.18 146.01,72.04 145.91,71.94 145.77,71.94 145.53,72.17 145.39,72.17 145.29,72.07 145.29,71.93 145.52,71.69 145.52,71.55 145.42,71.45 145.28,71.45 145.04,71.69 144.9,71.69 144.8,71.59 144.8,71.45 145.04,71.21 145.04,71.07 142.64,68.66 142.25,68.66 140.29,66.7 140.29,66.35 139.83,65.89 139.83,65.23
  BOTTOM w0.076: v3(140.47,63.64) 140.45,63.62 140.37,63.62 140.09,63.34 U80.AP65
  BOTTOM w0.152: USM2001.N11 155.25,81.82 v3(155.25,81.81)
M_A_DQ<51>: length 31.7
  IN2 w0.076: 139.61,65.17 139.91,64.87 139.91,63.64 v3(140.47,63.09)
  IN2 w0.114: v3(154.6,81.81) 154.67,81.74 154.67,81.25 154.78,81.14 154.78,80.64 154.52,80.38 154.52,79.08 153.93,78.49 153.77,78.49 153.53,78.73 153.37,78.73 153.21,78.57 153.21,78.41 153.45,78.17 153.45,78.01 152.63,77.19 149.96,77.19 144.13,71.36 144.13,71.03 144.21,70.96 144.21,70.82 144.11,70.72 143.96,70.72 143.75,70.93 143.61,70.93 143.51,70.83 143.51,70.68 143.72,70.47 143.72,70.33 143.62,70.23 143.48,70.23 143.27,70.44 143.13,70.44 143.03,70.34 143.03,70.2 143.24,69.99 143.24,69.85 143.14,69.75 142.99,69.75 142.78,69.96 142.64,69.96 142.47,69.78 141.49,69.78 141.38,69.67 141.38,68.25 139.98,66.86 139.98,66.38 139.61,66.01 139.61,65.17
  BOTTOM w0.076: v3(140.47,63.09) 140.07,62.69 U80.AN65
  BOTTOM w0.152: USM2001.M11 154.6,81.82 v3(154.6,81.81)
M_A_DQ<52>: length 36.2
  IN2 w0.114: v3(154.6,84.21) 154.6,84.22 154.99,84.61 156.71,84.61 157.77,83.55 158.33,83.55 159.67,82.22 159.67,79.33 155.16,74.82 153.2,74.82 151.28,72.9 151.28,72.48 148.92,70.12 148.68,70.12 148.08,69.52 148.08,69.42 146.53,67.87 145.66,67.87 145.21,67.43 144.62,67.43 143.49,66.29 143.49,65.2 v3(141.38,63.09)
  BOTTOM w0.076: v3(141.38,63.09) 140.99,62.69 U80.AN66
  BOTTOM w0.254: USM2001.M8 154.6,84.22 v3(154.6,84.21)
M_A_DQ<53>: length 34.4
  IN2 w0.114: v3(141.38,63.72) 143.13,65.47 143.13,66.42 144.46,67.75 145.09,67.75 145.56,68.21 146.38,68.21 147.69,69.52 147.69,69.63 148.7,70.65 148.94,70.65 150.95,72.66 150.95,73.25 152.88,75.19 154.76,75.19 159.13,79.56 159.13,82.31 158.23,83.21 157.68,83.21 157.13,83.76 155.7,83.76 155.64,83.82 155,83.82 154.6,83.42 v3(154.6,83.41)
  BOTTOM w0.076: v3(141.38,63.72) U80.AP66
  BOTTOM w0.152: v3(154.6,83.41) 154.6,83.42 154.92,83.74 USM2001.N9
M_A_DQ<54>: length 30.3
  IN2 w0.114: v3(154.6,82.61) 154.61,82.61 155,82.23 155.09,82.23 155.09,82.22 155.41,82.22 155.42,82.23 155.48,82.23 155.79,81.92 155.79,81.08 155.89,80.98 155.89,80.66 155.77,80.54 155.77,79.34 153.01,76.58 150.31,76.58 149.53,75.8 149.53,74.97 149.22,74.66 149.08,74.66 148.87,74.86 148.73,74.86 148.63,74.76 148.63,74.62 148.84,74.41 148.84,74.27 148.74,74.17 148.59,74.17 148.39,74.38 148.25,74.38 148.14,74.28 148.14,74.13 148.35,73.93 148.35,73.79 148.25,73.69 148.11,73.69 147.9,73.89 147.76,73.89 147.66,73.79 147.66,73.65 147.83,73.48 147.83,73.33 142.79,68.29 142.3,68.29 140.62,66.6 140.62,66.3 140.1,65.79 140.1,65.39 v3(140.49,64.99)
  BOTTOM w0.076: U80.AT65 140.12,64.64 140.47,64.99 v3(140.49,64.99)
  BOTTOM w0.152: USM2001.M10 154.6,82.62 v3(154.6,82.61)
M_A_DQ<55>: length 31.3
  IN2 w0.076: v3(140.49,65.63) 140.49,65.65
  IN2 w0.114: v3(155.25,82.61) 155.26,82.62 155.71,82.62 156.34,82 156.34,80.62 156.59,80.37 156.59,79.24 153.58,76.23 151.32,76.23 150.98,75.9 150.84,75.9 150.71,76.03 150.57,76.03 150.46,75.93 150.46,75.79 150.6,75.65 150.6,75.51 150.5,75.41 150.36,75.41 150.22,75.55 150.08,75.55 149.98,75.45 149.98,75.31 150.12,75.17 150.12,75.03 149.48,74.39 149.48,74.23 149.76,73.95 149.76,73.78 149.59,73.62 149.43,73.62 149.15,73.9 148.99,73.9 148.83,73.74 148.83,73.58 149.11,73.3 149.11,73.14 148.95,72.98 148.79,72.98 148.51,73.26 148.34,73.26 148.18,73.09 148.18,72.93 148.46,72.65 148.46,72.49 148.3,72.33 148.14,72.33 147.86,72.61 147.59,72.61 142.92,67.95 142.39,67.95 140.92,66.47 140.92,66.08 140.49,65.65
  BOTTOM w0.076: U80.AU65 140.14,65.29 140.47,65.63 v3(140.49,65.63)
  BOTTOM w0.152: v3(155.25,82.61) 155.25,82.62 USM2001.N10
M_A_DQ<56>: length 26.1
  IN2 w0.114: v3(148.11,83.41) 148.12,83.42 149.07,83.42 149.81,82.69 149.81,81.18 149.66,81.03 149.66,78.02 143.73,72.09 142.56,72.09 140.54,70.07 140.54,68.3 139.35,67.11 139.35,66.49 139.05,66.19 139.05,65.4 v3(138.64,64.99)
  BOTTOM w0.076: v3(138.64,64.99) 138.29,64.64 U80.AT61
  BOTTOM w0.152: USM2001.C9 148.11,83.42 v3(148.11,83.41)
M_A_DQ<57>: length 24.9
  IN2 w0.114: v3(148.11,82.61) 148.11,82.62 148.51,83.02 149.03,83.02 149.35,82.69 149.35,78.14 143.65,72.44 142.39,72.44 140.21,70.27 140.21,68.4 138.95,67.15 138.95,66.49 138.64,66.18 v3(138.64,65.63)
  BOTTOM w0.076: U80.AU61 138.31,65.29 v3(138.64,65.63)
  BOTTOM w0.152: v3(148.11,82.61) 148.11,82.62 USM2001.C10
M_A_DQ<58>: length 25.3
  IN2 w0.076: 137.35,64.88 137.35,64.18 137.73,63.81 v3(137.73,63.72)
  IN2 w0.114: v3(147.46,82.61) 147.45,82.61 147.05,82.21 146.85,82.21 146.84,82.21 146.52,82.21 146.52,82.21 146.13,81.82 146.13,77.98 142.35,74.2 141.62,74.2 138.13,70.71 138.13,68.63 137.02,67.52 137.02,65.21 137.35,64.88
  BOTTOM w0.076: v3(137.73,63.72) 137.35,63.34 U80.AP60
  BOTTOM w0.152: v3(147.46,82.61) 147.46,82.62 USM2001.B10
M_A_DQ<59>: length 27
  IN2 w0.076: 136.72,65.11 137.18,64.65 137.18,64.06 137.35,63.89 137.35,63.46 v3(137.73,63.09)
  IN2 w0.114: 136.72,65.11 136.72,67.73 137.81,68.82 137.81,70.88 141.46,74.53 142.22,74.53 145.79,78.09 145.79,82.28 146.52,83.02 147.05,83.02 147.45,83.41 v3(147.46,83.41)
  BOTTOM w0.076: v3(137.73,63.09) 137.33,62.69 U80.AN60
  BOTTOM w0.152: v3(147.46,83.41) 147.46,83.42 USM2001.B9
M_A_DQ<60>: length 29.8
  IN2 w0.076: 136.95,64.04 137.17,63.81 137.17,63.36 137.33,63.2 137.33,62.96 137.57,62.72 138.27,62.72 v3(138.64,63.09)
  IN2 w0.114: v3(147.46,84.21) 147.45,84.21 147.06,83.82 146.66,83.82 145.45,82.62 145.45,78.23 142.06,74.83 141.28,74.83 137.37,70.92 137.37,69.58 136.96,69.17 136.96,68.48 136.46,67.98 136.46,66.35 136.4,66.29 136.4,64.21 136.57,64.04 136.95,64.04
  BOTTOM w0.076: v3(138.64,63.09) 138.25,62.69 U80.AN61
  BOTTOM w0.152: USM2001.B8 147.46,84.22 v3(147.46,84.21)
M_A_DQ<61>: length 28.7
  IN2 w0.114: v3(148.11,84.21) 148.12,84.22 148.88,84.22 150.14,82.97 150.14,80.61 150.7,80.05 150.7,78.55 143.73,71.58 142.67,71.58 140.85,69.75 140.85,68.18 139.65,66.98 139.65,66.41 139.31,66.07 139.31,65.29 139.12,65.1 139.12,64.2 v3(138.64,63.72)
  BOTTOM w0.076: v3(138.64,63.72) 138.26,63.34 U80.AP61
  BOTTOM w0.152: v3(148.11,84.21) 148.11,84.22 USM2001.C8
M_A_DQ<62>: length 24.7
  IN2 w0.114: v3(147.46,81.81) 147.36,81.81 146.97,81.42 146.93,81.42 146.5,81 146.5,77.29 146.34,77.13 146.18,77.13 146.06,77.25 145.9,77.25 145.74,77.09 145.74,76.93 145.86,76.81 145.86,76.64 145.7,76.48 145.53,76.48 145.41,76.6 145.25,76.6 145.09,76.44 145.09,76.28 145.21,76.16 145.21,76 145.05,75.84 144.89,75.84 144.77,75.96 144.6,75.96 144.44,75.79 144.44,75.63 144.56,75.51 144.56,75.35 143.05,73.83 141.79,73.83 138.43,70.47 138.43,68.42 137.32,67.31 137.32,65.39 v3(137.73,64.99)
  BOTTOM w0.076: v3(137.73,64.99) 137.38,64.64 U80.AT60
  BOTTOM w0.152: v3(147.46,81.81) 147.46,81.82 USM2001.B11
M_A_DQ<63>: length 24
  IN2 w0.114: v3(137.73,65.63) 137.62,65.73 137.62,67.14 138.74,68.25 138.74,70.27 141.99,73.52 143.17,73.52 146.82,77.18 146.82,80.11 147.01,80.3 147.59,80.3 147.68,80.39 147.68,80.53 147.6,80.62 147.01,80.62 146.89,80.73 146.89,81.03 147.29,81.42 147.84,81.42 148.09,81.67 v3(148.09,81.81)
  BOTTOM w0.076: U80.AU60 137.39,65.29 v3(137.73,65.63)
  BOTTOM w0.152: v3(148.09,81.81) 148.1,81.81 USM2001.C11
M_A_DQS_DN*<0>: length 40.3
  IN2 w0.102: v3(145.54,62.18) 145.87,62.5 146.21,62.5 146.39,62.33 146.66,62.33 148.52,60.47 159.79,60.47 164.97,65.66 169.91,65.66 170.11,65.85 170.11,67.47 169.85,67.73 169.2,67.73 v3(168.66,67.18)
  BOTTOM w0.076: 169.33,68.53 169.33,68.55 169.28,68.61 169.28,69.06 169.64,69.43 169.64,70.5 169.88,70.74 USM2000.L11 ; v3(145.54,62.18) 145.54,62.04 145.28,61.79 144.6,61.79 144.38,62.01 143.93,62.01 143.91,61.99 143.73,61.99 143.71,62.01 143.28,62.01 143.26,61.99 143.08,61.99 143.06,62.01 142.95,62.01 142.87,62.09 142.87,62.18 142.93,62.25 U80.AM70
  BOTTOM w0.147: 169.33,68.53 169.33,68.05 169.08,67.8 169.03,67.8 168.82,67.6 168.49,67.6 168.44,67.55 168.22,67.55 168.03,67.37 v1(168.03,67.24) 168.03,67.16 168.18,67.01 168.49,67.01 v3(168.66,67.18)
M_A_DQS_DN*<1>: length 33.7
  IN2 w0.102: v3(166.96,70.57) 166.96,73.05 165.94,74.07 160.89,74.07 159.47,72.64 159.47,71.16 158.76,70.45 153.3,70.45 150.26,67.41 150.26,66.29 149.5,65.53 147.68,65.53 147.59,65.62 147.57,65.62 v3(147.21,65.98)
  BOTTOM w0.076: U80.AT69 142.76,64.85 143.03,64.85 143.15,64.97 143.34,64.97 143.38,65.01 143.59,65.01 143.6,65.02 143.66,65.02 143.67,65.04 143.97,65.04 144,65.01 144.05,65.01 144.08,64.99 144.54,64.99 144.74,65.18 146.3,65.18 147.1,65.98 v3(147.21,65.98)
  BOTTOM w0.147: USM2000.G11 166.96,70.59 v3(166.96,70.57)
M_A_DQS_DN*<2>: length 33.5
  IN1 w0.102: v3(164.93,70.49) 164.93,70.82 164.61,71.14 163.49,71.14 163.2,71.43 162.51,71.43 162.26,71.68 161.22,71.68 160.86,71.32 160.86,66.95 155.63,61.72 147.12,61.72 146.64,61.25 142.25,61.25 141.98,60.98 141.35,60.98 141.34,60.99 140.68,60.99 140.57,60.88 v3(140.57,60.61)
  BOTTOM w0.076: v3(140.57,60.61) U80.AH66
  BOTTOM w0.147: v3(164.93,70.49) 165.33,70.9 USM2000.D11
M_A_DQS_DN*<3>: length 49.3
  BOTTOM w0.076: 174.26,70.96 173.96,71.26 171.93,71.26 171.83,71.16 USM2000.P11 ; 145.11,60.02 145.09,59.99 144.12,59.99 144.11,60.01 144.05,60.01 144.04,60.02 143.99,60.02 143.96,60.04 143.68,60.04 143.65,60.01 143.59,60.01 143.53,59.94 142.76,59.94 U80.AG69
  BOTTOM w0.147: 174.26,70.96 174.5,70.72 174.5,70.72 174.58,70.64 174.58,70.63 174.67,70.55 174.67,67.19 170.27,62.79 168.69,62.79 168.38,62.48 168.38,62.04 168.23,61.89 167.94,61.89 167.79,62.04 167.79,62.48 167.47,62.79 166.94,62.79 166.63,62.48 166.63,62.04 166.48,61.89 166.18,61.89 166.04,62.04 166.04,62.48 165.72,62.79 165.19,62.79 164.87,62.48 164.87,62.04 164.73,61.89 164.43,61.89 164.28,62.04 164.28,62.48 163.97,62.79 163.44,62.79 163.12,62.48 163.12,62.04 162.97,61.89 162.68,61.89 162.53,62.04 162.53,62.48 162.22,62.79 161.68,62.79 161.37,62.48 161.37,62.04 161.22,61.89 160.93,61.89 160.78,62.04 160.78,62.48 160.46,62.79 159.56,62.79 156.27,59.51 151.57,59.51 151.09,59.03 146.09,59.03 145.66,59.46 145.66,59.55 145.2,60.02 145.11,60.02
M_A_DQS_DN*<4>: length 35.6
  BOTTOM w0.076: 158.6,83.17 158.58,83.19 158.53,83.19 158.48,83.24 156.05,83.24 155.88,83.07 155.88,82.45 USM2001.P11 ; 144.15,70.69 143.96,70.49 141.52,70.49 140.12,69.09 140.12,68.8 139.96,68.63 139.96,68.31 139.96,68.27 140.01,68.15 140.01,68.14 140.01,68.03 139.96,67.9 139.96,67.62 139.99,67.54 139.99,67.33 139.93,67.2 139.91,67.18 139.8,67.18 139.73,67.25 U80.BA64
  BOTTOM w0.147: 158.6,83.17 158.6,83.17 158.63,83.14 159.18,83.14 159.36,82.95 159.36,82.71 159.16,82.51 159.16,81.91 159.33,81.74 159.33,81.24 158.73,80.64 158.73,80.16 159.02,79.86 159.04,79.86 159.24,79.67 159.24,79.24 158.84,78.84 158.36,78.84 157.94,78.43 157.94,78.03 157.72,77.81 157.17,77.81 156.86,77.5 156.86,76.95 156.69,76.78 156.29,76.78 155.88,76.36 155.88,75.97 154.82,74.92 152.16,74.92 148.82,71.57 145.03,71.57 144.15,70.69
M_A_DQS_DN*<5>: length 26.9
  IN1 w0.102: v3(151.61,79.87) 151.85,79.63 151.85,79.54 151.76,79.45 148.01,79.45 147.91,79.55 147.5,79.55 147.34,79.38 147.1,79.38 146.99,79.49 146.99,79.59 v3(147.26,79.86)
  BOTTOM w0.076: v3(151.61,79.87) 151.75,80.01 151.75,80.53 151.95,80.73 151.95,81.15 151.92,81.18 151.92,81.54 151.8,81.66 151.48,81.66 151.19,81.95 151.19,81.97 151.03,82.13 USM2001.G11 ; U80.AY60 137.27,66.84 137.02,67.09 136.93,67.29 136.93,67.56 136.96,67.64 136.96,67.86 136.91,67.99 136.91,68.17 136.97,68.32 136.97,68.38 136.97,68.59 136.8,68.75 136.8,69.13 140.66,72.98 141.03,72.98 141.1,73.05 141.1,73.12
  BOTTOM w0.147: 141.1,73.12 145.08,77.09 145.33,77.34 145.33,77.49 146.52,78.68 146.52,79.06 146.97,79.51 147.05,79.51 147.2,79.65 147.2,79.81 147.24,79.85 147.24,79.86 v3(147.26,79.86)
M_A_DQS_DN*<6>: length 38
  IN1 w0.076: v3(141.38,64.36) 141.04,64.02 140.24,64.02
  IN1 w0.102: 140.24,64.02 140.02,64.24 140.02,64.55 139.85,64.72 139.85,67.66 138.75,68.77 138.75,69.11 136.9,70.96 136.9,73.52 138.19,74.82 138.19,75.38 137.88,75.69 137.88,77.27 139.03,78.41 139.19,78.41 143.8,78.41 144.31,77.9 150.9,77.9 151.02,78.02 151.99,78.02 v3(152.38,77.63)
  IN2 w0.102: v3(153.98,81.79) 153.91,81.72 153.91,79.85 152.23,78.18 152.23,77.78 v3(152.38,77.63)
  BOTTOM w0.076: U80.AR66 141.02,63.99 v3(141.38,64.36)
  BOTTOM w0.147: v3(153.98,81.79) 153.98,81.8 USM2001.L11
