# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ILIM_LO: length 2.2
  TOP w0.102: EU1B2.15 204.86,19.12 R1M5.2
ILIMVRH3: length 6.6
  TOP w0.079: v1(66.64,82.2) 66.64,82.37 PR147.2 66.93,83.27
  TOP w0.102: 66.93,83.27 66.56,83.64 66.37,83.64 v1(66.24,83.78)
  IN1 w0.079: v4(68.46,79.19) 68.46,79.72 66.64,81.54 v1(66.64,82.2)
  BOTTOM w0.102: v4(68.46,79.19) 68.46,79.49 68.47,79.5 PU3254.E12
ILIMVRH5: length 10
  TOP w0.102: v4(71,76.63) 71.13,76.5 v1(71.13,76) 71.13,75.97 70.96,75.8 70.96,75.56 71.03,75.49 71.03,74.69 71.61,74.11 71.61,73.02 71.86,72.77 71.96,72.77 72.43,72.3 72.74,72.3 72.97,72.52 76.4,72.52 76.5,72.63 PR138.2
  BOTTOM w0.102: v4(71,76.63) 70.97,76.61 PU3254.M7
ILIMVRL3: length 6.9
  TOP w0.102: PR170.1 66.9,84.62 v1(67.06,84.46)
  IN1 w0.079: v4(69.51,80.16) 69.32,80.34 69.32,80.89 68.93,81.29 68.93,81.78 68.71,81.99 68.71,82.81 v1(67.06,84.46)
  BOTTOM w0.102: PU3254.E10 69.47,79.91 69.51,79.95 v4(69.51,80.16)
IMVP8_PROCHOT*: length 4.4
  TOP w0.102: v1(202.05,39.25) 201.82,39.25 201.44,39.63 200.7,39.63 200.35,39.28 PR63.1 200.1,39.18 198.97,38.05 PU5.38
IMVP_PSYS: length 4.9
  TOP w0.203: PU5.1 197.8,39.93 v1(198.37,40.5)
  TOP w0.381: v1(198.37,40.5) 198.54,40.67 v1(199.45,40.67) PR42.1
  BOTTOM w0.203: PC9123.2 PR165.2 198.66,40.21 v1(198.37,40.5)
IMVP_SVID_CLK: length 4.1
  TOP w0.102: PR164.1 201.87,38.39 201.47,37.98 200.8,37.98 TP127.1 199.56,38.23 198.98,37.65 PU5.37
IMVP_SVID_DATA: length 4.6
  TOP w0.102: PR158.1 202.65,36.86 200.42,36.86 200.09,37.19 TP125.1 199.41,37.19 199.07,36.85 PU5.35
INT_HDMICLK+_C: length 5.4
  TOP w0.102: L19.2 15.2,47.59 14.95,47.84 14.83,47.84 14.55,47.56 14.24,47.56 14.18,47.5 D61.4 D61.7 12.52,47.5 12.46,47.56 12.08,47.56 11.32,48.32 11.15,48.32 CN12.10
INT_HDMICLK+_IC: length 1.9
  TOP w0.102: C983.2 23.86,46.26 23.07,46.26 22.98,46.17 U26.9
INT_HDMICLK+_LS: length 3.7
  TOP w0.102: L19.1 17.7,47.59 17.95,47.84 18.13,47.84 18.33,47.64 18.33,46.75 18.89,46.19 19.19,46.19 19.22,46.17 U26.19
INT_HDMICLK-_C: length 5.5
  TOP w0.102: CN12.12 11.15,48.68 11.46,48.68 12.23,47.91 12.45,47.91 12.54,48 D61.6 D61.5 14.21,48 14.29,47.91 14.4,47.91 14.68,48.19 14.93,48.19 15.17,48.44 L19.3
INT_HDMICLK-_IC: length 1.9
  TOP w0.102: U26.10 22.96,46.57 23.06,46.47 23.86,46.47 C151.2
INT_HDMICLK-_LS: length 3.7
  TOP w0.102: U26.18 19.19,46.57 19.17,46.54 19.04,46.54 18.69,46.9 18.69,47.79 18.28,48.19 17.92,48.19 17.68,48.44 L19.4
INT_HDMITX0N_C: length 9.7
  TOP w0.102: L18.3 15.2,46.41 15.03,46.24 14.77,46.24 14.59,46.41 14.24,46.41 14.16,46.5 D61.2 D61.9 12.56,46.5 12.48,46.41 12.31,46.41 v1(12.16,46.57)
  IN1 w0.079: CN12.3 9.7,44.13 9.93,44.13 10.66,43.39 11.14,43.39 11.4,43.64 11.4,46.06 11.7,46.36 11.96,46.36 v1(12.16,46.57)
INT_HDMITX0N_IC: length 4.8
  TOP w0.102: U26.7 22.99,45.37 23.08,45.27 23.67,45.27 23.74,45.35 26.07,45.35 26.37,45.05 26.56,45.05 C982.2
INT_HDMITX0N_LS: length 2.8
  TOP w0.102: L18.4 17.7,46.41 17.95,46.16 18.23,46.16 19.05,45.34 19.17,45.34 19.19,45.37 U26.21
INT_HDMITX0P_C: length 9.6
  TOP w0.102: v1(12.16,45.96) 12.16,45.96 12.26,46.06 12.51,46.06 12.57,46 D61.10 D61.1 14.19,46 14.25,46.06 14.44,46.06 14.62,45.88 14.9,45.88 15.23,45.56 L18.2
  IN1 w0.079: v1(12.16,45.96) 12.06,46.06 11.83,46.06 11.7,45.93 11.7,43.52 11.27,43.08 10.54,43.08 9.8,43.82 9.65,43.82 CN12.1
INT_HDMITX0P_IC: length 4.7
  TOP w0.102: C981.2 26.6,44.84 26.28,44.84 25.98,45.14 23.83,45.14 23.75,45.06 23.07,45.06 22.98,44.97 U26.6
INT_HDMITX0P_LS: length 2.8
  TOP w0.102: L18.1 17.63,45.56 17.87,45.8 18.08,45.8 18.9,44.99 19.2,44.99 19.22,44.97 U26.22
INT_HDMITX1N_C: length 6.5
  TOP w0.102: CN12.6 11.15,45.68 11.62,45.68 12.03,45.27 12.03,44.05 12.24,43.85 12.46,43.85 12.55,43.93 D60.6 D60.5 14.2,43.93 14.24,43.98 14.85,43.98 15.12,44.25 L17.3
INT_HDMITX1N_IC: length 2
  TOP w0.102: C141.2 23.87,44.26 23.6,44.26 23.39,44.47 23.07,44.47 22.97,44.57 U26.5
INT_HDMITX1N_LS: length 2.7
  TOP w0.102: L17.4 17.6,44.25 17.85,44 17.96,44 18.5,44.54 19.18,44.54 19.2,44.57 U26.23
INT_HDMITX1P_C: length 6.5
  TOP w0.102: CN12.4 11.15,45.32 11.48,45.32 11.68,45.12 11.68,43.9 12.09,43.49 12.53,43.49 12.59,43.43 D60.7 D60.4 14.21,43.43 14.39,43.62 14.83,43.62 15.05,43.4 L17.2
INT_HDMITX1P_IC: length 2
  TOP w0.102: C139.2 23.86,44.05 23.51,44.05 23.3,44.26 23.09,44.26 22.99,44.17 U26.4
INT_HDMITX1P_LS: length 2.7
  TOP w0.102: U26.24 19.21,44.17 19.19,44.19 18.65,44.19 18.1,43.64 17.9,43.64 17.65,43.4 L17.1
INT_HDMITX2N_C: length 10.6
  TOP w0.102: CN12.9 9.65,47.18 9.97,47.18 10.25,46.9 10.25,43.54 10.58,43.21 11.37,43.21 12.22,42.36 12.51,42.36 12.59,42.43 D60.9 D60.2 14.12,42.43 14.19,42.36 14.53,42.36 14.8,42.1 14.95,42.1 15.2,42.34 L16.3
INT_HDMITX2N_IC: length 3
  TOP w0.102: C984.2 23.85,41.91 23.69,41.91 23.56,42.04 23.56,42.94 23.23,43.27 23.03,43.27 22.94,43.37 U26.2
INT_HDMITX2N_LS: length 3.3
  TOP w0.102: U26.26 19.22,43.37 19.19,43.34 18.85,43.34 18.46,42.95 18.46,42.32 18.23,42.1 18,42.1 17.75,42.34 L16.4
INT_HDMITX2P_C: length 10.6
  TOP w0.102: CN12.7 9.65,46.82 9.83,46.82 9.9,46.75 9.9,43.4 10.44,42.86 11.22,42.86 12.07,42.01 12.51,42.01 12.59,41.93 D60.10 D60.1 14.14,41.93 14.22,42.01 14.38,42.01 14.65,41.74 14.98,41.74 15.23,41.49 L16.2
INT_HDMITX2P_IC: length 3
  TOP w0.102: U26.1 22.96,42.97 23.06,43.06 23.14,43.06 23.35,42.85 23.35,41.95 23.61,41.7 23.85,41.7 C129.2
INT_HDMITX2P_LS: length 3.3
  TOP w0.102: U26.27 19.22,42.97 19.19,42.99 18.99,42.99 18.81,42.81 18.81,42.18 18.38,41.74 17.98,41.74 17.73,41.49 L16.1
ISEN1_B: length 6.8
  TOP w0.203: PU5.9 194.6,40.04 193.99,40.65 v1(193.9,40.65) 193.85,40.69 193.85,41.33 193.75,41.42 193.75,42.03 193.4,42.38 PR10.1 192.98,42.61 v1(192.98,43.05)
  BOTTOM w0.203: v1(192.98,43.05) 193.07,42.97 PC1328.1 ; v1(192.98,43.05) 193.17,43.24 PR93.2 ; v1(192.98,43.05) 192.37,43.67 PR95.2
ISEN2_B: length 14.7
  TOP w0.203: PR96.2 192.06,43.05 v1(192.07,43.04) 192.25,42.86 PR11.1 191.87,42.38 191.41,41.92 v1(191.41,41.82) 191.41,41.66 191.97,41.1 192.49,41.1 193.36,40.22 193.68,40.22 193.71,40.19 193.9,40.19 194.2,39.89 PU5.10
  IN2 w0.203: v1(197.63,44.96) 197.6,44.93 196.3,44.93 193.92,42.56 192.52,42.56 192.07,43 v1(192.07,43.04)
  BOTTOM w0.203: PR94.2 197.53,45.06 v1(197.63,44.96) ; PC1327.1 192.06,43.03 v1(192.07,43.04)
ISL_ACIN_SNS: length 4.5
  TOP w0.254: PC1298.1 PR176.2 49.46,29.62 v1(49.55,29.7) 49.62,29.78 PR179.1
  BOTTOM w0.203: v1(49.55,29.7) 49.57,29.67 49.57,29.58 49.38,29.38 PU4.19
ISL_ACOK: length 5
  BOTTOM w0.178: PR47.2 53.95,30.3 53.54,29.88 53.54,29.47 53.38,29.32 52.82,29.32 52.06,28.56 51.62,28.56 51.38,28.32 PU4.24
  BOTTOM w0.203: v1(54.81,30.6) PR47.2
ISL_BAT_SRN: length 5.8
  TOP w0.203: PC1259.1 52.13,23.32 v1(52.44,23.63)
  BOTTOM w0.178: PU4.1 51.38,23.96 51.71,23.63 v1(52.44,23.63) 52.16,23.35 PC1258.2 53.05,23.03 PR126.1 53.76,23.75 v1(53.76,24.54)
ISL_BAT_SRP: length 5.5
  TOP w0.203: PC1260.1 50.85,23.34 v1(51.55,22.64)
  BOTTOM w0.178: PR127.1 52.6,22.69 PC1258.1 51.94,22.25 v1(51.55,22.64) 51.34,22.85 51.34,22.98 v1(51.17,23.15) 50.98,23.34 PU4.2
ISL_BDET: length 4.2
  TOP w0.203: v1(52.36,29.67) PR92.1 53.31,28.86 PR22.2 53.32,28.14 v1(53.06,27.88)
  BOTTOM w0.203: PU4.25 52.75,27.57 v1(53.06,27.88)
ISL_BGDRV: length 12
  IN2 w0.305: v1(52.38,24.25) 52.38,24.58 52.6,24.79 53.78,24.79 54.03,24.54 55.6,24.54 57.02,25.96 57.02,28.91 v1(57.04,28.94)
  BOTTOM w0.203: PU4.32 51.88,24.76 v1(52.38,24.25)
  BOTTOM w0.381: v1(57.04,28.94) 57.04,29.22 56.67,29.59 PC9122.2 57.22,29.93 57.37,29.78 PQ1.4
ISL_BOOST_BOOT: length 3.7
  BOTTOM w0.203: PU4.4 50.18,23.63 50.32,23.49 50.32,22.93 v1(49.92,22.53) 49.52,22.13 48.55,22.13 PC1261.2
ISL_BOOST_LG: length 14.4
  IN2 w0.711: v5(54.68,13.7) 51.6,13.7 51.05,14.25 51.05,18.75 48.16,21.64 48.16,23.14 48.42,23.41 v5(48.42,23.45)
ISL_BOOST_PHASE: length 14.1
  IN2 w0.711: v5(49.07,22.7) 49.07,22.11 52.37,18.81 52.37,17.03 52.8,16.6 54.65,16.6 v5(54.73,16.68)
  BOTTOM w0.203: v5(49.07,22.7) 49.08,22.72 49.08,23.55 49.38,23.84 PU4.6
  BOTTOM w0.254: v5(49.07,22.7) 49.04,22.73 48.13,22.73 PC1261.1 47.41,22.49 47.41,23.05 v1(47.62,23.25)
ISL_BOOST_UG: length 7.4
  IN2 w0.711: v5(53.51,17.53) 53.51,19.07 50.98,21.59 50,22.58 50,23.06 v5(49.7,23.35)
ISL_BUCK_BOOT: length 3.3
  TOP w0.305: v1(46.14,26.86) 46.57,26.43 PC1262.2
  BOTTOM w0.203: PU4.12 47.63,25.97 46.74,26.86 v1(46.14,26.86)
ISL_BUCK_LG:
  vias: v1(46.33,22.76)
ISL_BUCK_PHASE: length 0.8
  TOP w0.305: PC1262.1 46.33,25.28 v1(45.94,25.67)
  vias: v1(46.4,25.03)
ISL_BUCK_UG:
  vias: v1(46.55,26.3)
ISL_COMP: length 3.4
  TOP w0.203: PC9094.2 53.02,26.12 53.29,26.38 v1(53.29,26.38) 53.62,26.38 54.02,26.78 PR133.2
  BOTTOM w0.203: PU4.28 53.28,26.37 v1(53.29,26.38)
ISL_CSIN: length 8.4
  TOP w0.305: PC1283.2 v1(44.77,30.97) 44.77,31.02 44.94,31.19 v1(45.41,31.19)
  BOTTOM w0.203: PR124.1 45.41,31.47 v1(45.41,31.19) 45.89,30.71 46.11,30.71 PC1263.2 46.58,30.25 46.58,27.85 47.65,26.77 PU4.14
ISL_CSIP: length 8.6
  TOP w0.305: PC1284.2 46.04,31.67 v1(46.04,31.25)
  BOTTOM w0.203: PR125.1 46.3,32.46 46.3,31.64 46.04,31.39 v1(46.04,31.25) 46.65,31.25 v1(46.7,31.2) 47.22,30.68 PC1263.1 47.22,30.14 46.91,29.83 46.91,27.95 47.68,27.17 PU4.15
ISL_DCIN: length 3.8
  TOP w0.203: v1(47.59,26.25) 47.59,26.42 47.22,26.8 PC1189.1 47.21,27.11 PR128.1 47.52,28.48 v1(47.9,28.48)
  BOTTOM w0.203: PU4.17 48.26,28.07 47.9,28.43 v1(47.9,28.48)
ISL_HOT*: length 3.6
  BOTTOM w0.178: PU4.23 50.98,28.43 51.46,28.91 51.93,28.91 v1(52.82,29.8) 52.98,29.96 PR46.2
ISL_OTGEN: length 3.2
  TOP w0.254: PR110.2 50.65,29.61 v1(50.25,29.61)
  BOTTOM w0.203: PU4.20 49.78,28.95 50.25,29.42 v1(50.25,29.61)
ISL_PGM: length 2.2
  TOP w0.203: v1(53.28,26.99) 53.18,27.1 52.67,27.1 PR178.2
  BOTTOM w0.203: PU4.27 52.99,26.77 53.21,26.99 v1(53.28,26.99)
ISL_PSYS: length 6.3
  BOTTOM w0.203: PU4.30 52.76,25.57 53.07,25.26 53.49,25.26 53.83,25.59 53.83,27.27 54.07,27.52 v1(54.07,27.64) PR43.2
ITCH_SPI_CLK: length 6.7
  BOTTOM w0.076: U80.M2 104.02,51.79 103.89,51.79 103.64,51.68 103.57,51.65 103.4,51.6 100.91,51.6 100.77,51.73 98.93,51.73 98.91,51.72 98.9,51.72
  BOTTOM w0.102: 98.9,51.72 98.8,51.72 98.1,51.02 TP137.1
ITCH_SPI_CS*: length 8.7
  BOTTOM w0.076: U80.M1 103.32,51.75 100.97,51.75 100.79,51.93 98.9,51.93
  BOTTOM w0.102: TP142.1 96.08,50.3 96.54,50.76 97.39,50.76 98.56,51.93 98.9,51.93
ITCH_SPI_IO2: length 7.1
  BOTTOM w0.102: U80.V1 103.29,55.26 103.07,55.48 98.8,55.48 98.67,55.61 98.62,55.61 97.58,56.65 TP140.1
ITCH_SPI_IO3: length 9.4
  BOTTOM w0.076: 102.93,55.66 103.12,55.66 103.26,55.53 104.23,55.53 U80.V2
  BOTTOM w0.102: TP141.1 96.39,57.13 97.42,57.13 98.71,55.84 99.94,55.84 100.12,55.66 102.93,55.66
ITCH_SPI_MISO: length 9.1
  BOTTOM w0.076: U80.M3 104.6,51.94 104.28,51.63 103.92,51.63 103.69,51.53 103.44,51.42 103.29,51.42
  BOTTOM w0.102: 103.29,51.42 100.78,51.42 100.65,51.54 99,51.54 98.52,51.06 98.52,50.53 98.24,50.25 97,50.25 TP138.1
ITCH_SPI_MOSI: length 6.6
  BOTTOM w0.102: U80.J4 105.19,50.34 102.11,50.34 101.9,50.55 99.71,50.55 TP139.1
JACK_PLUG_DETECT_L: length 8.3
  TOP w0.102: R1D7.2 16.48,19.47 16.44,19.51 D50.1 14.74,19.51 v1(14.66,19.42) 14.57,19.34 11.37,19.34 10.23,18.2 J1C1.6
KB_COL2_SW: length 21.7
  TOP w0.102: v1(147.06,22.94) 146.88,22.77 R5068.2 ; v1(132.29,24.47) CRCP4011.7 CRCP4011.4 132.29,20.54 v1(132.46,20.38)
  IN1 w0.079: v1(147.06,22.94) 147.05,22.95 144.92,22.95 144.92,22.94 133.82,22.94 v1(132.29,24.47)
  BOTTOM w0.102: v1(132.46,20.38) 132.3,20.53 132.3,21.6 JCP4056.17
KB_COL[0]: length 79.2
  TOP w0.102: v1(111.96,18.8) 111.65,19.11 v1(111.65,21) 111.65,22.89 112.54,23.78 113.02,23.78 115.19,25.95 133.13,25.95 135.6,23.48 CRCP4010.7 CRCP4010.4 135.6,20.41 v1(135.63,20.38)
  IN2 w0.079: v1(79.29,37.17) 79.2,37.07 79.2,33.96 79.75,33.41 79.75,32.6 83.37,28.98 85.06,28.98 85.67,28.36 86.8,28.36 87.54,27.62 87.54,26.05 88.72,24.87 89.51,24.87 91.42,22.96 92.61,22.96 95.96,19.61 97.2,19.61 97.47,19.35 104.67,19.35 105.09,18.93 111.83,18.93 v1(111.96,18.8)
  BOTTOM w0.102: v1(79.29,37.17) 79.21,37.09 EUPM3247.B16 ; JCP4056.13 135.5,21.6 135.5,20.51 v1(135.63,20.38)
KB_COL[1]: length 64
  TOP w0.102: v1(114.19,19.62) 114.01,19.79 114.01,21.06 114.29,21.34 114.7,21.34 117.27,23.91 125.31,23.91 126.06,23.16 CRCP4043.6 CRCP4043.5 126.06,20.83 v1(126.51,20.38)
  IN2 w0.079: v1(79.59,34.81) 79.5,34.71 79.5,33.91 79.93,33.48 79.93,32.67 83.45,29.16 86.67,29.16 87.73,28.1 87.73,26.12 88.8,25.05 89.59,25.05 91.49,23.14 92.69,23.14 96.03,19.79 97.28,19.79 97.54,19.53 104.82,19.53 105.22,19.13 110.26,19.13 110.33,19.21 112.23,19.21 112.57,18.88 113.45,18.88 v1(114.19,19.62)
  BOTTOM w0.102: v1(126.51,20.38) 126.7,20.57 126.7,21.6 JCP4056.24 ; v1(79.59,34.81) 79.46,34.94 EUPM3247.A15
KB_COL[2]: length 95.1
  TOP w0.102: v1(114.55,20.81) 114.9,20.45 v1(114.9,19.07) 114.9,17.69 116.27,16.31 117.27,16.31 120.3,19.34 122.5,19.34 v1(123.51,20.35) ; v1(150.39,23.53) 150.74,23.89 150.74,25.28 150.54,25.48 149.42,25.48 149.21,25.7 R5063.2
  IN1 w0.079: v1(150.39,23.53) 149.57,22.72 147.46,22.72 147.27,22.52 141.67,22.52 140.56,21.41 124.57,21.41 v1(123.51,20.35)
  IN2 w0.079: v1(79.71,37.65) 79.71,36.24 79.99,35.96 79.99,34.64 79.68,34.33 79.68,33.99 80.11,33.56 80.11,32.75 82.99,29.87 83.45,29.87 83.63,30.06 84.11,30.06 84.79,29.37 86.71,29.37 87.91,28.18 87.91,26.2 88.87,25.23 89.66,25.23 91.57,23.32 92.76,23.32 96.11,19.97 97.35,19.97 97.62,19.71 104.9,19.71 105.27,19.34 110.2,19.34 110.28,19.41 112.31,19.41 112.64,19.08 113.2,19.08 113.76,19.64 113.76,20.02 v1(114.55,20.81)
  BOTTOM w0.102: EUPM3247.B15 v1(79.71,37.65)
KB_COL[3]: length 71.5
  TOP w0.102: v1(112.29,19.82) 112.54,20.07 112.54,22.19 115.68,25.34 132.02,25.34 132.79,24.56 CRCP4011.6 CRCP4011.5 132.79,20.67 v1(133.11,20.35)
  IN2 w0.079: v1(80.07,34.17) 80.29,33.96 80.29,33.02 81.94,31.37 83.05,31.37 83.69,30.72 84.87,29.55 86.79,29.55 88.09,28.25 88.09,26.27 88.95,25.41 89.74,25.41 91.64,23.5 92.84,23.5 96.18,20.15 97.43,20.15 97.69,19.89 104.97,19.89 105.3,19.57 110.18,19.57 110.48,19.87 112.23,19.87 v1(112.29,19.82)
  BOTTOM w0.102: JCP4056.16 133.1,21.6 133.1,20.36 v1(133.11,20.35) ; EUPM3247.A14 79.96,35.2 80.07,35.09 v1(80.07,34.17)
KB_COL[4]: length 70.5
  TOP w0.102: v1(112.82,19.51) 112.95,19.39 113.5,19.39 113.78,19.67 113.78,22.58 115.93,24.73 128.49,24.73 129.49,23.72 CRCP4014.6 CRCP4014.5 129.49,20.78 v1(129.9,20.37)
  IN2 w0.079: v1(112.82,19.51) 112.82,19.87 112.42,20.27 110.52,20.27 110.05,19.79 105.32,19.79 105.05,20.07 97.77,20.07 97.5,20.33 96.26,20.33 92.91,23.68 91.72,23.68 89.81,25.59 89.02,25.59 88.27,26.34 88.27,28.33 86.86,29.73 84.94,29.73 83.82,30.85 83.12,31.55 82.01,31.55 80.47,33.09 80.47,36.07 80.13,36.41 v1(80.13,37.17)
  BOTTOM w0.102: JCP4056.20 129.9,21.6 v1(129.9,20.37) ; v1(80.13,37.17) 80.21,37.09 EUPM3247.B14
KB_COL[5]: length 72.4
  TOP w0.102: v1(113.35,19.82) 113.56,20.02 113.56,22.64 115.85,24.93 129.53,24.93 130.79,23.66 CRCP4011.10 CRCP4011.1 130.79,20.63 v1(130.51,20.35)
  IN2 w0.079: v1(80.45,37.69) 80.52,37.61 80.52,36.41 80.65,36.28 80.65,33.17 82.09,31.73 83.2,31.73 83.95,30.98 85.02,29.91 86.94,29.91 88.45,28.4 88.45,26.42 89.1,25.77 89.89,25.77 91.79,23.86 92.99,23.86 96.33,20.51 99.23,20.51 99.62,20.9 101.01,20.9 101.53,20.38 105.05,20.38 105.43,19.99 109.89,19.99 110.35,20.45 112.73,20.45 v1(113.35,19.82)
  BOTTOM w0.102: EUPM3247.B13 80.71,36.82 80.54,36.99 80.54,37.6 v1(80.45,37.69) ; JCP4056.19 130.7,21.6 130.7,20.54 v1(130.51,20.35)
KB_COL[6]: length 62.4
  TOP w0.102: v1(114.5,21.79) 115.16,22.45 115.16,23.14 116.34,24.32 127.06,24.32 127.99,23.39 CRCP4014.9 CRCP4014.2 127.99,20.61 v1(127.76,20.38)
  IN2 w0.079: v1(114.5,21.79) 113.98,21.79 112.92,20.73 110.33,20.73 109.77,20.17 105.53,20.17 105.14,20.56 101.61,20.56 101.08,21.08 99.55,21.08 99.16,20.69 96.41,20.69 93.06,24.04 92.04,24.04 88.63,27.45 88.63,28.48 87.01,30.09 85.09,30.09 83.36,31.82 81.24,33.94 v1(81.24,34.17)
  BOTTOM w0.102: v1(81.24,34.17) 80.46,34.95 EUPM3247.A13 ; JCP4056.22 128.3,20.92 v1(127.76,20.38)
KB_COL[7]: length 61.8
  TOP w0.102: v1(127.12,20.39) 127.49,20.76 CRCP4014.1 CRCP4014.10 127.49,23.39 126.76,24.12 116.89,24.12 v1(115.56,22.79)
  IN2 w0.079: v1(81.38,34.82) 81.64,34.57 81.64,33.8 85.17,30.27 87.09,30.27 88.81,28.55 88.81,27.53 92.12,24.22 93.14,24.22 96.48,20.87 99.08,20.87 99.47,21.26 101.16,21.26 101.68,20.74 103.4,20.74 103.84,21.18 106.63,21.18 107.46,20.35 109.54,20.35 110.18,20.99 112.87,20.99 113.57,21.69 113.57,22.42 113.78,22.64 114.24,22.64 114.47,22.41 115.18,22.41 v1(115.56,22.79)
  BOTTOM w0.102: v1(81.38,34.82) 80.96,35.24 EUPM3247.A12 ; v1(127.12,20.39) 127.5,20.77 127.5,21.6 JCP4056.23
KB_ROW2_SW: length 21.3
  TOP w0.102: v1(149.7,23.68) 149.73,23.68 R5072.1 ; v1(136.3,20.38) 136.09,20.59 CRCP4010.5 CRCP4010.6 136.09,23.77 v1(135.43,24.44)
  IN1 w0.079: v1(135.43,24.44) 136.52,23.34 149.36,23.34 v1(149.7,23.68)
  BOTTOM w0.102: v1(136.3,20.38) 136.3,21.6 JCP4056.12
KB_ROW[0]: length 68
  TOP w0.102: v1(113.07,21.79) 113.07,22.44 115.77,25.13 129.71,25.13 131.29,23.55 CRCP4011.9 CRCP4011.2 131.29,20.55 v1(131.12,20.38)
  IN2 w0.079: v1(113.07,21.79) 110.6,21.79 109.72,20.91 108.86,20.91 108.41,21.36 103.77,21.36 103.37,20.96 101.72,20.96 101.23,21.44 99.4,21.44 99.01,21.05 96.56,21.05 93.21,24.4 92.19,24.4 88.99,27.6 88.99,28.63 87.16,30.45 85.24,30.45 81.82,33.88 81.82,35.78 80.94,36.66 v1(80.94,37.17)
  BOTTOM w0.102: EUPM3247.B12 81.21,36.9 v1(80.94,37.17) ; v1(131.12,20.38) 131.5,20.76 131.5,21.6 JCP4056.18
KB_ROW[1]: length 68.6
  TOP w0.102: v1(134.39,20.35) 134.59,20.56 CRCP4010.2 CRCP4010.9 134.59,23.52 132.37,25.74 115.27,25.74 113.11,23.58 112.62,23.58 112.06,23.01 v1(112.06,22.18)
  IN2 w0.079: v1(82.21,34.4) 82.21,33.74 85.32,30.63 87.24,30.63 89.17,28.7 89.17,27.68 92.27,24.58 93.29,24.58 96.6,21.26 98.96,21.26 99.32,21.62 101.31,21.62 101.79,21.14 103.29,21.14 103.74,21.59 107.61,21.59 107.78,21.76 110.32,21.76 110.74,22.18 v1(112.06,22.18)
  BOTTOM w0.102: v1(134.39,20.35) 134.7,20.67 134.7,21.6 JCP4056.14 ; EUPM3247.A11 81.46,35.37 82.21,34.61 v1(82.21,34.4)
KB_ROW[2]: length 82.7
  TOP w0.102: v1(103.09,21.57) 103.09,22.41 104.61,23.93 104.61,24.52 105.78,25.69 106.29,25.69 106.85,26.25 112.79,26.25 114.32,27.77 118.65,27.77 119.36,28.48 140.43,28.48 145.26,23.66 v1(146.09,23.66) 146.92,23.66 R5066.2
  IN2 w0.079: v1(103.09,21.57) 102.86,21.8 99.18,21.8 98.83,21.45 96.68,21.45 93.36,24.76 92.34,24.76 90.02,27.08 90.02,28.26 89.25,29.04 89.09,29.04 87.31,30.81 86.61,30.81 85.71,31.72 84.49,31.72 82.43,33.78 82.43,34.06 82.65,34.28 82.65,35.2 81.34,36.52 81.34,37.49 v1(81.06,37.77)
  BOTTOM w0.102: v1(81.06,37.77) 81.35,37.48 81.35,37.09 81.71,36.73 EUPM3247.B11
KB_ROW[3]: length 70.7
  TOP w0.102: v1(108.96,22.23) v1(110.13,23.4) 111.3,24.57 113.52,24.57 115.1,26.15 135.34,26.15 137.52,23.97 CRCP4009.10 CRCP4009.1 137.52,20.82 v1(137.1,20.39)
  IN2 w0.079: v1(82.85,33.92) 83.42,33.34 84.86,33.34 85.41,32.78 85.41,32.26 86.39,31.28 86.68,30.99 87.39,30.99 89.16,29.22 89.33,29.22 90.2,28.34 90.2,27.15 92.42,24.94 93.44,24.94 96.73,21.65 98.77,21.65 99.11,21.98 103.88,21.98 104.09,21.77 107.53,21.77 107.99,22.23 v1(108.96,22.23)
  BOTTOM w0.102: JCP4056.11 137.1,21.6 v1(137.1,20.39) ; v1(82.85,33.92) 82.85,34.37 81.96,35.26 EUPM3247.A10
KB_ROW[4]: length 68.9
  TOP w0.102: v1(133.75,20.37) 134.09,20.71 CRCP4010.1 CRCP4010.10 134.09,23.64 132.2,25.54 115.6,25.54 112.87,22.82 v1(112.46,22.82)
  IN2 w0.079: v1(81.78,37.24) 83.26,35.76 83.26,33.91 83.65,33.52 84.93,33.52 85.59,32.86 85.59,32.34 86.57,31.36 86.76,31.17 87.46,31.17 89.24,29.4 89.4,29.4 90.38,28.41 90.38,27.23 92.49,25.12 93.51,25.12 96.78,21.85 98.67,21.85 98.98,22.16 103.95,22.16 104.17,21.95 107.36,21.95 108.03,22.63 112.29,22.63 112.46,22.8 v1(112.46,22.82)
  BOTTOM w0.102: v1(81.78,37.24) 82.21,36.81 EUPM3247.B10 ; JCP4056.15 133.9,21.6 133.9,20.52 v1(133.75,20.37)
KB_ROW[5]: length 71.2
  TOP w0.102: v1(107.18,23.03) 107.18,23.04 109.12,24.98 113.35,24.98 114.93,26.55 136.16,26.55 139.02,23.69 CRCP4009.7 CRCP4009.4 139.02,21.55 139.5,21.08 139.5,20.39 v1(139.5,20.39)
  IN2 w0.079: v1(107.18,23.03) 107.18,22.89 106.49,22.21 104.17,22.21 104.03,22.34 98.83,22.34 98.54,22.05 96.83,22.05 94.41,24.48 94.41,25.7 92.87,27.24 92.47,27.24 91.27,28.43 91.27,28.76 87.71,32.33 86.72,32.33 86.17,32.88 86.04,32.88 85.22,33.7 84.03,33.7 v1(83.66,34.07)
  BOTTOM w0.102: v1(83.66,34.07) 82.46,35.27 EUPM3247.A9 ; v1(139.5,20.39) 139.5,21.6 JCP4056.8
KB_ROW[6]: length 69
  TOP w0.102: v1(106.58,22.87) 106.87,22.59 107.75,22.59 v1(108.84,23.68) 109.94,24.77 113.44,24.77 115.02,26.35 135.6,26.35 138.02,23.93 CRCP4009.9 CRCP4009.2 138.02,20.53 v1(138.17,20.38)
  IN2 w0.079: v1(106.58,22.87) 106.15,22.44 104.19,22.44 104.1,22.52 98.71,22.52 98.44,22.26 96.89,22.26 94.59,24.55 94.59,25.77 92.94,27.42 92.54,27.42 91.45,28.51 91.45,28.86 87.81,32.51 86.79,32.51 86.25,33.06 86.12,33.06 84.98,34.2 v1(84.68,34.2)
  BOTTOM w0.102: v1(84.68,34.2) 83.96,34.92 EUPM3247.A6 ; v1(138.17,20.38) 138.7,20.91 JCP4056.9
KB_ROW[7]: length 60.8
  TOP w0.102: v1(114.72,22.8) 114.72,23.1 116.15,24.52 128.23,24.52 128.99,23.76 CRCP4014.7 CRCP4014.4 128.99,20.49 v1(129.1,20.38)
  IN2 w0.079: v1(114.72,22.8) 114.05,23.48 112.44,23.48 111.78,22.82 108.27,22.82 107.64,23.45 106.59,23.45 105.78,22.64 104.24,22.64 104.18,22.71 98.61,22.71 98.37,22.46 96.94,22.46 94.77,24.63 94.77,25.85 93.02,27.6 92.62,27.6 91.63,28.58 91.63,28.96 87.9,32.69 86.87,32.69 86.3,33.26 86.17,33.26 85.04,34.39 85.04,35.31 84.24,36.1 v1(84.24,37.17)
  BOTTOM w0.102: v1(129.1,20.38) 129.1,21.6 JCP4056.21 ; v1(84.24,37.17) 84.21,37.13 EUPM3247.B6
KB_ROW[8]: length 75.7
  TOP w0.102: v1(144.11,20.34) 144.11,20.34 144.11,20.81 144.49,21.18 CRCP4008.4 CRCP4008.7 144.49,23.69 140.1,28.07 119.53,28.07 118.82,27.37 114.49,27.37 112.91,25.79 107.11,25.79 105.5,24.18 105.5,23.69 v1(104.87,23.05)
  IN2 w0.079: v1(104.87,23.05) 104.66,23.27 100.5,23.27 100.12,22.89 98.49,22.89 98.26,22.66 96.99,22.66 94.95,24.7 94.95,25.92 93.09,27.78 92.69,27.78 91.81,28.66 91.81,29.04 87.98,32.87 86.94,32.87 86.38,33.44 86.24,33.44 85.43,34.25 v1(85.43,34.63)
  BOTTOM w0.102: EUPM3247.A4 84.96,35.28 85.43,34.81 v1(85.43,34.63) ; JCP4056.2 144.3,21.6 144.3,20.77 144.11,20.58 v1(144.11,20.34)
KB_ROW[9]: length 79
  TOP w0.102: v1(142.82,20.35) 142.82,20.61 143.48,21.28 CRCP4008.2 CRCP4008.9 143.48,24.31 140.63,27.16 114.57,27.16 112.99,25.59 107.2,25.59 105.73,24.12 v1(105.73,23.18)
  IN2 w0.079: v1(83.98,37.75) 84.24,37.75 84.64,37.35 84.64,35.99 85.83,34.79 85.83,34.11 86.32,33.62 86.45,33.62 87.02,33.05 88.05,33.05 91.99,29.11 91.99,28.73 92.77,27.96 93.17,27.96 95.13,26 95.13,24.78 97.05,22.87 98.16,22.87 98.36,23.07 100.04,23.07 100.42,23.45 105.46,23.45 v1(105.73,23.18)
  BOTTOM w0.102: v1(83.98,37.75) 84.23,37.75 84.65,37.34 84.65,36.83 84.71,36.77 EUPM3247.B5 ; v1(142.82,20.35) 143.5,21.03 JCP4056.3
KB_ROW[10]: length 72
  TOP w0.102: v1(107.15,24.16) 108.17,25.18 113.16,25.18 114.74,26.76 136.46,26.76 139.52,23.7 CRCP4009.6 CRCP4009.5 139.52,21.72 140.86,20.38 v1(141.55,20.38)
  IN2 w0.079: v1(85.06,37.17) 85.06,35.82 86.01,34.87 86.01,34.18 86.39,33.8 86.53,33.8 87.09,33.23 88.15,33.23 89.02,32.37 89.52,32.37 94.34,27.54 94.34,27.04 95.31,26.07 95.31,24.85 97.09,23.07 98.11,23.07 98.29,23.25 99.97,23.25 100.35,23.63 106.62,23.63 v1(107.15,24.16)
  BOTTOM w0.102: v1(85.06,37.17) 85.21,37.02 EUPM3247.B4 ; JCP4056.5 141.9,21.6 141.9,20.73 v1(141.55,20.38)
KB_ROW[11]: length 72.2
  TOP w0.102: v1(142.18,20.35) 142.18,20.61 142.98,21.41 CRCP4008.1 CRCP4008.10 142.98,24.4 140.42,26.96 114.66,26.96 113.08,25.38 107.69,25.38 v1(106.49,24.19)
  IN2 w0.079: v1(106.49,24.19) 106.11,23.81 100.27,23.81 99.91,23.45 98.24,23.45 98.06,23.27 97.15,23.27 95.49,24.93 95.49,26.14 94.52,27.11 94.52,27.62 89.6,32.55 89.09,32.55 88.23,33.41 87.34,33.41 v1(86.41,34.35)
  BOTTOM w0.102: v1(142.18,20.35) 142.7,20.87 JCP4056.4 ; v1(86.41,34.35) 86.41,34.42 85.46,35.37 EUPM3247.A3
KB_ROW[12]: length 77.2
  TOP w0.102: v1(144.72,20.35) 144.72,20.61 144.72,20.61 144.98,20.87 CRCP4008.5 CRCP4008.6 144.98,23.54 140.25,28.28 119.44,28.28 118.74,27.57 114.4,27.57 112.82,25.99 107.03,25.99 106.44,25.41 106.27,25.41 v1(105.07,24.21)
  IN2 w0.079: v1(85.46,37.63) 85.46,36.07 87.87,33.66 88.23,33.66 89.16,32.73 89.67,32.73 94.71,27.69 94.71,27.19 95.67,26.22 95.67,25 97.2,23.48 97.99,23.48 98.14,23.63 99.84,23.63 100.32,24.11 104.97,24.11 v1(105.07,24.21)
  BOTTOM w0.102: EUPM3247.B3 85.71,36.87 85.51,37.07 85.51,37.57 v1(85.46,37.63) ; JCP4056.1 145.1,20.73 v1(144.72,20.35)
L_BKLT_EN: length 75.6
  IN1 w0.079: v3(109.78,54.27) 109.38,54.67 108.96,54.67 108.96,54.67 105.68,54.67 105.5,54.49 104.84,54.49 104.56,54.22 104.56,53.75 103.96,53.15 103.06,53.15 102.51,53.7 96.08,53.7 95.73,54.05 94.29,54.05 93.81,53.57 93.08,53.57 92.96,53.45 92.96,51.6 92.26,50.91 91.21,50.91 89.33,49.04 88.17,49.04 87.27,49.94 84.05,49.94 83.36,49.25 82.82,49.25 81.63,48.07 81.63,47.51 81.56,47.44 81.56,47.08 81.25,46.77 78.07,46.77 77.95,46.64 74.72,46.64 74.2,47.16 69.54,47.16 68.76,47.94 66.13,47.94 65.29,48.79 63.4,48.79 61.73,50.47 58.97,50.47 51.11,58.32 v1(50.44,58.32)
  BOTTOM w0.102: v1(50.44,58.32) 50.33,58.32 49.62,57.61 49.62,56.68 48.88,55.93 U111.1 ; U80.R12 110.15,53.9 v3(109.78,54.27)
L_BRIGHTNESS: length 85.2
  IN1 w0.079: v1(50.22,58.92) 49.98,58.68 49.98,57.57 50.28,57.27 51.66,57.27 59.5,49.43 62.08,49.43 63.14,48.37 63.14,46.92 65.06,45 66.15,45 66.54,45.39 70.33,45.39 71.14,44.58 72.74,44.58 73.58,43.75 74.67,43.75 75.14,44.22 77.99,44.22 78.36,43.86 79.46,43.86 79.59,43.73 84.38,43.73 84.62,43.97 85,43.97 85.48,44.45 88.15,44.45 90.95,47.25 90.95,47.86 91.41,48.32 91.41,48.88 91.1,49.18 91.1,50.04 91.79,50.73 92.34,50.73 93.96,52.35 96.61,52.35 97.77,53.52 102.44,53.52 102.99,52.97 104.36,52.97 105.91,54.52 108.84,54.52 v3(109.17,54.19)
  BOTTOM w0.102: U80.R11 109.5,53.86 v3(109.17,54.19) ; v1(50.22,58.92) 49.01,57.72 v1(49.01,57.32) 49.01,56.93 48.63,56.55 47.85,56.55 47.59,56.8 47.59,57.69 46.96,58.33 R619.2 47.23,58.73 47.69,58.73 48.6,59.65 49.01,59.65 49.4,60.03 J8L1.27
L_VDD_EN: length 91.7
  TOP w0.102: U8.3 42.45,57.76 42.64,57.95 R739.2 42.27,58.94 42.27,58.94 41.8,59.41 v1(41.8,59.65)
  IN1 w0.079: v1(41.8,59.65) 41.77,59.68 41.77,60.76 41.78,60.76 41.78,63.54 42.63,64.39 45.95,64.39 46.33,64.01 47.37,64.01 48.96,62.42 48.96,61.25 49.8,60.41 50.56,60.41 51.88,59.09 51.88,57.81 58.37,51.32 59.05,50.65 61.8,50.65 63.48,48.97 65.36,48.97 66.21,48.12 68.84,48.12 69.62,47.34 74.66,47.34 74.83,47.52 76.34,47.52 77.13,48.31 78.77,48.31 79.38,47.7 80.65,47.7 81.07,48.11 81.16,48.11 82.67,49.61 83.21,49.61 83.9,50.3 87.42,50.3 88.32,49.4 89.18,49.4 90.42,50.63 90.42,52.1 91.23,52.92 92.17,52.92 93,53.75 93.74,53.75 94.22,54.23 95.81,54.23 96.16,53.88 102.69,53.88 103.24,53.33 103.88,53.33 104.38,53.83 104.38,54.44 104.68,54.73 105.42,54.73 105.51,54.82 105.62,54.82 105.62,54.83 109.03,54.83 109.03,54.82 109.97,54.82 v3(110.44,55.29)
  BOTTOM w0.102: v3(110.44,55.29) 110.44,55.19 U80.U13
LCD_VCC:
  vias: v1(43.98,55.44) v1(44.4,55) v1(47.08,55.48)
LCD_VCC_OUT:
  vias: v1(46.17,57.56)
LID_OPEN: length 273.2
  TOP w0.102: R5118.1 178.47,90.05 C1106.1 v1(179.15,90.11)
  IN1 w0.079: v1(142.74,19.26) 143.1,18.91 144.62,18.91 144.89,19.18 154.4,19.18 155.62,20.4 160.27,20.4 161.78,21.91 164.02,21.91 164.97,20.96 182.57,20.96 183.18,20.35 191.19,20.35 191.33,20.5 191.33,20.98 191.08,21.24 190.42,21.24 189.52,22.14 189.52,24.49 190.86,25.83 204.99,25.83 206.64,27.48 211.4,27.48 212.33,28.42 212.33,29.66 212.17,29.83 206.85,29.83 203.52,33.16 203.52,35.78 201.55,37.75 201.26,37.75 200.73,38.29 200.73,39.12 202.27,40.66 202.27,44.47 196.98,49.75 196.98,56.64 193.05,60.57 193.05,63.44 187.42,69.07 187.42,75.29 185.62,77.1 178.43,77.1 176.24,79.28 176.24,87.21 v1(179.15,90.11)
  IN2 w0.079: v1(142.74,19.26) 142,18.52 121.56,18.52 120.78,19.3 117.08,19.3 113.98,16.21 113.27,16.21 110.94,13.88 107.15,13.88 107.03,14 103.71,14 103.57,14.14 102.01,14.14 101.84,13.97 99.66,13.97 99.19,14.43 v1(98.65,14.43) 98.4,14.19 94.71,14.19 94.42,14.48 94.22,14.48 90.95,17.75 88.71,17.75 84.77,21.69 83.67,21.69 79.98,25.38 78.67,25.38 74.31,29.74 v1(74.31,32.11) 73.86,32.56 73.86,33.77 72.84,34.79 72.84,37.27 72.09,38.02 72.09,39.58 71.18,40.49 71.18,42.76 v1(71.39,42.97)
  BOTTOM w0.102: D3.1 72.71,44.79 71.39,43.47 v1(71.39,42.97) ; v1(98.65,14.43) 98.73,14.52 CN17.44 ; C1027.2 79.05,33.48 77.62,33.48 76.24,32.11 v1(74.31,32.11)
LID_OPEN_C: length 5.4
  BOTTOM w0.102: D51.1 74.16,44.1 74.16,44.1 75.04,44.99 D3.2 76.29,44.99 76.55,45.25 77.74,45.25 77.94,45.04 EUPM3247.B34
LIMVRL5: length 2.1
  TOP w0.102: v4(71.47,75.16) 71.47,74.58 72.14,73.91 PR188.2
  BOTTOM w0.102: v4(71.47,75.16) PU3254.N6
LPC_CLKRUN*: length 86.3
  TOP w0.102: v3(103.97,74.26) 103.63,74.6 RAP1001.2
  IN2 w0.079: v1(76.47,42.68) 76.09,43.06 76.09,43.47 76.24,43.62 76.24,44.03 75.71,44.56 75.71,47.46 76.24,48 76.24,52.45 76.92,53.13 79.12,53.13 79.52,53.53 79.52,57.65 80.12,58.25 80.12,59.35 79.03,60.44 79.03,61.25 79.67,61.88 80.94,61.88 81.99,62.94 81.99,63.43 86.71,68.14 86.71,68.71 87.42,69.42 87.42,71.15 87.67,71.39 87.67,74.25 89.84,76.43 89.84,77.61 91.51,79.28 94.65,79.28 96,80.63 97.52,80.63 97.86,80.97 98.84,80.97 99.79,80.02 100.17,80.02 101.39,78.8 103.27,78.8 103.85,79.38 107.08,79.38 108.09,78.37 108.09,75.09 107.68,74.67 107.14,74.67 106.95,74.48 104.19,74.48 v3(103.97,74.26)
  BOTTOM w0.076: 107.41,69.77 107.76,69.77 108.16,69.38 108.76,69.38 108.94,69.56 109.17,69.56 109.4,69.33 109.4,68.27 109.46,68.21 109.46,67.96 109.4,67.92 109.38,67.87 109.37,67.78 109.41,67.62 109.43,67.59 109.45,67.53 109.48,67.43 109.48,67.29 109.48,67.27 109.46,67.19 109.46,66.93 109.52,66.87 109.69,66.7 U80.AW11
  BOTTOM w0.102: EUPM3247.A28 76.59,42.79 v1(76.47,42.68) ; v3(103.97,74.26) 104.77,73.46 104.95,73.46 105.22,73.19 105.22,72.93 v2(105.46,72.69) 106.16,71.99 106.16,70.46 106.85,69.77 107.41,69.77
LPC_FRAME*: length 70.9
  IN2 w0.079: v1(107.28,74.25) 107.21,74.18 104.58,74.18 104.3,73.89 103.79,73.89 103.06,74.62 103.06,76.42 102.27,77.21 100.69,77.21 100.16,77.74 99.57,77.74 98.35,78.96 96.29,78.96 95.22,77.89 92.41,77.89 91.93,77.4 91.93,76.55 89.32,73.95 89.32,71.57 89.41,71.49 89.41,68.88 83.38,62.85 83.38,62.36 81.64,60.63 81.64,57.81 80.91,57.07 80.91,52.64 81.28,52.27 81.28,49.85 80.71,49.28 80.33,49.28 79.51,48.46 79.51,46.81 78.41,45.71 78.41,43.7 77.87,43.15 77.87,42.78 78.91,41.74 v1(78.91,41.74)
  BOTTOM w0.076: U80.BA12 110.25,67.45 110.25,69.42 109.19,70.49 108.99,70.49 108.81,70.67
  BOTTOM w0.102: EUPM3247.B28 78.35,42.04 78.65,41.74 v1(78.91,41.74) ; v1(107.28,74.25) 107.5,74.04 107.5,72.68 107.92,72.26 107.92,71.56 108.81,70.67
LPC_LAD<0>: length 81.2
  IN2 w0.079: v1(98.44,80.01) 98.09,79.65 96.11,79.65 94.97,78.51 92.16,78.51 91.31,77.66 91.31,76.81 88.7,74.2 88.7,71.34 88.19,70.83 88.19,69.1 87.48,68.4 87.48,67.82 82.76,63.11 82.76,62.62 81.03,60.88 81.03,58.06 80.29,57.33 80.29,53.1 79.55,52.36 77.24,52.36 77.02,52.14 77.02,47.72 77.14,47.6 77.14,46.67 76.98,46.52 76.98,44.84 77.14,44.69 77.14,41.91 78.63,40.42 79.13,40.42 v1(79.62,39.92)
  BOTTOM w0.076: U80.AY13 110.84,67.27 110.94,67.37 111.05,67.51 111.11,67.67 111.11,67.81 111.05,68.04 111.05,68.18 111.1,68.3 111.1,68.58 111.01,68.68 111.01,69.69 109.5,71.2 109.34,71.2
  BOTTOM w0.102: v1(98.44,80.01) 98.73,80.3 100.06,80.3 101.08,79.28 101.08,79.05 101.31,78.82 101.74,78.82 101.92,79 101.92,79.48 102.22,79.78 103.18,79.78 103.35,79.96 106.91,79.96 107.94,78.93 107.94,75.45 108.21,75.18 108.21,73.12 108.67,72.66 108.67,71.86 109.34,71.2 ; EUPM3247.B25 78.46,40.54 78.61,40.39 79.15,40.39 v1(79.62,39.92)
LPC_LAD<1>: length 73.6
  IN2 w0.079: v1(107.28,75.37) 107,75.65 105.26,75.65 104.38,74.76 103.55,74.76 103.26,75.05 103.26,76.59 101.83,78.03 101.02,78.03 100.02,79.03 99.36,79.03 99.27,78.94 98.95,78.94 98.44,79.45 96.2,79.45 95.05,78.3 92.24,78.3 91.52,77.58 91.52,76.72 88.91,74.12 88.91,71.4 88.99,71.32 88.99,69.04 88.15,68.21 82.97,63.02 82.97,62.54 81.23,60.8 81.23,57.98 80.5,57.24 80.5,52.45 80.87,52.07 80.87,50.02 80.54,49.69 80.15,49.69 79.1,48.63 79.1,46.98 78,45.89 78,43.87 77.46,43.32 77.46,42.13 78.65,40.93 v1(78.83,40.93)
  BOTTOM w0.076: U80.BA13 110.6,68 110.6,69.56 109.35,70.81 109.19,70.81 109.09,70.92
  BOTTOM w0.102: v1(107.28,75.37) 107.85,74.8 107.85,72.83 108.3,72.38 108.3,71.71 109.09,70.92 ; v1(78.83,40.93) 78.54,40.93 78.43,41.04 EUPM3247.B26
LPC_LAD<2>: length 75.8
  IN2 w0.079: v1(79.41,41.14) 79.22,41.33 78.69,41.33 77.66,42.35 77.66,43.23 78.21,43.78 78.21,45.8 79.31,46.9 79.31,48.55 80.24,49.48 80.62,49.48 81.08,49.94 81.08,52.17 80.7,52.55 80.7,57.16 81.44,57.89 81.44,60.71 83.17,62.45 83.17,62.94 89.19,68.96 89.19,71.41 89.12,71.49 89.12,74.03 91.72,76.64 91.72,77.49 92.33,78.09 95.14,78.09 96.28,79.24 98.35,79.24 98.92,78.67 99.33,78.67 99.48,78.82 99.93,78.82 100.93,77.82 101.48,77.82 v1(101.69,77.6)
  BOTTOM w0.076: U80.BB13 110.84,69.56 109.41,70.99 109.27,70.99 109.13,71.12
  BOTTOM w0.102: 109.13,71.12 108.5,71.76 108.5,72.53 108.03,73 108.03,75.07 107.71,75.4 107.71,78.83 106.81,79.73 104.23,79.73 103.24,78.73 102.85,78.73 102.23,78.11 102.2,78.11 v1(101.69,77.6) ; v1(79.41,41.14) 79.21,41.34 78.63,41.34 78.42,41.54 EUPM3247.B27
LPC_LAD<3>: length 76.4
  IN2 w0.079: v1(104.72,75.96) 104.72,75.39 104.29,74.97 103.63,74.97 103.47,75.13 103.47,76.68 101.91,78.23 101.16,78.23 99.94,79.45 99.56,79.45 99.42,79.6 98.61,80.4 98.09,80.4 97.76,80.07 96.24,80.07 94.88,78.71 91.82,78.71 91.1,78 91.1,76.89 88.5,74.29 88.5,71.43 87.98,70.91 87.98,69.19 87.27,68.48 87.27,67.91 82.56,63.19 82.56,62.71 80.82,60.97 80.82,58.15 80.09,57.41 80.09,53.18 79.47,52.57 77.16,52.57 76.81,52.22 76.81,47.64 76.93,47.52 76.93,46.75 76.78,46.6 76.78,44.75 76.93,44.6 76.93,42.35 v1(76.45,41.87)
  BOTTOM w0.076: U80.AY12 110.27,66.98 110.57,67.28 110.57,67.7 110.41,67.87 110.41,69.51 109.27,70.64 109.11,70.64 108.89,70.86
  BOTTOM w0.102: v1(76.45,41.87) 76.52,41.79 EUPM3247.A26 ; v1(104.72,75.96) 104.72,75.35 105.39,74.68 105.73,74.68 105.98,74.43 106.9,74.43 107.15,74.68 107.49,74.68 107.67,74.49 107.67,72.75 108.1,72.32 108.1,71.65 108.89,70.86
LPC_SERIRQ: length 74.7
  TOP w0.102: v1(104.01,76.05) 103.45,75.5 R894.2
  IN2 w0.079: v1(104.01,76.05) 104.01,76.54 102.03,78.52 101.27,78.52 100.05,79.74 99.68,79.74 98.73,80.69 97.98,80.69 97.64,80.35 96.12,80.35 94.76,78.99 91.63,78.99 90.12,77.49 90.12,76.31 88.22,74.4 88.22,71.55 87.7,71.03 87.7,69.31 86.99,68.6 86.99,68.03 82.28,63.31 82.28,62.82 81.03,61.58 79.76,61.58 79.32,61.13 79.32,60.55 80.4,59.47 80.4,58.13 79.8,57.53 79.8,53.3 79.35,52.85 77.04,52.85 76.53,52.34 76.53,47.52 76.65,47.4 76.65,46.87 76.5,46.72 76.5,44.64 76.65,44.48 76.65,43.45 v1(76.49,43.29)
  BOTTOM w0.076: U80.AY11 109.83,67.24 109.83,67.34 109.97,67.57 110.1,67.7 110.1,69.33 109.12,70.31 108.87,70.31 108.64,70.53
  BOTTOM w0.102: 108.64,70.53 107.74,71.44 107.74,72.15 107.32,72.57 107.32,73.61 106.9,74.02 105.85,74.02 105.5,74.37 105.26,74.37 104.41,75.22 104.41,75.65 104.02,76.04 v1(104.01,76.05) ; EUPM3247.A29 76.49,43.29 v1(76.49,43.29)
M_A_CA_A<0>: length 51.7
  IN1 w0.097: v3(139.02,77.46) 139.91,77.46 139.96,77.42 142.01,77.42 142.14,77.55 143.66,77.55 144.04,77.18 157.19,77.18 161.51,81.5 166.07,81.5 166.49,81.92 169.73,81.92 172.8,78.84 v3(172.8,78.44)
  BOTTOM w0.076: U80.BA51 132.64,67.66 132.64,67.88 132.65,67.89 132.65,67.89 132.65,67.9 132.68,67.99 132.68,68.19 132.65,68.27 132.65,68.28 132.65,68.63 132.74,68.72 132.74,70.29 133.82,71.38 133.82,72.11 134.7,72.98 134.7,74.59 134.81,74.7
  BOTTOM w0.132: USM2000.R2 172.8,78.43 v3(172.8,78.44) ; 134.81,74.7 137.58,77.46 v3(139.02,77.46)
M_A_CA_A<1>: length 49.3
  IN1 w0.097: v3(139.29,74.24) 138.84,74.69 138.84,74.86 138.83,74.86 138.83,75.17 138.84,75.18 138.84,75.48 139.02,75.66 139.72,75.66 139.89,75.84 139.89,76.91 140.07,77.09 142.14,77.09 142.29,77.24 143.39,77.24 143.75,76.88 157.38,76.88 161.58,81.09 170.07,81.09 172.37,78.79 172.37,78.65 v3(172.15,78.44)
  BOTTOM w0.076: U80.BB54 134.01,68.51 134.01,69.88 136.01,71.87 136.01,72.96
  BOTTOM w0.132: 136.01,72.96 137.2,74.16 138.63,74.16 138.72,74.24 v3(139.29,74.24) ; v3(172.15,78.44) 172.15,78.43 USM2000.P2
M_A_CA_A<2>: length 50
  IN1 w0.097: v3(171.18,78.94) 170.53,79.59 170.25,79.59 170.16,79.51 170.16,79.01 170.07,78.92 169.25,78.92 169.09,79.08 169.09,80.21 168.83,80.47 161.87,80.47 157.69,76.3 143.4,76.3 142.9,75.8 141.94,75.8 141.66,76.08 141.66,76.26 141.45,76.47 141.05,76.47 140.7,76.12 v3(140.32,76.12)
  BOTTOM w0.076: U80.BA52 133.08,67.98 133.33,68.24 133.33,68.56 133.25,68.65 133.25,70.08 135.16,72 135.16,74.11
  BOTTOM w0.132: 135.16,74.11 137.18,76.13 138.67,76.13 138.8,76.26 138.8,76.34 139.1,76.63 139.69,76.63 139.92,76.4 140.04,76.4 v3(140.32,76.12) ; USM2000.N2 v3(171.18,78.94)
M_A_CA_A<3>: length 50.7
  IN1 w0.097: v3(140.42,76.7) 140.8,76.7 140.89,76.79 142.06,76.79 142.49,76.36 142.99,76.36 143.23,76.59 157.57,76.59 161.75,80.77 169.91,80.77 171.6,79.09 171.6,78.48 171.5,78.38 171.5,77.65 v3(171.5,77.64)
  BOTTOM w0.076: U80.AY52 132.88,67.21 132.88,67.47 132.81,67.66 132.81,67.87 132.85,67.95 132.85,68.2 132.85,68.22 132.81,68.31 132.81,68.56 132.9,68.65 132.9,70.22 134.06,71.38 134.06,72 134.95,72.88 134.95,74.37 135.05,74.48
  BOTTOM w0.132: v3(171.5,77.64) 171.5,77.63 USM2000.N3 ; v3(140.42,76.7) 139.99,76.7 139.83,76.87 138.97,76.87 138.73,76.63 v1(137.89,76.63) 137.21,76.63 135.05,74.48
M_A_CA_A<4>: length 50.8
  IN1 w0.097: v3(140.61,75.54) 140.61,74.62 140.71,74.52 143.7,74.52 143.79,74.62 143.79,75.61 143.89,75.71 157.94,75.71 162.07,79.83 166.91,79.83 168.03,78.71 168.03,77.75 168.54,77.25 170.47,77.25 170.85,77.63 v3(170.85,77.64)
  BOTTOM w0.076: U80.AW52 132.98,66.65 133.3,66.97 133.3,67.52 133.51,67.72 133.51,70.11 135.37,71.97 135.37,73.83
  BOTTOM w0.132: USM2000.M3 170.85,77.63 v3(170.85,77.64) ; 135.37,73.83 137.34,75.81 139.81,75.81 140.07,75.54 v3(140.61,75.54)
M_A_CA_A<5>: length 49.9
  IN1 w0.097: v3(138.45,73.42) 137.74,73.42 137.47,73.15 137.47,72.76 137.61,72.61 137.79,72.61 137.87,72.53 138.03,72.37 138.03,72.25 138.07,72.22 138.07,72.21 139.72,70.56 147.55,70.56 147.76,70.77 147.76,72.59 147.85,72.69 150,72.69 150.14,72.83 150.14,72.97 150.04,73.07 148.01,73.07 147.91,73.16 147.91,73.31 148.01,73.41 154.12,73.41 154.22,73.5 154.22,74.08 154.32,74.18 158.55,74.18 161.6,77.23 165.91,77.23 166.31,77.63 v3(166.31,77.64)
  BOTTOM w0.076: U80.AY55 134.87,66.89 134.58,67.18 134.5,67.33 134.5,67.52 134.56,67.68 134.56,67.82 134.49,68.04 134.49,68.15 134.53,68.24 134.54,68.26 134.54,68.67 134.38,68.83 134.38,68.85 134.38,69.15 134.38,69.15 134.38,69.48 136.44,71.54 136.44,72.44 137.42,73.42
  BOTTOM w0.132: USM2000.F3 166.31,77.63 v3(166.31,77.64) ; v3(138.45,73.42) 137.42,73.42
M_A_CA_A<6>: length 51.6
  IN1 w0.097: v3(165.66,77.64) 165.68,77.64 166.07,78.03 167.47,78.03 167.7,78.26 167.7,78.56 166.76,79.5 162.17,79.5 158.08,75.4 144.26,75.4 144.14,75.29 144.14,73.4 144.03,73.29 142.74,73.29 142.61,73.16 142.61,72.6 142.47,72.46 140.27,72.46 140.17,72.56 v3(140.17,75.11)
  BOTTOM w0.076: U80.AW54 134.21,66.68 133.9,66.99 133.9,67.53 133.67,67.76 133.67,70.04 135.59,71.95 135.59,73.57
  BOTTOM w0.132: USM2000.E3 165.66,77.63 v3(165.66,77.64) ; v3(140.17,75.11) 139.76,75.52 138.44,75.52 137.73,74.82 136.83,74.82 135.59,73.57
M_A_CA_A<7>: length 49.4
  IN1 w0.097: v3(165.66,78.44) 165.68,78.43 166.09,78.43 166.2,78.54 166.2,79.03 166.05,79.19 162.29,79.19 158.21,75.11 144.74,75.11 144.55,74.92 144.55,72.98 144.44,72.87 143.05,72.87 142.94,72.75 142.94,72.59 143.05,72.48 144.43,72.48 144.54,72.36 144.54,72.2 144.43,72.09 139.95,72.09 139.24,72.8 139.24,73.3 139.76,73.82 139.76,74.3 139.69,74.38 v3(139.69,74.69)
  BOTTOM w0.076: U80.BA54 134.11,67.97 133.84,68.24 133.84,69.98 135.79,71.93 135.79,73.29
  BOTTOM w0.132: USM2000.E2 165.66,78.43 v3(165.66,78.44) ; v3(139.69,74.69) 139.11,74.69 138.96,74.54 138.48,74.54 138.44,74.49 136.99,74.49 135.79,73.29
M_A_CA_A<8>: length 51.1
  IN1 w0.097: v3(165.01,78.44) 165.01,78.43 164.62,78.04 161.99,78.04 158.43,74.48 147.62,74.48 147.52,74.38 147.52,74.2 147.62,74.11 153.12,74.11 153.22,74.01 153.22,73.85 153.12,73.75 147.55,73.75 147.45,73.65 147.45,71.72 147.14,71.41 139.66,71.41 138.85,72.22 138.47,72.22 138.15,72.54 138.15,72.65 138.1,72.7 138.1,72.77 v3(137.86,73.01)
  BOTTOM w0.076: 137.52,73.01 136.67,72.16 136.67,71.39 135.12,69.84 135.12,68.8 135,68.68 135,68.27 135.06,68.14 135.06,68.03 135,67.9 135,67.67 U80.BA55
  BOTTOM w0.132: USM2000.D2 165.01,78.43 v3(165.01,78.44)
  BOTTOM w0.152: v3(137.86,73.01) 137.52,73.01
M_A_CA_A<9>: length 51.4
  IN1 w0.097: v3(138.88,73.83) 138.95,73.76 138.95,72.67 139.88,71.74 146.81,71.74 146.93,71.85 146.93,72.12 146.81,72.23 145.05,72.23 144.94,72.35 144.94,74.15 145.05,74.26 145.42,74.26 145.54,74.15 145.54,72.75 145.65,72.63 145.88,72.63 146.03,72.78 146.03,74.15 146.14,74.26 146.41,74.26 146.52,74.15 146.52,72.98 146.64,72.87 146.86,72.87 146.98,72.98 146.98,74.6 147.16,74.78 158.31,74.78 162.4,78.87 164.19,78.87 164.36,78.71 v3(164.36,78.44)
  BOTTOM w0.076: 136.23,72.67 136.23,71.71 134.19,69.67 134.19,68.77 134.38,68.59 134.38,68.3 134.32,68.18 134.32,68.04 134.38,67.81 134.38,67.68 134.31,67.47 134.31,67.21 U80.AY54
  BOTTOM w0.132: v3(138.88,73.83) 137.39,73.83 136.23,72.67 ; USM2000.C2 164.36,78.43 v3(164.36,78.44)
M_A_CA_B<0>: length 51.3
  IN1 w0.097: v3(130.41,65.63) 130.41,70.02 133.2,72.82 133.2,74.51 133.69,74.99 134,74.99 134.91,75.9 134.91,78.73 138.08,81.89 141.99,81.89 143.06,82.96 143.06,90.77 143.17,90.88 151.17,90.88 151.96,91.68 155.45,91.68 155.56,91.56 155.56,90.84 155.68,90.72 155.9,90.72 156.02,90.84 156.02,91.56 156.13,91.68 156.44,91.68 156.55,91.56 v3(156.55,89.68)
  BOTTOM w0.076: U80.AU46 v3(130.41,65.63)
  BOTTOM w0.132: v3(156.55,89.68) 156.55,89.66 USM2001.R2
M_A_CA_B<1>: length 51.2
  IN1 w0.097: v3(155.9,89.68) 155.41,89.68 154.92,90.17 154.18,90.17 153.44,90.91 152.49,90.91 152.07,90.49 152.07,90.17 151.95,90.06 151.17,90.06 151.06,90.17 147.09,90.17 147.02,90.09 147.02,89.38 146.9,89.27 146.67,89.27 146.55,89.38 146.55,90.05 146.44,90.17 145.64,90.17 145.5,90.02 145.5,89.67 145.62,89.55 146.1,89.55 146.2,89.45 146.2,89.1 146.13,89.03 144.7,89.03 144.32,88.64 144.32,84.91 144.43,84.8 144.86,84.8 144.97,84.68 144.97,84.46 144.86,84.34 144.43,84.34 144.32,84.23 144.32,84 144.43,83.88 144.9,83.88 145.01,83.77 145.01,83.54 144.9,83.43 144.43,83.43 144.32,83.31 144.32,82.53 142.99,81.21 138.2,81.21 135.49,78.49 135.49,75.66 134.39,74.56 134.39,73.11 131.5,70.22 131.5,67.04 131.61,66.93 131.61,66.5 131.32,66.21 v3(131.32,65.63)
  BOTTOM w0.076: U80.AU48 v3(131.32,65.63)
  BOTTOM w0.132: USM2001.P2 155.9,89.66 v3(155.9,89.68)
M_A_CA_B<2>: length 51.5
  IN1 w0.097: v3(130.41,64.99) 130.83,65.41 130.83,66.05 130.78,66.1 130.78,67.03 130.91,67.16 131.04,67.16 131.15,67.28 131.15,67.51 131.04,67.62 130.91,67.62 130.8,67.73 130.8,67.96 130.91,68.08 131.04,68.08 131.15,68.19 131.15,68.42 131.04,68.53 130.91,68.53 130.8,68.65 130.8,68.87 130.91,68.99 131.03,68.99 131.14,69.11 131.14,69.34 130.8,69.69 130.8,69.95 134.09,73.24 134.09,74.67 135.2,75.78 135.2,78.61 138.18,81.59 142.77,81.59 143.97,82.78 143.97,86.66 143.85,86.77 143.48,86.77 143.36,86.89 143.36,87.12 143.48,87.23 143.85,87.23 143.97,87.35 143.97,87.57 143.85,87.69 143.48,87.69 143.36,87.8 143.36,88.03 143.48,88.15 143.85,88.15 143.97,88.26 143.97,88.49 143.85,88.6 143.48,88.6 143.36,88.72 143.36,88.95 143.48,89.06 143.74,89.06 143.94,89.26 143.94,90.2 144.27,90.52 151.51,90.52 152.27,91.28 154.8,91.28 154.92,91.17 v3(154.92,90.72)
  BOTTOM w0.076: U80.AT46 v3(130.41,64.99)
  BOTTOM w0.132: USM2001.N2 155.05,89.46 155.05,90.58 v3(154.92,90.72)
M_A_CA_B<3>: length 50.9
  IN1 w0.097: v3(132.24,65.63) 132.74,66.13 132.74,68.22 135.29,70.78 135.29,74.25 136.35,75.3 136.35,78.13 138.49,80.28 145.24,80.28 146.2,81.24 146.2,82.76 146.46,83.02 148.55,83.02 148.93,83.4 148.93,83.57 149.13,83.77 150.38,83.77 150.57,83.96 150.57,84.43 150.38,84.63 149.7,84.63 149.59,84.74 149.59,84.99 149.7,85.11 150.48,85.11 150.59,85.22 150.59,85.48 150.45,85.62 149.15,85.62 149.04,85.73 149.04,85.91 149.15,86.02 151.68,86.02 151.92,86.27 151.92,87.67 152.04,87.79 152.04,89.1 152.2,89.26 156.62,89.26 156.77,89.1 156.77,88.69 156.55,88.47 155.64,88.47 155.25,88.86 v3(155.25,88.88)
  BOTTOM w0.076: U80.AU50 v3(132.24,65.63)
  BOTTOM w0.132: USM2001.N3 155.25,88.86 v3(155.25,88.88)
M_A_CA_B<4>: length 49.6
  IN1 w0.097: v3(133.15,65.63) 133.15,68.05 135.58,70.47 135.58,74.11 136.64,75.17 136.64,78.01 138.61,79.99 145.55,79.99 146.99,81.43 147.29,81.43 147.3,81.42 147.62,81.42 147.63,81.43 147.94,81.43 147.95,81.42 148.27,81.42 148.28,81.43 148.29,81.43 148.47,81.24 148.93,81.24 149.29,81.6 149.29,82.32 149.41,82.44 150.82,82.44 150.93,82.55 150.93,82.78 150.82,82.9 149.33,82.9 149.21,83.01 149.21,83.24 149.33,83.35 150.82,83.35 150.93,83.47 150.93,85.48 151.04,85.6 152.05,85.6 152.55,85.1 154.72,85.1 154.84,85.22 154.84,85.96 154.72,86.07 152.46,86.07 152.25,86.28 152.25,87.59 153.12,88.46 153.79,88.46 153.79,88.46 154.11,88.46 154.12,88.46 154.2,88.46 154.6,88.86 v3(154.6,88.88)
  BOTTOM w0.076: U80.AU52 v3(133.15,65.63)
  BOTTOM w0.132: v3(154.6,88.88) 154.6,88.86 USM2001.M3
M_A_CA_B<5>: length 49.3
  IN2 w0.097: v3(140.41,77.8) 140.9,78.29 142.62,78.29 143.36,79.03 143.36,85.55 143.26,85.65 142.66,85.65 142.56,85.74 142.56,85.94 142.66,86.03 143.05,86.03 143.18,86.16 143.18,86.29 143.05,86.42 142.31,86.42 142.22,86.51 142.22,86.71 142.31,86.8 143.05,86.8 143.16,86.91 143.16,87.09 143.05,87.19 142.31,87.19 142.22,87.29 142.22,87.48 142.31,87.58 143.05,87.58 143.16,87.68 143.16,87.86 143.05,87.96 142.8,87.96 142.71,88.06 142.71,90.99 142.8,91.09 148.79,91.09 149.76,90.12 149.76,89.55 150.02,89.29 151.24,89.29 151.34,89.2 151.34,88.7 151.11,88.47 150.17,88.47 150.06,88.58 v3(150.06,88.88)
  BOTTOM w0.076: 134.59,74.94 134.45,74.79 134.45,73.05 133.56,72.16 133.56,71.41 131.94,69.79 131.94,68.88 132.19,68.63 132.19,68.27 132.14,68.15 132.14,68.04 132.2,67.82 132.2,67.68 132.15,67.52 132.15,67.02 U80.AY51
  BOTTOM w0.132: 134.59,74.94 137.58,77.93 139.4,77.93 139.52,77.8 v3(140.41,77.8) ; v3(150.06,88.88) 150.06,88.86 USM2001.F3
M_A_CA_B<6>: length 51.3
  IN1 w0.076: 131.69,66.12 131.69,65.36 v3(131.32,64.99)
  IN1 w0.097: v3(149.41,88.88) 149.41,88.86 149.02,88.48 147.14,88.48 147.03,88.37 147.03,88.14 146.89,88 146.71,88 146.6,88.12 146.6,88.35 146.48,88.46 145.32,88.46 144.98,88.13 144.98,87.82 145.3,87.51 145.3,87.28 145.18,87.16 144.88,87.16 144.77,87.05 144.77,86.82 144.88,86.71 145.18,86.71 145.3,86.59 145.3,86.36 145.18,86.25 144.86,86.25 144.75,86.13 144.75,85.91 144.86,85.79 145.18,85.79 145.3,85.68 145.3,85.31 145.49,85.12 147.35,85.12 147.5,85.27 147.5,85.41 147.61,85.52 148.08,85.52 148.21,85.4 148.21,84.86 148.06,84.71 146.34,84.71 145.87,84.25 145.87,83.5 143.22,80.85 138.25,80.85 135.77,78.37 135.77,75.54 134.7,74.46 134.7,72.97 132.34,70.61 132.34,70.6 131.92,70.18 131.92,70.02 132.05,69.9 132.21,69.9 133.95,71.64 134.11,71.64 134.23,71.52 134.23,71.36 131.84,68.98 131.84,67.42 131.98,67.29 131.98,66.4 131.69,66.12
  BOTTOM w0.076: U80.AT48 v3(131.32,64.99)
  BOTTOM w0.132: v3(149.41,88.88) 149.41,88.86 USM2001.E3
M_A_CA_B<7>: length 50.9
  IN1 w0.076: v3(132.24,64.99) 131.88,65.35 131.88,65.89
  IN1 w0.097: 131.88,65.89 132.37,66.39 132.37,68.31 133.02,68.95 133.02,69.54 134.11,70.63 134.72,70.63 135.01,70.92 135.01,74.37 136.06,75.42 136.06,78.25 138.37,80.56 145.04,80.56 145.2,80.72 145.2,80.78 145.04,80.94 144.28,80.94 144.18,81.05 144.18,81.21 144.4,81.43 145.51,81.43 145.71,81.63 145.71,81.94 145.38,82.27 145.38,82.43 146.32,83.37 146.32,83.59 146.55,83.82 148.64,83.82 148.84,84.03 148.84,84.49 148.54,84.79 148.54,85.15 148.61,85.21 148.61,85.78 148.4,85.98 147.39,85.98 147.26,85.85 147.26,85.73 147.16,85.63 146.43,85.63 146.22,85.84 146.22,87.47 146.41,87.66 151.5,87.66 151.75,87.92 151.75,89.12 151.6,89.27 149.8,89.27 149.36,89.71 v3(149.36,89.73)
  BOTTOM w0.076: U80.AT50 v3(132.24,64.99)
  BOTTOM w0.132: USM2001.E2 149.36,89.71 v3(149.36,89.73)
M_A_CA_B<8>: length 49.7
  IN2 w0.097: v3(148.76,89.68) 148.76,90.16 148.14,90.78 143.45,90.78 143.08,90.4 143.08,89 143.66,88.42 143.66,78.89 142.6,77.83 v3(141.66,77.83)
  BOTTOM w0.076: U80.BB50 131.75,68.58 131.58,68.76 131.58,69.91 133.08,71.41 133.08,72.26 133.94,73.13 133.94,75.2
  BOTTOM w0.132: v3(148.76,89.68) 148.76,89.66 USM2001.D2 ; 133.94,75.2 137.48,78.74 137.48,79.57 137.61,79.71 137.84,79.71 137.97,79.57 137.97,78.95 138.11,78.82 138.37,78.82 138.5,78.95 138.5,79.59 138.63,79.72 138.9,79.72 139.03,79.59 139.03,78.95 139.16,78.82 139.43,78.82 139.56,78.95 139.56,79.59 139.69,79.72 139.96,79.72 140.09,79.59 140.09,78.95 140.22,78.82 140.48,78.82 140.62,78.95 140.62,79.59 140.75,79.72 141.01,79.72 141.14,79.59 141.14,78.86 141.25,78.76 141.57,78.76 141.67,78.86 141.67,79.67 141.8,79.81 v1(142.85,79.81) 142.98,79.67 142.98,78.16 142.65,77.83 v3(141.66,77.83)
M_A_CA_B<9>: length 51
  IN2 w0.097: v3(141.02,77.83) 141.02,76.9 141.14,76.78 142.01,76.78 144.05,78.82 144.05,88.65 143.59,89.11 143.59,90.15 143.85,90.41 145.7,90.41 145.81,90.31 145.81,85.55 145.9,85.46 147.19,85.46 147.29,85.55 147.29,85.74 147.19,85.83 146.43,85.83 146.32,85.93 146.32,90.25 146.42,90.35 147.86,90.35 148.11,90.1 v3(148.11,89.68)
  BOTTOM w0.076: U80.AY50 131.84,67.19 131.84,67.35 131.95,67.47 132.03,67.68 132.03,67.81 131.97,68.04 131.97,68.18 131.98,68.21 131.99,68.22 131.99,68.24 132,68.25 132.01,68.27 132.01,68.56 131.99,68.58 131.99,68.6 131.74,68.84 131.74,69.83 133.35,71.43 133.35,72.24 134.19,73.08 134.19,75 134.4,75.2
  BOTTOM w0.132: v3(148.11,89.68) 148.11,89.66 USM2001.C2 ; v3(141.02,77.83) 140.51,78.34 v1(139.86,78.34) 137.53,78.34 134.4,75.2
M_A_CKE<0>: length 49.6
  IN1 w0.097: v3(169.55,77.64) 169.23,77.64 169.16,77.72 169.16,78.61 169.06,78.7 168.89,78.7 168.79,78.61 168.79,77.73 168.71,77.64 168.55,77.64 168.39,77.8 168.39,78.97 167.22,80.15 161.97,80.15 157.82,76 143.54,76 143.42,75.87 143.42,74.93 143.32,74.83 143.12,74.83 143.03,74.93 143.03,75.41 142.93,75.51 142.74,75.51 142.64,75.41 142.64,74.93 142.54,74.83 142.35,74.83 142.25,74.93 142.25,75.41 142.16,75.51 141.96,75.51 141.87,75.41 141.87,74.93 141.77,74.83 141.1,74.83 141,74.93 141,75.81 v3(141.25,76.05)
  BOTTOM w0.076: v3(141.25,76.05) 141.24,76.04 141.24,75.31 139.12,73.2 139.12,72.74 138.91,72.53 138.91,72.52 138.69,72.31 138.69,72.31 135.74,69.36 135.74,68.39 135.7,68.3 135.58,68.05 135.58,68.05 135.58,68.05 135.43,67.91 U80.BA56
  BOTTOM w0.132: v3(169.55,77.64) 169.55,77.63 USM2000.K3
