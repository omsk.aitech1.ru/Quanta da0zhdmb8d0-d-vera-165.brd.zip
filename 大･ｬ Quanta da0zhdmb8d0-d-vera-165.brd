# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_RCOMPN: length 7.4
  BOTTOM w0.076: 105.79,48.59 105.79,48.62 106.18,49 U80.F5
  BOTTOM w0.102: 102.4,48.69 102.86,48.22 103.25,48.22 103.39,48.36 103.64,48.36 103.7,48.31 103.99,48.31 104.04,48.36 104.3,48.36 104.34,48.31 104.62,48.31 104.71,48.4 105.11,48.4 105.26,48.24 105.56,48.24 105.79,48.47 105.79,48.59
  BOTTOM w0.381: RAP1053.2 101.08,50 102.4,48.69
PCIE_RCOMPP: length 6.8
  BOTTOM w0.076: 103,47.8 103.05,47.75 104.32,47.75 104.38,47.8 104.61,47.8 104.66,47.76 104.98,47.76 105.24,48.02 105.7,48.02 U80.E5
  BOTTOM w0.381: 103,47.8 102.4,47.8 100.97,49.22 RAP1053.1
PCIE_RX_DN*<1>: length 112.3
  IN1 w0.079: v1(115.02,42.41) 114.73,42.12 114.57,42.12 113.32,43.37 113.32,45.6 112.07,46.85 112.07,48.26 111.78,48.55 111.78,49.78 111.59,49.97 111.45,49.97 v3(111.21,50.22)
  BOTTOM w0.102: CN8.43 185.3,18.95 185.11,18.75 185.11,17.71 v1(184.12,16.72) 183.84,17 183.09,17 182.07,15.98 165.95,15.98 164.65,17.28 151.88,17.28 150.68,16.08 118.62,16.08 116.48,18.23 116.48,24.22 112.86,27.83 112.86,32.57 113.52,33.23 113.52,34.61 114.33,35.42 114.33,42 114.55,42.22 114.83,42.22 v1(115.02,42.41) ; v3(111.21,50.22) 110.97,50.45 U80.H13
PCIE_RX_DP<1>: length 112.3
  IN1 w0.079: v1(115.02,41.63) 114.71,41.94 114.49,41.94 113.14,43.29 113.14,45.52 111.89,46.77 111.89,48.18 111.59,48.47 111.59,49.7 111.51,49.78 111.44,49.78 v3(111.21,49.55)
  BOTTOM w0.102: v1(115.02,41.63) 115.16,41.76 115.16,41.92 115.06,42.01 114.65,42.01 114.54,41.9 114.54,35.33 113.73,34.53 113.73,33.15 113.07,32.49 113.07,27.92 116.69,24.31 116.69,18.31 118.71,16.29 150.59,16.29 151.79,17.49 164.74,17.49 166.04,16.19 181.98,16.19 183.01,17.21 183.34,17.21 v1(184.12,17.99) 184.55,17.56 184.66,17.56 184.9,17.8 184.9,18.84 185.22,19.16 186.33,19.16 186.62,19.45 CN8.41 ; v3(111.21,49.55) 110.96,49.8 U80.G13
PCIE_TX_C_DN*<1>: length 8.6
  BOTTOM w0.102: C827.2 115.36,40.25 115.36,40.67 115.44,40.75 115.44,43.34 115.19,43.59 113.72,43.59 112.84,44.46 112.84,45.91 113.12,46.19 U80.B17
PCIE_TX_C_DP<1>: length 8.6
  BOTTOM w0.102: C828.2 115.78,40.05 115.57,40.26 115.57,40.59 115.65,40.66 115.65,43.43 115.28,43.8 113.77,43.8 113.06,44.52 113.06,45.36 113.12,45.42 113.25,45.42 113.38,45.55 113.38,45.7 113.3,45.78 U80.A17
PCIE_TX_DN*<1>: length 97.1
  BOTTOM w0.102: CN8.37 186.48,20.45 186.33,20.59 185.34,20.59 182.19,17.44 182.19,17.18 181.67,16.67 170.53,16.67 169.92,17.28 167.08,17.28 v1(166.74,16.94) 166.43,17.25 165.78,17.25 165.02,18.02 151.55,18.02 150.46,16.92 118.82,16.92 117.23,18.51 117.23,24.45 113.67,28.01 113.67,32.4 114.24,32.97 114.24,34.25 115.02,35.03 115.02,35.13 115.03,35.14 115.03,37.96 115.54,38.46 115.54,38.89 C827.1
PCIE_TX_DP<1>: length 97.1
  BOTTOM w0.102: C828.1 115.75,38.89 115.75,38.38 115.24,37.87 115.24,35.05 115.23,35.04 115.23,34.94 114.45,34.16 114.45,32.88 113.89,32.32 113.89,28.09 117.44,24.54 117.44,18.6 118.91,17.14 150.37,17.14 151.47,18.23 165.1,18.23 165.87,17.47 166,17.47 v1(166.74,18.21) 167.46,17.49 170.01,17.49 170.62,16.88 181.59,16.88 181.98,17.27 181.98,17.53 185.26,20.81 186.33,20.81 186.48,20.95 CN8.35
PCIE_WAKE*: length 175.9
  TOP w0.102: v1(108.77,73.78) 108.77,73.93 108.27,74.43 RAP1011.2 ; v1(185.74,16.36) 185.81,16.29 R1138.1
  IN2 w0.079: v1(108.77,73.78) 108.17,73.19 107.07,73.19 106.59,73.67 104.66,73.67 104.34,73.34 103.79,73.34 103.56,73.57 103.14,73.57 101.32,75.39 100.38,75.39 99.92,75.85 98.39,75.85 97.65,75.11 94.27,75.11 93.44,74.28 93.44,73.64 92.96,73.16 92.96,72.08 92.29,71.41 92.29,68.07 91.84,67.62 91.84,66.05 90.43,64.64 89.69,64.64 86.55,61.5 86.55,59.59 85.65,58.69 85.65,58.39 85.24,57.97 85.24,49.24 85.77,48.71 85.77,47.16 88.03,44.9 88.03,43.57 88.21,43.39 88.21,42.95 88.46,42.7 88.46,40.64 88.97,40.13 89.34,40.13 90.89,38.58 90.89,38.42 91.89,37.42 91.89,36.2 93.17,34.93 94.69,34.93 96.11,33.51 96.11,32.03 97.07,31.07 97.24,31.07 101.73,26.58 108.5,26.58 109.08,26.01 116.01,26.01 119.33,22.7 123.67,22.7 124.18,22.19 145.67,22.19 146.61,21.26 146.71,21.26 147.34,20.62 147.34,20.2 149.07,18.47 155.21,18.47 155.58,18.84 167.57,18.84 167.94,18.47 172.41,18.47 173.98,20.05 181.44,20.05 185.13,16.36 v1(185.74,16.36)
  BOTTOM w0.076: 109.95,71.69 109.95,71.69 112.09,69.55 112.09,68.43 U80.BB15
  BOTTOM w0.102: v1(108.77,73.78) 108.77,73.2 109.64,72.33 109.64,72 109.95,71.69
PD_WP*: length 65.7
  TOP w0.102: v1(86.25,28.76) 85.83,29.18 83.46,29.18 81.67,30.97 74.02,30.97 72.93,32.06 72.93,32.27 72.02,33.18 69.36,33.18 68.46,34.07 68.04,34.07 67.42,34.69 67.42,38.05 64.1,41.38 61.67,41.38 60.39,42.65 56.74,42.65 56.61,42.78 49.96,42.78 49.93,42.81 37.56,42.81 v1(37.33,42.58) 37.08,42.33 36.04,42.33 35.76,42.62 35.76,44.85 35.79,44.89 35.79,45.48 35.89,45.58 U95.34
  BOTTOM w0.102: v1(86.25,28.76) 86.26,28.76 87.29,29.79 87.29,30.47 R5153.2
PE_RST*: length 16.4
  TOP w0.102: Q127.1 189.81,23.43 v1(190.62,23.43) 191.43,23.43 191.99,22.87 191.99,22.21 191.69,21.91 R5020.2 190.34,20.33 190.92,19.74 192.35,19.74 194.61,17.48 v1(196.16,17.48)
  BOTTOM w0.102: CN8.52 196.07,16.7 196.16,16.79 v1(196.16,17.48)
PECI: length 94.1
  TOP w0.102: v1(135.47,42.69) 136.74,41.41 R5037.1
  IN1 w0.079: v1(120.01,22) 125.14,27.13 131.06,27.13 131.64,27.72 131.64,29.34 134.43,32.14 135.2,32.14 138.07,35.01 138.07,36.3 137.63,36.74 137.63,38.26 137.03,38.87 137.03,39.44 136.49,39.97 136.49,40.98 135.47,42.01 v1(135.47,42.69)
  IN2 w0.079: v1(120.01,22) 119.22,22 115.78,25.45 108.84,25.45 108.27,26.02 101.5,26.02 97.66,29.85 96.72,29.85 96.41,30.16 96.41,30.89 91.74,35.56 91.42,35.56 91.1,35.87 91.1,36.75 89.01,38.84 88.87,38.84 88.61,39.1 88.61,39.44 87.9,40.16 87.9,42.46 87.64,42.72 87.64,43.15 87.46,43.33 87.46,44.67 85.09,47.03 84.88,47.03 84.65,47.27 84.65,47.97 83.63,48.99 83.63,50.53 83.2,50.97 v1(82.78,50.97)
  BOTTOM w0.076: U80.A54 134.4,45.68 134.4,44.09 135.47,43.02 v1(135.47,42.69)
  BOTTOM w0.102: R5079.2 82.39,50.66 82.7,50.97 v1(82.78,50.97)
PGVR2: length 1.5
  TOP w0.102: v4(68.47,78.15) 69.39,78.15 TP160.1
  BOTTOM w0.102: v4(68.47,78.15) 68.43,78.19 PU3254.H13
PM_CPUPWRGD: length 9.2
  BOTTOM w0.102: TP39.1 150,45.88 148.99,45.88 148.53,45.42 142.97,45.42 142.61,45.78 U80.A68
PM_LANPHY_ENABLE: length 7.9
  BOTTOM w0.076: 112.23,71.57 113.5,70.3 113.5,68.83 113.69,68.64 113.69,68.27 113.64,68.15 113.64,68.04 113.71,67.82 113.71,67.63 113.65,67.48 113.65,67.38 113.41,66.62 U80.AW17
  BOTTOM w0.102: 112.23,71.57 112.23,72.93 TP17.1
PM_SLP_S0*: length 103.5
  TOP w0.079: 71.42,83.27 71.42,83.14 71.24,82.96 71.24,81.8 70.13,80.69 v4(70,80.69)
  TOP w0.102: v1(91.33,70.51) 91.06,70.78 TP100.1 ; v1(74.49,90.86) 74.03,90.41 71.65,90.41 70.68,89.44 70.68,87.26 71.77,86.17 71.77,85.12 71.42,84.77 71.42,83.27
  IN1 w0.079: v1(91.33,70.51) 91.75,70.51 93.44,72.19 94.94,72.19 95.47,72.73 97.16,72.73 97.48,72.41 98.39,72.41 99.12,71.68 99.51,71.68 103.73,67.47 107.13,67.47 107.74,66.85 109.08,66.85 110.31,65.62 v3(110.31,64.99) ; v1(74.49,90.86) 74.69,91.07 83.28,91.07 86.53,87.81 v1(89.25,87.81)
  IN2 w0.079: v1(81.95,47.28) 81.81,47.42 81.81,48.61 82.38,49.18 82.38,51.16 83.16,51.94 83.16,52.19 84.06,53.09 84.06,55.92 83.67,56.31 83.67,59.45 84.13,59.9 84.78,59.9 85.71,60.83 85.71,61.88 87.9,64.07 87.9,64.95 91.33,68.38 v1(91.33,70.51)
  BOTTOM w0.102: v1(89.25,87.81) 90.31,86.74 90.31,85.06 89.79,84.54 89.79,78.58 90,78.38 90,74.06 90.61,73.45 90.61,71.61 91.33,70.89 v1(91.33,70.51) ; v1(81.95,47.28) 81.95,47.03 81.96,47.03 EUPM3247.A39 ; v3(110.31,64.99) 109.96,64.64 U80.AT11 ; v4(70,80.69) PU3254.C10
PM_SLP_S3*: length 406.2
  TOP w0.102: PR73.2 103.87,29.65 102.92,29.65 100.87,31.69 v1(100.87,31.88) ; v1(200.53,19.39) 200.35,19.57 200.35,22.82 200.8,23.27 PU50.2 203.21,23.27 203.34,23.14 203.34,22.41 203.87,21.88 207.87,21.88 208.12,22.13 208.12,23.16 PC1280.1 208.27,24.03 PU51.5 ; v1(32.24,59.22) 31.25,59.22 29.76,57.73 29.76,55.86 29.3,55.41 PU20.9 ; v1(61.77,71.41) 59.73,71.41 58.89,70.57 58.89,69.6 57.04,67.75 56.05,67.75 55.88,67.58 53.65,67.58 TP101.1 53.26,67.98 53.26,68.82 53.38,68.94 v1(53.38,69.1) 53.38,69.25 52.93,69.7 PU23.2
  IN1 w0.079: v4(67.44,76.16) 67.09,76.51 67.09,78.29 67.82,79.03 67.82,79.33 67.47,79.69 v4(67.47,80.19) ; v1(100.87,31.88) 100.87,33.37 100.35,33.89 99.2,33.89 97.58,32.27 96.96,32.27 v1(96.87,32.37) 94.21,32.37 90.34,28.49 88.93,28.49 87.99,27.55 85.52,27.55 85.19,27.22 83.83,27.22 83.24,27.81 78.92,27.81 78.65,28.08 73.72,28.08 72.9,28.9 70.24,28.9 v1(66.21,32.93) 60.9,38.24 59.17,38.24 57.23,40.17 53.52,40.17 49.72,43.97 49.72,46.96 48.87,47.81 47.49,47.81 45.66,49.64 45.66,50.02 44.73,50.96 44.73,54.29 44.98,54.54 44.98,55.26 42.42,57.82 39.08,57.82 36.57,60.33 33.36,60.33 v1(32.24,59.22) ; v1(91.56,86.37) 92.54,87.34 92.54,88.16 93.73,89.35 97.8,89.35 v1(98.62,90.17)
  IN2 w0.079: v3(112.12,63.72) 111.68,64.17 111.68,65.11 111.52,65.26 111.52,65.95 111.9,66.33 111.9,67.27 109.63,69.54 108.41,69.54 108.12,69.83 108.12,70.03 108.32,70.24 108.32,71.03 107.79,71.56 106.16,71.56 105.07,72.65 103.51,72.65 103.15,73.01 101.88,73.01 100.97,73.92 99.24,73.92 99,74.16 98.44,74.16 98.22,73.94 95.55,73.94 95.45,73.85 v1(95.01,73.85) 94.81,74.05 94.26,74.05 94.01,73.8 94.01,73.38 93.56,72.93 93.56,71.87 92.85,71.16 92.85,67.84 92.41,67.39 92.41,64.68 91.67,63.94 89.79,63.94 87.12,61.27 87.12,59.36 86.22,58.46 86.22,57.97 85.91,57.66 85.91,49.37 86.41,48.86 86.41,47.32 88.78,44.94 88.78,44.68 89.33,44.14 89.33,42.73 90.15,41.91 90.15,40.68 90.55,40.28 91.26,40.28 91.82,39.72 91.82,38.57 95.03,35.36 95.04,35.36 96.87,33.53 v1(96.87,32.37) 102.11,27.12 108.73,27.12 109.23,26.63 116.42,26.63 119.81,23.24 123.9,23.24 124.37,22.77 145.86,22.77 146.83,21.8 146.93,21.8 147.88,20.85 147.88,20.57 149.38,19.08 155.02,19.08 155.31,19.38 167.01,19.38 167.33,19.7 169.31,19.7 169.31,19.69 172.86,19.69 173.76,20.59 181.67,20.59 184.21,18.05 188.24,18.05 189.16,18.97 198.71,18.97 199.2,19.46 200.46,19.46 v1(200.53,19.39) ; v4(67.44,76.16) 66.58,75.29 63.73,75.29 62.61,74.17 62.09,73.65 62.09,71.73 v1(61.77,71.41)
  BOTTOM w0.076: U80.AP15 111.74,63.34 v3(112.12,63.72)
  BOTTOM w0.102: v1(32.24,59.22) 32.22,59.23 32.22,61.35 33.98,63.1 37,63.1 43.68,69.78 52.85,69.78 53.38,69.25 v1(53.38,69.1) ; v4(67.44,76.16) 67.47,76.19 PU3254.L14 ; v1(98.62,90.17) 98.9,90.46 PR80.2 ; v1(95.01,73.85) 95.01,74.57 93.32,76.26 93.32,77.05 91.56,78.81 91.56,81.34 90.82,82.08 90.82,84.16 91.31,84.64 91.31,86.11 v1(91.56,86.37) ; EUPM3247.A21 76.71,39.29 76.4,38.99 76.4,38.47 75.76,37.83 74.68,37.83 74.66,37.83 74.53,37.95 72.59,37.95 72.38,38.16 70.42,38.16 69.96,38.62 68.19,38.62 67.4,37.83 67.4,34.12 v1(66.21,32.93) ; PU3254.C14 v4(67.47,80.19)
PM_SLP_S4*: length 230.5
  TOP w0.079: v4(67.98,80.72) 67.86,80.85 67.86,81.27 67.85,81.27 67.85,81.33 67.65,81.54 65.93,81.54 65.78,81.69 65.19,81.69
  TOP w0.102: v1(108.04,30.11) 107.92,30.23 105.67,30.23 PR55.1 ; 65.19,81.69 64.43,81.69 v1(64.05,82.08)
  IN1 w0.079: v1(64.05,82.08) 63.81,81.83 63.81,75.62 62.27,74.09 62.27,72.87 v1(62.5,72.64) 62.9,72.25 64.26,72.25 65.22,71.29 67.38,71.29 67.62,71.53 71.67,71.53 72.57,70.64 75.79,70.64 77.55,68.88 80.68,68.88 82.34,70.54 82.34,72.52 86.49,76.67 86.49,78.1 88.66,80.27 96.77,80.27 98.17,78.87 100.32,78.87 100.9,78.3 101.82,78.3 103.66,76.46 108.26,76.46 109.17,75.55 109.17,74.84 v1(109.67,74.34)
  IN2 w0.079: v4(67.98,80.72) 68.48,80.72 68.84,80.36 69.21,80.36 69.36,80.51 69.66,80.51 69.78,80.38 69.78,80.38 70.35,79.81 70.65,79.81 70.88,80.04 70.88,80.12 71.67,80.9 71.67,81.28 72.16,81.78 72.63,81.78 73.18,82.33 v1(73.68,82.33) ; v1(62.5,72.64) 62.5,70.6 62.15,70.24 61.41,70.24 60.87,69.7 60.87,67.27 61.71,66.43 61.71,63.02 60.47,61.78 60.47,59.95 60.93,59.49 60.93,56.24 59.89,55.2 59.89,54.27 60.18,53.97 60.18,53.38 60.84,52.72 60.84,51.91 60.04,51.1 59.85,51.1 59.02,50.27 59.02,47.94 58.72,47.64 58.72,44.56 59.84,43.44 61.49,43.44 62.15,42.78 62.15,41.99 v1(62.16,41.98) 64.1,40.04 64.1,38.13 67.02,35.21 68.36,35.21 70.42,33.15 70.42,28.8 76.1,23.11 76.1,22.88 79.03,19.95 84.44,19.95 88.76,15.62 91.01,15.62 93.61,13.01 93.81,13.01 94.57,12.25 99.49,12.25 99.9,12.67 101.81,12.67 102.61,11.87 109.14,11.87 v1(109.36,12.1)
  BOTTOM w0.076: v1(109.67,74.34) 110.08,73.93 110.08,73.57 110.05,73.54 TP102.1 110.2,73.01 110.2,72.2 112.66,69.75 112.66,67.7 112.69,67.67 U80.BA16 ; 73.7,81.42 73.71,81.43 73.71,82.08
  BOTTOM w0.079: 73.71,82.08 73.71,82.3 v1(73.68,82.33) ; PU3254.B2 73.7,81.42
  BOTTOM w0.102: v1(62.16,41.98) 62.37,42.2 64.97,42.2 65.68,41.49 66.88,41.49 67.28,41.88 70.71,41.88 70.85,41.74 73.35,41.74 73.76,41.33 75.41,41.33 75.94,40.8 76.2,40.8 76.21,40.79 EUPM3247.A24 ; PU3254.D13 67.98,80.2 v4(67.98,80.72) ; v1(109.36,12.1) 109.75,12.48 109.75,14.82 109.49,15.07 109.49,27.28 108.04,28.73 v1(108.04,30.11)
PM_SUS_STAT*: length 6.8
  BOTTOM w0.076: 108.51,70.37 108.59,70.37 108.81,70.14 109.02,70.14 109.95,69.22 109.95,68.06 109.79,67.91 109.79,67.91 U80.BA11
  BOTTOM w0.102: TP77.1 107.1,72.8 107.1,72.27 107.54,71.84 107.54,71.34 108.51,70.37
PMON_PSYS: length 214.7
  TOP w0.102: PR42.2 201.14,41.3 v1(201.08,41.36)
  IN2 w0.079: v1(199.94,17.31) 199.37,17.88 189.62,17.88 187.17,15.42 185.05,15.42 182.76,17.71 179.9,17.71 179.67,17.48 167.65,17.48 167.2,17.93 155.97,17.93 155.52,17.48 148.17,17.48 144.78,20.88 141.26,20.88 140.21,19.83 122.07,19.83 121.32,20.58 115.77,20.58 113.73,18.55 113.2,18.55 112.95,18.3 111.7,18.3 111.25,18.75 105.02,18.75 104.6,19.17 97.39,19.17 97.15,19.41 95.9,19.41 92.75,22.56 v1(92.45,22.56) 91.56,22.56 89.44,24.68 88.65,24.68 87.36,25.97 87.36,27.55 86.8,28.11 85.54,28.11 84.9,28.75 83.34,28.75 79.57,32.52 79.57,33.33 79.02,33.88 79.02,36.88 78.5,37.4 78.5,38.16 v1(78.83,38.49)
  BOTTOM w0.102: PR43.1 55.62,30.39 64.61,30.39 67.58,27.41 67.58,23.94 68.33,23.2 75.07,23.2 75.79,22.49 82.54,22.49 83.96,21.06 90.16,21.06 91.66,22.56 v1(92.45,22.56) ; EUPM3247.B21 78.78,38.54 v1(78.83,38.49) ; v1(199.94,17.31) 200.3,17.66 200.58,17.66 200.93,18.02 200.93,26.65 206.65,32.37 206.65,34.15 202.03,38.77 202.03,38.96 201.08,39.91 v1(201.08,41.36)
PP3300_USB_PD_EN: length 46
  TOP w0.102: PU22.2 23.21,55.03 23.08,54.9 23.08,54.28 22.88,54.08 22.4,54.08 PR97.1 21.79,53.47 21.79,52.86 v1(21.86,52.79) ; U126.5 U126.2 14.88,53.75 v1(15.38,53.25) ; v1(39.36,47.28) 39.36,46.97 39.08,46.69 38.35,46.69 37.71,47.34 U95.38
  BOTTOM w0.102: v1(39.36,47.28) 39.36,47 v1(37.43,45.07) 35.5,43.14 35.5,42.55 35.2,42.25 29.32,42.25 27.35,44.22 27.35,45.7 26.69,46.37 26.69,47.32 26.87,47.5 26.87,48.72 25.65,49.94 25.65,50.92 24.06,52.51 22.14,52.51 v1(21.86,52.79) 21.66,52.99 21.06,52.99 20.9,53.15 16.7,53.15 16.41,53.44 15.79,53.44 15.6,53.25 v1(15.38,53.25) 15.03,53.6 U124.2 U124.5
PRE: length 4.2
  TOP w0.102: v1(19.14,48.62) 19.19,48.57 20.54,48.57 20.7,48.41 U26.15
  BOTTOM w0.102: v1(19.14,48.62) 18.94,48.42 17.79,48.42 R687.2
PWRLED#: length 105.6
  TOP w0.102: v1(19.54,70.57) 19.39,70.42 17.53,70.42 16.68,71.26 16.68,71.91 15.43,73.16 Q109.2
  IN1 w0.079: v1(89.02,39.31) 89.02,38.93 87.86,37.77 87.86,36.96 86.29,35.39 78.09,35.39 76.08,37.41 72.59,37.41 71.74,38.27 69.84,38.27 69.22,38.88 67.31,38.88 63.28,42.91 62.96,42.91 62.02,43.85 59.35,43.85 57.55,45.65 56.1,45.65 54.97,46.78 54.97,48.41 v1(55.32,48.76) ; v1(19.54,70.57) 19.96,70.99 20.78,70.99 22.1,69.67 23.28,69.67 23.74,69.21 25.98,69.21 26.44,69.67 39.78,69.67 42.91,66.53 50.92,66.53 51.62,65.83 51.62,64.83 v1(51.76,64.68)
  IN2 w0.079: v1(51.76,64.68) 51.76,64.52 52.78,63.51 54,63.51 55.06,62.44 55.06,61.07 54.73,60.74 54.73,58.68 55.08,58.33 55.08,56.29 54.25,55.46 54.25,49.51 55,48.76 v1(55.32,48.76)
  BOTTOM w0.102: v1(89.02,39.31) 89,39.29 EUPM3247.A60
RCOMP: length 12.3
  IN2 w0.508: v1(143.1,40.39) 143.32,40.61 143.32,41.93 138.88,46.36 138.45,46.36 137.73,47.08 v3(137.73,48.28)
  BOTTOM w0.254: v3(137.73,48.28) 137.65,48.32 U80.E60
  BOTTOM w0.508: RAP1323.1 142.59,39.82 143.1,40.33 v1(143.1,40.39)
ROP_ACSWON*: length 1.2
  TOP w0.102: TP116.1 73.48,76.22 v4(73,76.71)
  BOTTOM w0.102: PU3254.M3 72.97,76.41 73,76.44 v4(73,76.71)
ROP_BAT1SWON*: length 3
  TOP w0.079: v4(75.28,78.11) 75.56,78.39 TP117.1
  BOTTOM w0.079: 74.16,77.48 74.11,77.44 73.72,77.44 PU3254.J2
  BOTTOM w0.102: 74.16,77.48 74.9,77.48 75.28,77.86 v4(75.28,78.11)
ROP_BAT2SWON*: length 2
  TOP w0.079: v4(73.45,78.21) 73.42,78.21 TP118.1
  BOTTOM w0.102: v4(73.45,78.21) 72.97,77.73 PU3254.K3
ROP_BC_ACOK: length 73.4
  TOP w0.102: v1(56.38,67.34) 57.14,67.34 58.77,68.97 v1(60.71,68.97) 62.65,68.97 64.29,70.6 PR100.2 64.78,71.45 65.36,71.45 65.37,71.46 65.53,71.46 65.98,71.91 65.98,73.52 66.98,74.52 v4(66.98,75.13) ; RPM3455.2 86.96,45.83 85.65,47.14 85.65,47.4 85.22,47.84 85.03,47.84 84.76,48.1 84.76,48.76 85.59,49.58 85.59,57.57 86.2,58.18 86.2,61.7 86,61.91 86,63.98 84.98,65 84.98,66.94 v1(84.76,67.15)
  IN1 w0.079: v1(84.76,67.15) 84.76,66.9 82.36,64.5 78.61,64.5 77.94,63.84 76.65,63.84 75.44,62.63 61.93,62.63 57.96,66.61 57.12,66.61 v1(56.38,67.34)
  BOTTOM w0.102: v4(66.98,75.13) 66.98,75.29 67.38,75.69 PU3254.N14
ROP_DSW_PWROK: length 79.6
  TOP w0.079: TP106.1 65.19,76.87
  TOP w0.102: RAP1005.2 108.27,73.41 107.92,73.06 R3587.1 CAP14472.2 108.68,73.12 109.2,73.64 109.2,74.45 109.61,74.87 109.61,76.22 v1(109.52,76.31) ; 65.19,76.87 v3(64.7,76.37) 64.5,76.17 PR75.2
  IN1 w0.079: v1(109.52,76.31) 109.11,76.31 108.68,76.74 103.77,76.74 101.94,78.58 101.01,78.58 99.8,79.79 98.93,79.79 98.62,79.48 97.96,79.48 96.89,80.55 88.55,80.55 86.21,78.21 86.21,76.9 82.01,72.7 82.01,70.61 81.34,69.93 77.14,69.93 75.98,71.1 72.76,71.1 71.87,71.99 67.43,71.99 67.19,71.75 65.41,71.75 65.14,72.02 65.14,73.9 64.7,74.34 v3(64.7,76.37)
  BOTTOM w0.076: U80.BB20 114.43,68.46 114.43,69.23 113.86,69.8 113.86,70.83 112.65,72.04
  BOTTOM w0.079: 65.89,76.86 66.27,76.86 66.34,76.93 66.7,76.93 66.97,76.67 PU3254.M15
  BOTTOM w0.102: 112.65,72.04 112.65,73.4 111.69,74.37 111.69,75.36 111.33,75.72 110.11,75.72 v1(109.52,76.31) ; 65.89,76.86 65.82,76.86 65.33,76.37 v3(64.7,76.37)
ROP_EC_INT*: length 66.9
  TOP w0.102: PR102.2 60.05,70.52 v1(59.53,70.52)
  IN2 w0.079: v1(61.47,42.5) 59.98,42.5 58.05,44.43 58.05,45.75 57.71,46.09 57.71,49.76 59.62,51.67 59.8,51.67 60.28,52.14 60.28,52.48 59.92,52.84 59.68,52.84 58.98,53.54 58.98,55.59 59.56,56.17 59.56,61.66 60.91,63.01 60.91,64.46 59.53,65.84 v1(59.53,70.52) 60.33,71.32 60.33,72.29 62.32,74.28 62.32,75.53 62.76,75.96 64.95,75.96 65.3,76.31 65.3,76.73 65.63,77.07 66.08,77.07 66.54,77.53 66.54,78.85 66.86,79.17 v4(67.46,79.17)
  BOTTOM w0.102: v4(67.46,79.17) 67.47,79.18 PU3254.E14 ; EUPM3247.A31 76.59,44.29 76.45,44.15 75.51,44.15 75.3,43.95 75.3,43.26 75.12,43.09 74.37,43.09 74.02,42.73 72.95,42.73 72.46,42.25 71.06,42.25 70.88,42.43 68.93,42.43 68.64,42.71 68.14,42.71 67.66,43.19 63.59,43.19 62.91,42.5 v1(61.47,42.5)
ROP_EC_PWRBTN*: length 63.8
  TOP w0.079: v1(75.07,74.33) 75.66,73.74 PR101.2 75.26,73.32 74.49,73.32 74.02,73.79 74.02,74.2 72.62,75.6 72.54,75.6 71.93,76.2 v4(71.93,76.66)
  IN1 w0.079: v1(74.59,71.52) 74.59,72.91 75.33,73.64 75.33,74.07 v1(75.07,74.33)
  IN2 w0.079: v1(63.24,43.49) 63.24,46.91 63.97,47.65 63.97,53.22 64.3,53.54 64.3,57.48 65.6,58.78 66.06,58.78 66.69,59.42 66.69,60.54 63.54,63.69 63.54,65.32 64.95,66.73 65.75,66.73 66.86,67.84 66.86,71.24 67.61,71.99 71.11,71.99 71.71,71.39 71.94,71.39 72.47,70.86 73.94,70.86 v1(74.59,71.52)
  BOTTOM w0.102: v4(71.93,76.66) 71.93,76.41 71.97,76.37 PU3254.M5 ; R1179.2 74.32,43.47 73.89,43.04 72.79,43.04 72.31,42.55 71.19,42.55 71.01,42.73 69.05,42.73 68.77,43.01 68.27,43.01 67.79,43.49 v1(63.24,43.49)
ROP_I2C_SLAVEADDR: length 5.2
  TOP w0.102: PR74.2 76.24,74.55 76.24,74.68 75.85,75.06 74.64,75.06 74.38,75.33 PR90.1 74.1,75.75 v4(73.01,75.75)
  BOTTOM w0.102: PU3254.N4 72.7,75.69 72.72,75.7 72.84,75.7 72.89,75.75 v4(73.01,75.75)
ROP_PCH_PWRBTN*: length 40.7
  TOP w0.102: RAP1458.2 107.56,76.61 103.65,76.61 102.71,77.56 102.71,78.93 v1(102.41,79.23)
  IN1 w0.079: v1(102.41,79.23) 101.53,80.12 99.41,80.12 98.87,80.65 97.25,80.65 97.07,80.84 88.43,80.84 84.69,77.1 81.12,77.1 80.31,77.9 76.49,77.9 v1(76.47,77.88)
  BOTTOM w0.079: 75.76,76.33 75.36,75.94 73.72,75.94 PU3254.N2
  BOTTOM w0.102: 75.76,76.33 76.24,76.33 76.65,76.74 76.65,77.71 v1(76.47,77.88)
ROP_RESET*: length 2.2
  TOP w0.079: TP115.1 71,79.14 70.51,79.64 70,79.64 v4(70,79.63)
  BOTTOM w0.102: PU3254.D9 69.97,79.93 70,79.9 70,79.64 v4(70,79.63)
ROP_RSMRST_PWRGD*: length 62
  TOP w0.102: PR104.2 62.55,71.16 v1(63.21,71.83) ; v1(64.67,79.38) 64.39,79.66 TP107.1 63.53,79.12 63.53,78.19 63.76,77.97 63.76,77.05 63.35,76.64 63.35,75.12 62.98,74.76 v1(62.98,73.99)
  IN2 w0.079: v1(66.08,60.33) 65.7,60.71 64.76,60.71 63.95,59.9 63.95,58.91 63.62,58.58 62.07,58.58 61.49,59.16 61.49,59.73 61.03,60.19 61.03,61.54 62.32,62.83 62.32,68.42 63.03,69.13 63.03,69.92 63.21,70.1 v1(63.21,71.83) 63.57,72.18 63.57,72.8 62.98,73.39 v1(62.98,73.99)
  BOTTOM w0.102: EUPM3247.A36 80.46,47 80.37,47.09 80.37,47.62 81.27,48.53 81.27,48.88 80.46,49.69 77.52,49.69 76.55,50.66 76.55,51.9 77.48,52.84 77.48,53.93 76.13,55.29 76.13,60.12 75.73,60.51 71.35,60.51 71.1,60.76 66.51,60.76 v1(66.08,60.33) ; v1(64.67,79.38) 64.95,79.1 66.39,79.1 PU3254.F16
ROP_SHUTDWN*: length 23.1
  TOP w0.102: PR111.2 68.81,85.27 v1(69.21,84.87) ; v1(61.4,79.17) 61.94,78.63 61.94,76.29 PR21.2
  IN1 w0.079: v1(69.21,84.87) 69.04,84.71 69.04,84.08 69.7,83.42 69.7,82.32 69.99,82.03 69.99,81.72 70.55,81.17 70.55,80.49 70.5,80.45 v3(70.5,80.17)
  IN2 w0.079: v1(69.21,84.87) 68.83,84.49 68.83,84.01 68.7,83.88 66.76,83.88 66.07,84.57 64.3,84.57 61.59,81.86 61.59,79.36 v1(61.4,79.17)
  BOTTOM w0.102: v3(70.5,80.17) 70.5,80.44 70.47,80.47 PU3254.C8
ROP_SYS_PWROK: length 111.1
  TOP w0.079: 65.4,72.6 65.64,72.85 65.64,73.46 66.29,74.1 66.29,74.35 65.96,74.68 65.96,75.27 66.51,75.83 TP111.1 66.51,76.19 v4(67.49,77.16)
  TOP w0.102: 65.4,72.6 65.03,72.23 61.75,72.23 v1(61.51,71.99)
  IN1 w0.079: v1(104.27,44.78) 103.32,44.78 102.42,43.88 102.04,43.88 101.06,42.9 101.06,40.83 97.88,37.65 95.46,37.65 88.46,30.65 88.04,30.65 87.65,30.26 84.82,30.26 84.51,30.57 83.74,30.57 83.21,31.1 74.09,31.1 71.22,33.96 70.05,33.96 69.53,34.48 v1(68.34,34.48)
  IN2 w0.079: v1(61.51,71.99) 61.26,71.74 61.26,70.74 61.17,70.65 61.16,70.65 60.59,70.07 60.59,67.16 61.41,66.33 61.41,63.11 59.84,61.54 59.84,56.05 59.26,55.47 59.26,53.66 59.79,53.12 60.04,53.12 60.56,52.6 60.56,52.03 59.92,51.38 59.73,51.38 58.74,50.39 58.74,48.06 58.44,47.76 58.44,44.68 58.43,44.45 59.72,43.16 61.37,43.16 61.86,42.67 61.86,42.34 61.71,42.19 61.71,41.28 61.94,41.05 61.94,38.73 66.2,34.48 v1(68.34,34.48)
  BOTTOM w0.076: U80.B6 105.7,46.76 105.66,46.72 105.33,46.39 105.04,46.39 104.75,46.1 104.32,46.1 104.22,46
  BOTTOM w0.102: RAP1004.2 100.65,43 102.42,44.78 v1(104.27,44.78) 104.27,45.34 104.08,45.52 104.08,45.87 104.22,46 ; v4(67.49,77.16) 67.52,77.19 PU3254.K13
ROP_VCCST_PWRGD: length 173.8
  IN1 w0.079: v1(148.25,38.95) 146.54,37.23 140.75,37.23 139.49,35.97 139.49,34.42 131.9,26.83 125.39,26.83 119.34,20.77 116.87,20.77 115.1,19.01 112.74,19.01 108.63,14.89 v1(108.63,13.19)
  IN2 w0.079: v1(108.63,13.19) 108.08,12.64 105.24,12.64 104.74,13.14 103.59,13.14 103.24,13.5 102.28,13.5 102.11,13.32 97.08,13.32 96.86,13.55 94.44,13.55 94.15,13.84 93.95,13.84 90.68,17.11 88.44,17.11 84.78,20.77 79.98,20.77 76.92,23.84 76.62,23.84 71.92,28.54 71.92,31.56 71.24,32.24 71.24,33.54 69.3,35.48 69.3,36.42 67.65,38.06 67.65,42.99 66.51,44.13 66.51,56.46 72.7,62.64 73.3,62.64 77.16,66.51 78.68,66.51 79.91,67.73 79.91,69.55 80.15,69.79 81.43,69.79 82.44,70.8 82.44,73.21 83.33,74.1 83.33,76.39 82.16,77.55 81.27,77.55 80.56,78.27 78.12,78.27 77.87,78.52 77.87,79.87 78.07,80.07 78.07,83.4 v1(77.79,83.68)
  BOTTOM w0.102: v1(77.79,83.68) 76.7,83.68 TP108.1 74.24,81.21 74.24,80.95 PU3254.C1 ; v1(148.25,38.95) 148.15,39.05 RAP1062.2 148.57,39.64 RAP1064.1
RTC_RST*: length 80.8
  IN2 w0.079: v1(97.66,76.13) 97.2,75.67 93.97,75.67 92.88,74.58 92.88,73.88 92.38,73.38 92.38,72.3 91.73,71.65 91.73,68.3 91.28,67.86 91.28,67.05 85.99,61.77 85.99,60.71 84.9,59.62 84.24,59.62 83.95,59.33 83.95,56.43 84.35,56.04 84.35,52.97 83.78,52.41 v1(83.78,51.8) ; v3(113.04,62.45) 112.67,62.82 112.67,67.16 110.47,69.35 110.47,70.51 108.97,72.02 106.39,72.02 106.06,72.35 v1(106.06,72.63)
  BOTTOM w0.076: U80.AM16 v3(113.04,62.45)
  BOTTOM w0.102: v1(106.06,72.63) 105.55,73.13 105.55,73.45 105.25,73.76 105.01,73.76 104.13,74.64 103.77,74.64 103.29,75.12 103.29,76.09 102.71,76.67 RAP3052.2 101.06,76.67 100.81,76.91 CAP1073.2 100.31,77.38 99.59,77.38 98.66,78.3 RAP1072.2 98.38,78.3 97.93,77.86 97.93,77.22 97.66,76.94 v1(97.66,76.13) ; v1(83.78,51.8) 83.96,51.62 84.46,51.62 88.2,47.88 88.81,47.88 89.91,46.78 90.5,46.78 90.95,46.34 92.09,46.34 92.47,45.95 92.47,44.11 93.81,42.77 93.81,41.48 95.34,39.95 R1048.1
RTC_X1: length 23.4
  IN1 w0.079: v1(106.21,74.94) 106.18,74.96 106.18,74.02 107.09,73.11 108.23,73.11 108.88,72.46 109.92,72.46 110.35,72.02 111.45,70.92 112.5,70.92 114.97,68.45 114.97,65.65 115.22,65.41 115.22,63.58 114.09,62.45 v3(113.95,62.45)
  BOTTOM w0.102: X6.1 104.25,77.6 105.13,76.71 C291.1 105.88,75.87 RAP1088.1 105.88,75.43 106.21,75.1 v1(106.21,74.94) ; U80.AM18 113.54,62.04 v3(113.95,62.45)
RTC_X2: length 22.6
  IN1 w0.079: v1(106.83,74.94) 106.83,74.02 107.28,73.57 108.42,73.57 109.07,72.92 110.11,72.92 111.64,71.38 112.69,71.38 115.57,68.5 115.57,66.11 115.4,65.93 115.4,62.99 v3(114.87,62.45)
  BOTTOM w0.102: X6.2 106.75,77.47 106.13,76.86 C289.1 106.13,76.39 106.47,76.06 106.47,75.89 RAP1088.2 106.66,75.69 106.66,75.29 106.83,75.13 v1(106.83,74.94) ; U80.AM20 114.46,62.04 v3(114.87,62.45)
SA_BOOT_DRV: length 2.6
  TOP w0.203: v1(166.41,29.73) 166.37,29.68 PR70.1 164.94,29.68 164.52,30.1 PU9.2
SA_CSN: length 54.8
  TOP w0.203: v1(198.46,33.11) 198.92,32.65 PR33.1 PR144.1 PC9107.1 201.83,32.46 PC24.1 202.09,32.72 v1(202.68,32.72)
  BOTTOM w0.152: PR12.1 198.59,31.28 196.25,31.28 195.67,31.85 185.14,31.85 184.66,32.33 181.79,32.33 181.16,31.7 181.16,29.43 180.09,28.35 168.83,28.35 167.78,27.3 157.14,27.3 PR141.1
  BOTTOM w0.203: PC1282.2 198.46,33.8 v1(198.46,33.11) 198.82,32.74 PR173.2 PR12.1
SA_CSP: length 9.6
  TOP w0.178: PU5.27 196.6,33.68 197.66,32.62 v1(197.66,32.26)
  TOP w0.203: PC24.2 201.28,31.7 201.26,31.68 PC9107.2 PR144.2 199.38,31.18 198.05,31.18 v1(198.03,31.2) 197.66,31.58 v1(197.66,32.26)
  BOTTOM w0.203: PR120.1 197.04,32.8 197.01,32.77 PR155.1 197.03,32.26 v1(197.66,32.26)
SA_FCCM: length 51.1
  TOP w0.203: v1(199.64,33.57) 199.61,33.57 199.29,33.9 197.55,33.9 197.4,34.05 PU5.29
  TOP w0.229: v1(182.55,31.84) 182.55,31.84 182.55,31.8 181.77,31.02 168.75,31.02 165.21,27.48 160.81,27.48 159.74,28.55 v1(159.74,29.06) 159.74,29.58 160.73,30.57 161.12,30.57 161.59,30.1 PU9.7
  IN2 w0.203: v1(199.64,33.57) 199.64,32.42 198.56,31.35 194.41,31.35 193.77,31.99 182.7,31.99 v1(182.55,31.84)
SA_HG_DRV:
  vias: v5(160.88,28.96)
SA_LG_DRV:
  vias: v5(160.93,31.55)
SA_PWM: length 41.8
  TOP w0.203: v1(199.63,34.26) 197.93,34.26 197.8,34.4 PU5.30
  TOP w0.229: PU9.3 v1(165.22,30.6) 166.39,30.6 167.14,31.35 181.44,31.35 v1(181.88,31.79)
  IN2 w0.203: v1(199.63,34.26) 199.78,34.26 200.09,33.95 200.09,32.41 198.68,30.99 194.32,30.99 193.65,31.67 183.42,31.67 183.13,31.38 182.29,31.38 v1(181.88,31.79)
SA_SW_DRV: length 58.9
  TOP w0.229: PU9.8 161.61,29.6 161.13,30.08 v1(160.94,30.08)
  TOP w0.305: v1(160.94,30.08) 160.25,29.39 160.25,28.6 160.67,28.18 PC1187.1
  IN2 w0.152: v1(152.79,30.96) 152.42,30.59 152.42,30.27 153.64,29.04 159.58,29.04 160.14,28.48 166.69,28.48 169.61,31.4 180.16,31.4 181.39,32.64 194.16,32.64 194.67,32.12 196.66,32.12 197.34,32.8 197.95,32.8 v1(198.25,32.5)
  BOTTOM w0.203: PR120.2 197.82,32.93 v1(198.25,32.5)
  BOTTOM w0.254: PL7.1 v1(152.79,30.96)
  vias: v5(157.3,31.41)
SCREW_SPI_WP*: length 65.2
  TOP w0.102: v1(69.21,56.65) 69.21,56.39 69.05,56.24 R896.2 68.75,56.29 RPM3457.2 RAP1407.2 68.93,57.95 69.56,57.31 UAP1008.2 70.91,57.31 71.04,57.44 71.04,57.84 70.92,57.96 UAP1008.1 69.73,57.96 69.03,58.66 69.03,60.84 QAP1009.2
  IN2 w0.079: v1(75.4,49.61) 75.39,49.6 75.39,48.35 75.21,48.17 75.21,43.02 75.69,42.54 75.69,41.43 77.47,39.65 77.47,37.15 77.89,36.73 77.89,33.73 78.67,32.96 78.67,32.15 80.22,30.59 80.22,29.32 80.76,28.78 82.27,28.78 83.67,27.37 86.22,27.37 v1(86.43,27.16)
  BOTTOM w0.102: v1(75.4,49.61) 75.73,49.61 76.98,48.37 77.51,48.37 77.59,48.45 R895.2 77.47,48.8 77.18,48.8 75.4,50.58 75.4,52.23 75.21,52.43 75.21,53.39 74.43,54.16 73.69,54.16 73.5,53.97 71.68,53.97 70.78,54.88 69.66,54.88 69.21,55.33 v1(69.21,56.65) ; v1(86.43,27.16) 87.29,28.01 v1(87.29,28.58) 87.29,29.14 87.5,29.35 87.5,30.39 87.8,30.69 88.29,30.69 R5153.1 89.13,31.53 UPM3253.3
SCREW_SPI_WP_STATUS: length 47.3
  TOP w0.102: QAP1009.3 71.98,61.37 71.72,61.63 71.72,62.64 71.95,62.87 R1178.2 76.7,62.87 77.11,62.45 77.11,58.63 v1(77.61,58.13) 78.11,57.63 79.1,57.63 79.26,57.46 81.78,57.46 v1(83.44,55.8)
  IN1 w0.079: v1(83.44,55.8) 83.89,55.8 83.98,55.72 84.99,55.72 87.18,57.91 87.18,58.42 87.86,59.1 90,59.1 90.32,59.42 92.8,59.42 v1(92.93,59.55)
  BOTTOM w0.076: U80.AD4 105.47,57.75 105.76,57.34 105.76,56.46 105.58,56.28 105.27,56.28 105.15,56.16 103.37,56.16 103.24,56.04 100.63,56.04 100.43,56.24
  BOTTOM w0.102: 100.43,56.24 100.22,56.45 98.79,56.45 97.67,57.57 95.87,57.57 95.54,57.9 95.54,58.04 95.18,58.4 94.53,58.4 94.37,58.57 94.37,58.84 94.12,59.09 93.82,59.09 93.36,59.55 v1(92.93,59.55)
SD_CD*_R_R: length 3.7
  BOTTOM w0.102: CN17.19 103.53,10.52 104.39,9.66 RAP1360.2 104.57,9.66 104.57,9.41 104.66,9.32 105.36,9.32 v1(105.66,9.61)
SD_CDZ: length 281.6
  TOP w0.102: v1(88.58,69.75) 88.58,68.67 88.24,68.33 88.24,66.91 89.67,65.49 v1(89.67,64.16) 89.67,62.83 90.04,62.47 v1(90.04,61.83) ; R4434.1 99.41,74.86 v3(98.67,74.86)
  IN1 w0.079: v1(142.05,19.29) 142.48,19.72 145.19,19.72 145.3,19.82 154.39,19.82 155.43,20.86 160.08,20.86 161.59,22.37 164.22,22.37 165.14,21.45 183.33,21.45 v1(183.96,20.81) ; v1(106.82,70.39) 105.31,70.39 102.53,73.16 101.21,73.16 99.51,74.86 v3(98.67,74.86) 98.63,74.82 98.63,74.29 98.07,73.73 96.41,73.73 95.43,74.71 94.27,74.71 93.53,73.97 93.53,73.75 91.33,71.55 90.72,71.55 90.04,70.87 89.7,70.87 v1(88.58,69.75) 88.13,69.3 88.13,68.69 84.6,65.16 84.1,65.16 83.83,64.89 82.28,63.34 80.22,63.34 79.51,62.63 78.13,62.63 v1(77.84,62.34)
  IN2 w0.079: v1(77.84,62.34) 77.49,62.34 74.91,59.76 74.91,56.31 74.11,55.51 72.99,55.51 70.92,53.44 70.92,51.94 70.38,51.4 70.38,45.51 71.53,44.36 71.53,43.4 71.85,43.07 71.85,42.58 71.64,42.37 71.64,40.68 72.55,39.78 72.55,38.21 73.3,37.46 73.3,34.98 74.32,33.96 74.32,32.75 74.77,32.3 74.77,29.95 78.89,25.84 80.17,25.84 83.86,22.15 84.96,22.15 88.9,18.21 91.14,18.21 94.41,14.94 94.66,14.94 94.95,14.65 98.15,14.65 98.42,14.92 99.36,14.92 99.85,14.43 101.65,14.43 101.82,14.6 104.43,14.6 104.54,14.49 107.28,14.49 107.42,14.34 v1(109.1,14.34) 110.76,14.34 113.08,16.67 113.78,16.67 116.88,19.76 120.98,19.76 121.73,19.01 141.78,19.01 v1(142.05,19.29)
  BOTTOM w0.102: RAP1360.1 105.42,10.12 107.84,10.12 108.96,11.23 108.96,12.38 109.26,12.68 109.26,14.18 v1(109.1,14.34) ; v1(106.82,70.39) 106.68,70.53 R5107.2 ; v1(183.96,20.81) 185.56,22.4 188.21,22.4 192.04,18.58 192.04,11.84 190.97,10.78 190.97,9.35 191.51,8.82 196.44,8.82 197.2,9.58 222.57,9.58 225.52,12.53 225.52,14.19 225.78,14.45 CN2.30 ; R5009.2 92.15,56.73 91.86,56.73 90.63,57.95 90.63,58.47 89.84,59.26 89.84,61.64 v1(90.04,61.83)
SD_RCOMP: length 13.5
  IN1 w0.203: v3(96.23,55.86) 96.59,55.51 97.71,55.51 98.15,55.95 103.45,55.95 104.53,57.03 105.16,57.03 105.27,56.92 106.9,56.92 107.31,57.32 v3(107.31,57.41)
  BOTTOM w0.203: v3(96.23,55.86) 96.21,55.84 RAP1050.1 ; U80.AB7 106.95,56.96 107.31,57.32 v3(107.31,57.41)
SERVO_EC_RST*: length 3.1
  BOTTOM w0.102: CR15.1 103.98,17.99 v1(104.49,17.48) 104.73,17.24 CN17.14
SERVO_EC_SPI_CLK: length 46.3
  TOP w0.102: v1(108.4,20.78) 108.4,20.33 107.26,19.18 103.37,19.18 100.25,22.31 100.25,23.77 99.38,24.64 v1(99.35,24.64)
  BOTTOM w0.102: RPM3579.1 RPM3462.1 87.98,31.91 86.89,30.82 86.89,29.97 85.84,28.93 85.84,27.13 86.23,26.74 87.43,26.74 87.75,27.06 90.12,27.06 90.3,27.24 93.16,27.24 94.23,26.17 98.01,26.17 99.35,24.83 v1(99.35,24.64) ; v1(108.4,20.78) 108.4,15.13 107.68,14.41 107.15,14.41 106.44,13.7 106.44,12.76 105.79,12.11 105.74,12.11 105.53,11.89 CN17.9
SERVO_EC_SPI_CS*: length 31.9
  TOP w0.102: v1(106.54,20.71) 105.65,19.82 103.63,19.82 100.88,22.57 100.88,24.3 98.42,26.75 97.96,26.75 97.35,27.36 v1(97.35,27.72)
  BOTTOM w0.102: v1(97.35,27.72) 97.48,27.85 RPM3463.1 98,27.58 97.5,27.08 94.4,27.08 93.56,27.92 90.09,27.92 89.86,27.69 88.51,27.69 88.26,27.94 RPM3468.2 88.26,28.82 RPM3578.1 ; v1(106.54,20.71) 106.54,19.26 105.43,18.14 105.43,16.59 105.53,16.49 CN17.10
SERVO_EC_SPI_MISO: length 31.2
  TOP w0.102: v1(105.91,20.71) 105.25,20.05 103.73,20.05 101.11,22.67 101.11,24.39 v1(98.34,27.16)
  BOTTOM w0.102: v1(105.91,20.71) 105.91,18.95 105.13,18.17 CN17.12 ; RPM3581.1 88.1,29.64 87.7,29.24 87.7,28.11 88.34,27.47 89.95,27.47 90.13,27.64 93.52,27.64 94.58,26.58 98.33,26.58 RPM3461.1 98.38,27.12 v1(98.34,27.16)
SERVO_EC_SPI_MOSI: length 42.5
  TOP w0.102: v1(96.84,28.07) 96.84,27.55 97.87,26.53 98.33,26.53 100.65,24.2 100.65,22.48 103.54,19.59 106.67,19.59 107.76,20.68 v1(107.76,20.78) ; v1(89.07,33.83) 89.12,33.88 RPM3580.1 RPM3460.1
  BOTTOM w0.102: v1(89.07,33.83) 89.1,33.87 91.67,33.87 92.52,33.01 92.52,32.24 91.94,31.66 91.94,29.4 92.3,29.04 93.22,29.04 94.18,28.07 v1(96.84,28.07) ; v1(107.76,20.78) 107.76,20.05 107.99,19.82 107.99,15.3 107.46,14.77 106.91,14.77 106.04,13.89 106.04,12.86 105.13,11.95 CN17.11
SERVO_PCH_SPI_CLK: length 66.6
  IN2 w0.079: v1(76.63,53.99) 76.63,53.78 75.58,52.73 75.58,51.85 75.01,51.29 75.01,48.51 74.83,48.33 74.83,42.86 75.31,42.38 75.31,41.27 77.09,39.49 77.09,36.99 77.51,36.57 77.51,33.57 77.85,33.23 77.85,32.42 79.84,30.44 79.84,29.16 80.6,28.39 82.11,28.39 83.52,26.99 84.89,26.99 88.43,23.45 88.43,23.33 88.24,23.14 88.24,23.03 88.4,22.87 88.51,22.87 88.71,23.06 88.82,23.06 88.98,22.9 88.98,22.79 88.78,22.6 88.78,22.49 88.94,22.33 89.05,22.33 89.25,22.52 89.36,22.52 89.52,22.36 89.52,22.25 89.33,22.06 89.33,21.94 89.49,21.78 89.6,21.78 89.79,21.98 89.9,21.98 90.06,21.82 90.06,21.71 89.87,21.51 89.87,21.4 90.03,21.24 90.14,21.24 90.33,21.44 90.44,21.44 90.75,21.13 92.25,21.13 95.45,17.92 96.54,17.92 96.73,17.73 103.12,17.73 103.22,17.63 103.22,17.41 103.32,17.31 103.55,17.31 103.63,17.38 103.63,17.66 103.71,17.73 103.98,17.73 104.08,17.63 104.08,17.38 104.17,17.29 104.69,17.29 104.79,17.19 104.79,16.99 104.89,16.89 105.1,16.89 105.2,16.99 105.2,17.17 105.33,17.29 107.08,17.29 107.14,17.23 v1(107.14,16.89)
  BOTTOM w0.102: CN17.2 107.21,16.81 v1(107.14,16.89) ; v1(76.63,53.99) 76.93,53.7 RAP1406.2
SERVO_PCH_SPI_CLK_R: length 8.4
  BOTTOM w0.102: R866.2 71.11,56.39 71.11,56.19 v1(71.19,56.12) 71.65,55.66 74.87,55.66 76.23,54.3 76.23,53.82 76.48,53.58 RAP1406.1
SERVO_PCH_SPI_CS*: length 77.5
  TOP w0.102: RAP1405.2 80.18,57.23 79.17,57.23 79,57.4 78.09,57.4 v1(77.61,56.93)
  IN2 w0.079: v1(108.96,16.77) 107.64,16.77 107.16,16.3 102.4,16.3 102.2,16.49 97.14,16.49 96.3,17.33 95.21,17.33 92,20.54 89.9,20.54 85.14,25.3 85.14,25.67 84.41,26.4 83.27,26.4 82.96,26.71 81.86,27.81 80.36,27.81 79.25,28.92 79.25,30.19 77.27,32.17 77.27,32.98 76.92,33.33 76.92,33.95 76.29,34.58 76.29,35.03 76.85,35.6 76.85,36.4 76.5,36.75 76.5,38.6 74.72,40.38 74.72,42.14 74.24,42.62 74.24,48.57 74.38,48.72 74.38,51.49 74.99,52.1 74.99,53.26 77.61,55.89 v1(77.61,56.93)
  BOTTOM w0.102: CN17.3 106.73,11.88 107.61,12.76 107.61,13.44 109.26,15.1 109.26,16.47 v1(108.96,16.77)
SERVO_PCH_SPI_CS*_R: length 8.9
  TOP w0.102: v1(81.45,57.06) 81.45,56.74 81.08,56.37 81.08,56.37 80.94,56.22 RAP1405.1 80.41,56.22 80.02,55.83 R865.2 79.43,55.83 78.98,56.27 76.97,56.27 76.29,56.95 RAP1412.1
  BOTTOM w0.102: v1(81.45,57.06) 81.45,57.61 80.87,58.2 UAP1012.1
SERVO_PCH_SPI_HOLD*: length 74
  TOP w0.102: v1(73.65,56.36) 74.04,55.97 RAP1408.1
  IN2 w0.079: v1(106.9,13.32) 106.69,13.1 105.49,13.1 104.97,13.62 103.83,13.62 103.49,13.96 102.09,13.96 101.92,13.79 97.28,13.79 97.05,14.01 94.63,14.01 94.34,14.3 94.15,14.3 90.88,17.57 88.63,17.57 84.7,21.51 83.6,21.51 79.91,25.2 78.6,25.2 73.68,30.11 73.68,33.58 72.66,34.61 72.66,37.19 71.91,37.94 71.91,39.51 71.18,40.23 71,40.42 71,44.24 69.92,45.32 69.92,51.86 69.79,51.99 69.79,53.2 72.95,56.36 v1(73.65,56.36)
  BOTTOM w0.102: v1(106.9,13.32) 106.9,12.81 105.93,11.84 CN17.7
SERVO_PCH_SPI_MISO: length 81.6
  IN2 w0.079: v1(108.81,16.09) 107.32,16.09 107.31,16.09 102.31,16.09 102.12,16.29 97.06,16.29 96.22,17.13 95.12,17.13 91.92,20.33 89.81,20.33 84.93,25.21 84.93,25.59 84.32,26.19 83.19,26.19 83.16,26.21 81.78,27.6 80.27,27.6 79.04,28.83 79.04,30.11 77.06,32.09 77.06,32.9 76.71,33.24 76.71,33.86 76.08,34.5 76.08,35.12 76.64,35.68 76.64,36.31 76.29,36.66 76.29,38.52 76.12,38.69 74.51,40.3 74.51,42.05 74.03,42.54 74.03,48.66 74.04,48.67 74.04,52.22 73.97,52.29 73.97,52.69 76.9,55.62 v1(76.9,56.93)
  BOTTOM w0.102: v1(108.81,16.09) 108.81,14.96 107.38,13.54 107.38,12.94 106.33,11.88 CN17.5 ; v1(76.9,56.93) 76.9,56.3 79.24,53.96 81.15,53.96 81.74,54.55 81.74,55 82.16,55.43 82.67,55.43 82.74,55.5 RAP1409.2
SERVO_PCH_SPI_MOSI: length 68.6
  IN2 w0.079: v1(106.47,16.89) 106.47,16.61 106.36,16.5 104.34,16.5 104.26,16.58 104.26,16.83 104.18,16.91 104.03,16.91 103.95,16.83 103.95,16.58 103.87,16.5 103.09,16.5 102.99,16.61 102.99,17.01 102.79,17.2 102.68,17.2 102.58,17.1 102.58,16.85 102.48,16.75 102.33,16.75 102.23,16.85 102.23,17.25 102.13,17.35 101.96,17.35 101.88,17.27 101.88,16.89 101.79,16.8 101.65,16.8 101.56,16.89 101.56,17.27 101.48,17.35 101.33,17.35 101.25,17.27 101.25,16.89 101.16,16.8 101.02,16.8 100.93,16.89 100.93,17.27 100.85,17.35 98.84,17.35 98.76,17.27 98.76,16.79 98.67,16.7 98.54,16.7 98.45,16.79 98.45,17.27 98.37,17.35 98.21,17.35 98.13,17.27 98.13,16.79 98.04,16.7 97.91,16.7 97.82,16.79 97.82,17.27 97.74,17.35 97.58,17.35 97.5,17.27 97.5,16.79 97.41,16.7 97.28,16.7 97.19,16.79 97.19,17.27 97.11,17.35 96.57,17.35 96.39,17.54 95.29,17.54 92.09,20.75 89.98,20.75 85.34,25.39 85.34,25.76 84.49,26.6 83.36,26.6 81.95,28.01 80.44,28.01 79.45,29 79.45,30.28 77.47,32.26 77.47,33.07 77.13,33.41 77.13,36.41 76.7,36.84 76.7,38.69 74.92,40.47 74.92,42.23 74.44,42.71 74.44,48.49 74.59,48.63 74.59,51.4 75.19,52.01 75.19,52.91 75.88,53.59 v1(75.88,53.59)
  BOTTOM w0.102: v1(75.88,53.59) 75.91,53.57 RAP1410.2 ; CN17.4 106.73,16.62 v1(106.47,16.89)
SERVO_SPI_WP*: length 75.5
  TOP w0.102: v1(67.92,59.39) 68.3,59.02 RAP1407.1
  IN2 w0.079: v1(95.7,13.14) 94.45,13.14 94.03,13.56 93.84,13.56 90.57,16.83 88.32,16.83 84.66,20.49 79.87,20.49 76.8,23.55 76.5,23.55 71.63,28.42 71.63,31.44 70.96,32.12 70.96,33.43 68.46,35.92 67.81,35.92 66.52,37.22 66.52,39.48 65.54,40.46 65.54,43.17 63.71,45 63.71,46.88 64.33,47.5 64.33,53.07 64.66,53.39 64.66,56.8 64.9,57.04 65.46,57.04 65.68,57.26 65.68,58.07 65.93,58.33 66.95,58.33 67.92,59.3 v1(67.92,59.39)
  BOTTOM w0.102: CN17.40 99.53,15.22 99.53,15.21 99.53,13.89 99.19,13.55 96.11,13.55 v1(95.7,13.14)
SKL_CNL*: length 11.9
  BOTTOM w0.076: 141.3,43.36 141.2,43.36 139.91,44.64 139.91,46.66 U80.C64
  BOTTOM w0.102: RAP1324.1 148.14,41.32 v1(147.57,41.89) 147.27,42.19 146.12,42.19 144.96,43.36 141.3,43.36
SM_INTRUDER*: length 26.6
  IN1 w0.079: v1(94.41,73.64) 94.61,73.44 95.06,73.44 95.41,73.09 97.65,73.09 97.97,72.77 98.72,72.77 99.4,72.09 99.67,72.09 101.55,70.21 102.63,70.21 104.67,68.17 107.19,68.17 107.78,67.58 109.39,67.58 110.68,66.29 112.22,66.29 112.67,65.84 112.67,64.09 v3(113.04,63.72)
  BOTTOM w0.076: v3(113.04,63.72) U80.AP16
  BOTTOM w0.102: RAP1075.2 94.41,74.38 v1(94.41,73.64)
SM_RCOMP_0: length 23.3
  IN1 w0.152: 114.42,66.89 114.6,66.71 114.6,65.35 114.42,65.17 114.42,64.83 v3(113.95,64.36)
  IN1 w0.254: 114.42,66.89 114.42,67.7 113.25,68.87 113.25,69.09 112,70.34 111.26,70.34 109.99,71.61 108.95,71.61 108.61,71.95 105.95,71.95 104.92,72.98 104.92,74.05 104.24,74.72 102.29,74.72 101.29,75.73 v3(101.29,76.2)
  BOTTOM w0.254: v3(113.95,64.36) U80.AR18 ; RAP1019.1 100.61,76.49 100.83,76.49 101.12,76.2 v3(101.29,76.2)
SM_RCOMP_1: length 20.9
  IN1 w0.152: 113.5,67.89 113.5,66.59 113.87,66.22 114.02,66.22 114.36,65.89 114.36,65.46 113.95,65.05 v3(113.95,64.99)
  IN1 w0.254: 113.5,67.89 112.69,68.71 112.69,68.88 111.74,69.83 111.05,69.83 109.78,71.1 108.74,71.1 108.4,71.44 105.74,71.44 102.97,74.22 101.95,74.22 v3(101.15,75.02)
  BOTTOM w0.254: v3(113.95,64.99) U80.AT18 ; v3(101.15,75.02) 101.14,75.01 100.87,75.01 100.23,75.65 RAP1018.1
SM_RCOMP_2: length 18.8
  IN1 w0.203: v3(113.95,65.65) 113.95,65.74 112.99,66.69 112.99,67.33
  IN1 w0.254: 112.99,67.33 112.99,67.65 111.91,68.74 111.35,68.74 109.52,70.57 108.52,70.57 108.15,70.93 105.53,70.93 102.76,73.71 101.68,73.71 101.37,74.02 v1(101.37,74.08)
  BOTTOM w0.254: v3(113.95,65.65) 113.85,65.65 U80.AU18 ; v1(101.37,74.08) 101.11,74.08 100.35,74.84 RAP1017.1
SMB_CLK: length 11.3
  IN1 w0.079: v1(97.91,52.09) 97.93,52.11 100.26,52.11 100.61,51.76 101.98,51.76 102.38,52.15 103.85,52.15 105.62,53.92 106.37,53.92 106.38,53.92 106.41,53.92 106.52,54.03 v3(106.59,54.14)
  BOTTOM w0.102: U80.R7 106.9,53.83 v3(106.59,54.14) ; v1(97.91,52.09) 97.33,52.09 RAP1051.1
SMB_DATA: length 12.2
  IN1 w0.079: v3(107.24,54.14) 106.83,53.73 105.76,53.73 104,51.97 102.45,51.97 102.05,51.57 100.54,51.57 100.18,51.93 98.34,51.93 98.01,51.6 v1(97.55,51.6)
  BOTTOM w0.102: RAP1052.1 97.09,51.13 v1(97.55,51.6) ; U80.R8 107.55,53.83 v3(107.24,54.14)
SOC_CATERR*: length 11.9
  BOTTOM w0.076: U80.D63 139.11,47.51 139.04,47.41 138.96,47.14 138.96,47.02 138.89,46.78 138.82,46.54 138.82,46.3 138.86,46.21 138.86,46.02 138.82,45.92 138.82,45.56 139.09,45.3 139.09,44.3 139.79,43.59 139.79,43.39
  BOTTOM w0.102: R49.2 143.25,39.65 143.25,39.94 143.6,40.29 v2(143.6,40.6) 143.6,40.7 143.26,41.04 143.26,41.53 142.77,42.02 140.86,42.02 139.79,43.09 139.79,43.39
SOC_PROCHOT*: length 111.6
  IN1 w0.079: v1(149.04,39.05) 146.94,36.95 140.87,36.95 139.77,35.85 139.77,34.3 131.99,26.53 125.49,26.53 119.46,20.49 117,20.49 115.21,18.7 112.84,18.7 109.57,15.43 109.57,13.55 107.42,11.39 101.1,11.39 100.65,11.84 v1(100.65,12.28)
  IN2 w0.079: v1(100.65,12.28) 100.35,11.97 94.45,11.97 93.69,12.73 93.5,12.73 90.89,15.34 88.65,15.34 84.32,19.67 78.92,19.67 75.82,22.76 75.82,23 70.11,28.71 70.11,32.18 v1(70.02,32.27)
  BOTTOM w0.102: R1180.1 149.71,42.53 R66.2 149.75,41.49 149.75,40.11 149.04,39.4 v1(149.04,39.05) ; R1076.1 69.7,32.59 v1(70.02,32.27) 70.34,32.27 71.09,33.01 QPM3251.3
SOC_THRMTRIP*: length 12.6
  BOTTOM w0.076: 140,43.39 140,43.62 139.25,44.37 139.25,45.36 138.99,45.63 138.99,45.89 139.05,46 139.05,46.15 138.99,46.35 138.99,46.52 139.07,46.77 139.24,47.06 U80.C63
  BOTTOM w0.102: 140,43.39 140,43.21 140.99,42.22 143.25,42.22 v2(143.5,41.97) 143.65,41.82 143.65,41.39 144.24,40.8 144.24,39.32 R88.2 145.02,39.15 C6005.2
SOURCE_EC_PROCHOT*: length 3.4
  TOP w0.102: v1(76.37,37.75) 77.3,37.75 R1074.2 77.83,37.74 77.85,37.72 R1075.2 78.84,37.72 v1(78.9,37.66)
  BOTTOM w0.102: EUPM3247.B19 78.78,37.54 v1(78.9,37.66)
SPI_TPM_IRQ*: length 79.3
  TOP w0.102: U82.18 61.62,56.52 61.95,56.19 62.85,56.19 63.16,55.88 63.16,55.43 63.01,55.27 RAP1424.2 62.45,55.27 v1(62.02,54.84) 61.59,54.41 61.59,53.47 61.05,52.94 60.51,52.94 v1(59.89,52.32)
  IN1 w0.079: v1(103.01,49.21) 102.53,48.72 102.53,45.73 101.91,45.11 101.53,45.11 98.38,41.96 97.34,41.96 96.09,40.7 95.6,40.7 93.58,38.69 93.58,37.11 88.18,31.72 83.93,31.72 83.6,32.04 76.01,32.04 74.56,33.49 73.46,33.49 72.04,34.91 70.67,34.91 69.2,36.38 69.11,36.38 68.46,37.03 66.5,37.03 62.52,41.01 60.6,41.01 v1(60.27,41.33)
  IN2 w0.079: v1(60.27,41.33) 60.27,41.81 57.77,44.32 57.77,45.64 57.43,45.98 57.43,49.87 59.87,52.32 v1(59.89,52.32)
  BOTTOM w0.102: v1(103.01,49.21) 103.48,49.68 104.21,49.68 U80.H2
SPK_OUT_L_N:
  vias: v1(32.38,17.53)
SPK_OUT_L_P:
  vias: v1(31.03,17.64)
SPK_OUT_R_N:
  vias: v1(37.94,17.2)
SPK_OUT_R_P:
  vias: v1(36.59,17.15)
SRTCRST*: length 91
  IN2 w0.079: v3(113.95,63.09) 113.44,63.6 113.44,66.78 110.75,69.47 110.75,70.63 108.68,72.7 107.15,72.7 106.6,73.26 v1(106.11,73.26) 105.88,73.26 105.55,72.93 103.8,72.93 103.44,73.29 102.81,73.29 101.61,74.49 98.37,74.49 98.1,74.22 95.73,74.22 95.6,74.35 94.16,74.35 93.73,73.92 93.73,73.5 93.28,73.05 93.28,72.01 92.57,71.3 92.57,67.95 92.12,67.51 92.12,64.8 91.55,64.22 89.68,64.22 86.84,61.38 86.84,59.47 85.94,58.57 85.94,58.09 85.62,57.77 85.62,49.25 86.05,48.83 86.05,47.28 88.31,45.02 88.31,43.68 88.49,43.5 88.49,43.07 88.75,42.81 88.75,42.62 89.69,41.68 89.69,40.49 90.36,39.82 91.03,39.82 91.35,39.49 91.35,38.35 93.97,35.74 v1(93.97,35.6)
  BOTTOM w0.076: U80.AN18 113.56,62.69 v3(113.95,63.09)
  BOTTOM w0.102: v1(106.11,73.26) 106.11,73.33 105.37,74.07 105.13,74.07 104.26,74.95 103.89,74.95 103.6,75.24 103.6,76.21 102.69,77.12 RAP3052.1 101.24,77.35 101.24,78.21 100.69,78.76 CAP1079.2 99.72,79.87 v1(99.43,79.87) 99.01,79.87 RAP1078.2 98.4,79.33 97.87,79.87 97.34,79.87 C6002.2 ; v1(93.97,35.6) 94.11,35.47 QPM3391.3
SUS_CLK: length 235.7
  TOP w0.102: v1(155.49,93.95) 155.98,93.95 159.81,90.13 171.09,90.13 173.3,92.34 187.62,92.34 190.47,89.49 190.47,79.69 187.7,76.92 187.7,68.48 188.53,67.65 189.87,67.65 192.75,64.76 192.75,61.62 195.88,58.5 195.88,50.47 202.05,44.3 202.05,42.09 202.32,41.81 202.32,39.94 206.77,35.49 206.77,32.6 205.63,31.45 204.72,31.45 201.8,28.53 v1(201.16,28.53) ; v3(110.79,73.13) 111.53,73.13 TP120.1
  IN1 w0.079: v1(104.83,94.99) 104.83,89.1 102.16,86.42 102.16,81.57 104.38,79.34 107.82,79.34 110.07,77.1 110.07,74.68 110.13,74.62 110.13,73.55 110.55,73.13 v3(110.79,73.13)
  IN2 w0.079: v1(104.83,94.99) 106.16,93.67 125.48,93.67 126.95,95.14 130.39,95.14 130.83,94.7 134.5,94.7 135.02,95.22 136.79,95.22 137.31,94.7 138.24,94.7 138.98,93.95 155.49,93.95 v1(155.49,93.95)
  BOTTOM w0.076: U80.BA17 112.99,68.03 112.99,70.01 110.66,72.34 110.66,73 v3(110.79,73.13)
  BOTTOM w0.102: v1(201.16,28.53) 199.43,26.8 199.43,19.54 199.13,19.24 199.13,10.73 198.47,10.07 194.61,10.07 192.52,12.15 192.52,16.87 192.85,17.2 CN8.50
SUSLED#: length 104.5
  TOP w0.102: Q110.2 13.45,73.16 14.06,72.55 15.75,72.55 16.48,71.82 16.48,71.18 17.49,70.16 19.73,70.16 v1(20.16,70.59)
  IN1 w0.079: v1(20.16,70.59) 20.92,70.59 22.02,69.49 23.21,69.49 23.67,69.03 26.05,69.03 26.51,69.49 39.7,69.49 42.84,66.35 50.51,66.35 v1(51.22,65.64)
  IN2 w0.079: v1(69.72,31.38) 69.58,31.51 69.58,32.16 69.26,32.49 64.86,32.49 59.41,37.94 59.31,37.94 58.54,38.7 56.01,38.7 54.07,40.64 54.07,56.93 53.79,57.21 53.79,60.1 54.88,61.19 54.88,62.37 53.92,63.32 52.3,63.32 51.37,64.25 51.37,65.49 v1(51.22,65.64)
  BOTTOM w0.102: EUPM3247.B17 78.71,36 78.63,35.92 78.63,34.25 78.07,33.69 77.54,33.69 76.36,32.51 v1(76.01,32.51) 74.14,32.51 73.66,32.04 70.54,32.04 69.88,31.38 v1(69.72,31.38)
SW1: length 5.9
  TOP w0.33: v1(68.42,68.87) 68.15,69.14 PR69.2 67.8,70.84 v1(67.84,70.87)
  BOTTOM w0.305: v1(67.84,70.87) 67.96,71 67.96,74.18 PU3254.T13
SW2: length 9.9
  BOTTOM w0.254: PU3254.K15 PU3254.K16 65.69,77.19 65.63,77.25
  BOTTOM w0.457: 65.63,77.25 65.17,77.71 v1(64.85,77.71) 61.26,77.71 60.6,78.36 PL2.1
SW3: length 9.8
  TOP w0.305: PR68.2 63.34,86.67 63.06,86.95 v1(62.7,86.95)
  BOTTOM w0.305: v1(62.7,86.95) 63.52,86.95 64.18,86.29 64.18,85.4 66.57,83.01 67.63,83.01 67.97,82.68 PU3254.A13
SW4: length 8.1
  TOP w0.254: v1(72.66,85.89) 72.66,85.55 PR67.2 72.95,85.49 73.22,85.76 74.6,85.76 v1(75.11,85.24)
  BOTTOM w0.305: 72.47,81.98 72.47,82.39 75.11,85.03 75.11,85.27 75.11,85.26 v1(75.11,85.24)
  BOTTOM w0.33: PU3254.A4 72.47,81.98
  vias: v1(71.19,84.74)
SWVR5: length 11
  TOP w0.254: v1(78.33,78.83) 78.11,79.05 PR66.2
  BOTTOM w0.305: PU3254.T4 72.47,74.09 73.15,73.41 73.16,73.41 73.26,73.31 74.9,73.31 76.83,75.24 76.83,76.08 77.16,76.41 v1(77.16,77.15) 77.16,77.88 77.42,78.15 PU3048.5
SYS_SHDN#: length 156.2
  TOP w0.102: PR76.2 64.6,74.35 v1(64.22,73.97) 63.78,73.53 62.77,73.53 62.3,74 PR21.1
  IN1 w0.079: v1(64.22,73.97) 64.86,73.33 64.86,71.9 65.29,71.47 67.31,71.47 67.55,71.71 71.75,71.71 72.64,70.82 75.86,70.82 77.41,69.27 v1(80.36,69.27)
  IN2 w0.079: v1(80.36,69.27) 81.48,69.27 82.72,70.52 82.72,73.01 83.61,73.9 83.61,79.18 87.08,82.65 88.17,82.65 90.77,85.25 90.77,87.87 90.39,88.25 89.1,88.25 88.63,88.72 88.63,89.38 92.58,93.33 95.47,93.33 98.11,95.96 137.95,95.96 139.48,94.44 155.82,94.44 156.45,93.81 156.45,92.85 159.52,89.79 170.18,89.79 178.27,81.7 v1(178.27,75.98)
  BOTTOM w0.102: PR9.2 v1(178.27,75.98)
TABLET_MODE: length 1.4
  TOP w0.102: 117.19,21.88 116.3,21.88 TP252.1
TCH_I2C_SCL: length 8
  TOP w0.102: Q137.1 49.23,62.38 48.87,62.02 R5155.2 48.87,60.36 48.85,60.34 R346.2 v1(48.85,59.03)
  BOTTOM w0.102: J8L1.32 51.9,60.09 51.71,59.9 50.08,59.9 49.21,59.03 v1(48.85,59.03)
TCH_I2C_SDA: length 10.6
  TOP w0.102: v1(50.97,65.08) 50.24,65.82 R338.2 48.09,65.04 R5154.2 48.66,64.24 48.66,63.84 48.5,63.68 Q137.4
  BOTTOM w0.102: J8L1.33 52.4,62.03 50.97,63.45 v1(50.97,65.08)
TCH_INTR*: length 24.6
  TOP w0.102: Q139.1 39.6,58.08 R5158.1 v1(40.47,57.31) 40.48,57.31 41.25,58.08 R6006.2 40.62,61.67 39.8,61.67 39.58,61.89 39.58,62.23 39.83,62.49 40.53,62.49 41.09,63.05 41.98,63.05 44.33,65.4 44.39,65.46 v1(45.05,65.46)
  BOTTOM w0.102: v1(45.05,65.46) 45.51,65.01 45.86,65.01 46.53,65.67 47.14,65.67 50.31,62.49 50.31,61.54 50.4,61.45 J8L1.29
TCH_PNL_INTR*: length 113.9
  TOP w0.102: v1(40.2,62.9) 39.91,62.9 39.21,62.19 Q139.3 40.17,60.74 R6006.1
  IN1 w0.079: v1(40.2,62.9) 40.4,62.69 40.4,61.17 40.78,60.79 40.78,58.91 41.11,58.58 44.01,58.58 45.06,57.53 45.51,57.53 48.79,54.26 49.31,54.26 49.83,53.74 49.83,53.2 49.72,53.09 49.72,51.04 50.23,50.53 50.23,49.28 52.56,46.95 52.56,44.58 53.78,43.35 57.56,43.35 58.62,42.3 60.65,42.3 61.38,41.57 62.76,41.57 66.73,37.6 68.69,37.6 69.35,36.94 69.43,36.94 69.58,36.8 70.9,35.47 72.62,35.47 74.04,34.06 75.8,34.06 76.68,33.18 78.7,33.18 79.27,32.61 83.84,32.61 84.16,32.28 85.25,32.28 85.85,32.87 87.47,32.87 90.82,36.23 90.82,36.73 93.69,39.6 93.69,43.21 93.16,43.75 93.16,46.58 93.43,46.85 93.43,47.48 93.69,47.74 93.69,47.97 94.71,48.99 v1(94.71,49.36)
  BOTTOM w0.076: U80.A7 106.76,45.5 105.99,45.5 105.63,45.14 105.63,44.72 103.82,42.91 RAP1453.2
  BOTTOM w0.102: R5159.1 v1(94.71,49.36) 94.71,49.01 93.67,47.97 93.67,47.56 v1(93.58,47.47) 93.49,47.38 93.49,46.97 93.39,46.87 93.39,44.49 95.12,42.76 96.23,42.76 96.65,42.34 98.38,42.34 98.98,41.74 98.98,41.28 99.26,41 100.02,41 100.37,41.36 101.24,41.36 102.12,42.24 103.61,42.24 103.82,42.46 RAP1453.2
