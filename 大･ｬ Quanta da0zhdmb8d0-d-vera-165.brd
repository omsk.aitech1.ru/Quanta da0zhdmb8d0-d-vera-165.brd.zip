# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N19466265: length 1.7
  TOP w0.102: U138.13 95.62,74.41 95.67,74.36 R5146.2
N19743292: length 5
  TOP w0.102: U138.12 94.97,77.51 96.03,78.57 R5139.1
N19797876: length 2.9
  TOP w0.102: v1(37.48,45.17) 37.48,44.54 R1181.2 36.89,44.78 U95.36
N19797932: length 1.9
  TOP w0.102: U95.35 36.39,45.68 36.21,45.5 v1(36.21,45.27) 36.16,45.22 R1182.2
N20576888: length 3.8
  BOTTOM w0.102: PU1.5 185.24,73.51 PC46.1 PR14.2 v1(185.38,75.83)
N20576892: length 12.4
  BOTTOM w0.102: PU1.1 v1(179.78,73.51) 178.72,73.51 177.18,75.04 177.18,77.83 178.33,78.98 178.33,82.03 PR15.1
N20576900: length 2.7
  BOTTOM w0.102: PU1.3 179.23,75.4 PR9.1 v1(179.05,76.06)
N20656100: length 5.3
  TOP w0.102: R870.1 75.4,55.56 72.76,55.56 v1(72.43,55.89) 73.01,56.46 73.01,56.57 72.92,56.66 UAP1008.4
N21137008: length 4.5
  TOP w0.102: v1(19.5,47.48) 19.27,47.48 19.17,47.38 19.17,47.07 19.27,46.97 U26.17
  BOTTOM w0.102: C1104.2 v1(17.76,47.28) 19.3,47.28 v1(19.5,47.48)
N21153040: length 2.2
  TOP w0.102: U3.4 37.02,22.77 36.93,22.86 v1(36.93,23.32) 36.93,24.28 R1D4.1
N21154824: length 2.5
  TOP w0.102: v1(31.89,24.52) 31.85,24.48 R1D13.1 31.85,22.7 31.89,22.67 U5.4
N21155644: length 4.7
  TOP w0.102: U5.2 32.89,23.29 R1D12.1 R1B28.1 34.84,24.1 34.84,24.9 v1(35.12,25.18)
N21157615: length 1.5
  BOTTOM w0.102: EUCP4040.15 29.01,33.14 29.05,33.18 RCP4194.1
N21157617: length 1.7
  BOTTOM w0.102: EUCP4040.16 29.51,33.38 RCP4193.1
N21158850: length 2.2
  BOTTOM w0.102: EUCP4040.6 29.01,28.72 28.29,28 R1157.2
N21158856: length 2.4
  BOTTOM w0.102: EUCP4040.7 28.51,28.78 v1(27.83,28.1) 27.63,28.1 27.4,27.87 RCP4190.2
N21158858: length 3
  BOTTOM w0.102: EUCP4040.8 28.01,28.74 27.78,28.51 26.92,28.51 v1(26.56,28.15) 26.51,28.1 RCP4191.2
N21160290: length 7.5
  TOP w0.102: R5100.2 R5098.1 R5102.1 33.9,34.29 v1(34.21,33.99) 34.51,33.69 34.51,31.15 34,30.64 QCP4112.2
N21357334: length 2.3
  TOP w0.102: TP189.1 80.23,38.29 v1(79.62,38.29)
  BOTTOM w0.102: v1(79.62,38.29) 79.41,38.07 78.57,38.07 78.54,38.04 EUPM3247.B20
N21357342: length 4
  TOP w0.102: v1(78.81,44.92) 78.81,45.3 76.93,47.18 TP190.1
  BOTTOM w0.102: v1(78.81,44.92) 78.81,45.04 79.21,45.44 EUPM3247.B36
N21357344: length 1.7
  TOP w0.102: v1(85.64,44.92) 85.64,45.44 TP202.1
  BOTTOM w0.102: v1(85.64,44.92) 85.71,44.99 EUPM3247.B49
N21533023: length 8.9
  TOP w0.102: v1(81.42,56.14) 80.82,55.53 v1(80.61,55.53) 80.51,55.43 79.49,55.43 78.88,56.04 77.06,56.04 77,55.99 R870.2 76.11,56.49 75.96,56.49 RAP1413.1
  BOTTOM w0.102: 80.07,55.66 80.94,55.66 v1(81.42,56.14)
N21533075: length 4
  TOP w0.102: RAP1408.2 74.77,56.87 74.34,57.3 RAP1414.1 74.01,56.85 v1(74.24,56.62)
  BOTTOM w0.102: UAP1012.7 73.93,56.93 v1(74.24,56.62)
N21758250: length 2.1
  TOP w0.102: TP250.1 61.82,50.22 v1(61.61,50.02)
  BOTTOM w0.102: v1(61.61,50.02) 61.61,49.51 USM2006.E9
N21758257: length 1.6
  TOP w0.102: TP251.1 60.55,50.45 v1(60.95,50.05)
  BOTTOM w0.102: v1(60.95,50.05) 60.95,49.81 USM2006.E10
N22199236: length 0.9
  TOP w0.102: TP143.1 16.71,58.84 U97.4
N22281245: length 15.8
  TOP w0.102: v3(107.48,64.33) 107.32,64.33 106.65,65.01 103.95,65.01 103.56,64.61 101.86,64.61 101.11,65.36 101.11,67.7 98.08,70.73 98.08,71.44 97.72,71.8 RAP1432.2
  BOTTOM w0.102: v3(107.48,64.33) 107.43,64.33 U80.AR7
N22353822: length 10.3
  BOTTOM w0.102: U80.H1 102.04,49.96 101.62,50.37 99.94,50.37 99.81,50.24 99.81,49.79 99.56,49.54 v1(97.99,49.54) 97.57,49.95 95.96,49.95 95.86,49.85 95.44,49.85 94.99,50.3 R5159.2
N22390889: length 2.5
  BOTTOM w0.102: QPM3360.3 94.61,39.53 94.96,39.18 R1048.2 96,39.18 v1(96.11,39.07)
N22574114: length 2.8
  TOP w0.203: PR142.1 191.26,37.87 191.26,37.64 191.65,37.25 PU5.15
N22721118: length 9.7
  TOP w0.102: D4.2 178.83,82.74 179.02,82.93 R5160.1 178.92,83.9 C437.1 178.92,85.65 178.78,85.78 176.9,85.78 176.57,85.45 v1(175.44,85.45) 174.31,85.45 173.73,86.03 MR1.2
N22721124: length 3.7
  TOP w0.102: R5118.2 177.69,87.55 177.68,87.54 177.68,86.77 v1(177.58,86.68) 177.49,86.58 MR1.1
N22725849: length 1.7
  TOP w0.102: v1(85.03,44.89) 85.03,44.68 TP286.1
  BOTTOM w0.102: v1(85.03,44.89) 85.21,45.07 EUPM3247.B48
N22725878: length 1.7
  TOP w0.102: v1(85.05,47.43) 85.12,47.36 TP287.1
  BOTTOM w0.102: v1(85.05,47.43) 84.96,47.34 EUPM3247.A45
N22748003: length 2.3
  TOP w0.102: Q125.3 10.39,77.9 R5004.1
N22748005: length 7.8
  TOP w0.102: v1(9.09,76.18) 9.18,76.18 R5004.2
  BOTTOM w0.102: LED2.2 6.08,80.2 6.52,79.76 6.52,77.5 7.84,76.18 v1(9.09,76.18)
N22748034: length 15.8
  TOP w0.102: v1(8.74,76.72) 8.02,77.44 8.02,81.82 9.36,83.16 R3550.1
  BOTTOM w0.102: v1(8.74,76.72) 7.69,76.72 6.82,77.58 6.82,80.17 5.29,81.7 LED2.3
N22748061: length 3.1
  TOP w0.102: v1(10.99,83.73) R3550.2 10.14,82.97 9.64,82.48 Q121.3
N22804113: length 1.1
  BOTTOM w0.102: R6002.2 96.65,80.81 C6002.1
N22891221: length 5.2
  BOTTOM w0.102: J8L1.25 48.4,60.1 48.18,59.88 47.03,59.88 46.91,59.76 45.62,59.76 44.67,58.81 R788.1
N22969897: length 21.3
  BOTTOM w0.076: U80.AW2 104.14,66.62 103.8,66.96 103.28,66.96 102.78,67.47
  BOTTOM w0.102: RAP1044.2 93.21,81.34 94,80.55 94,78.65 v2(94.53,78.11) 95.01,77.63 95.01,76.44 96.69,74.76 96.69,74.61 97.7,73.61 R217.2 97.87,73.38 97.66,73.16 97.66,71.86 98.03,71.49 98.03,70.45 101.01,67.47 102.78,67.47
N22970777: length 3.7
  BOTTOM w0.102: v1(93.91,86.88) RAP1386.2 93.91,85.89 93.1,85.09 RAP1387.1 93.41,84.66 93.41,83.84 RAP1385.2
N23269888: length 2
  TOP w0.102: v1(86.56,83.42) 86.7,83.28 R6003.2 C6003.1
N23269899: length 2.1
  TOP w0.102: v1(101.14,38.8) 101.64,38.29 C6001.1 R6001.2
N26714628: length 26.8
  TOP w0.102: TP273.1 144.75,40.17 v1(144.75,41.05)
  IN1 w0.102: v3(128.58,48.92) 128.2,49.3 128.2,49.91 128.62,50.33 138.65,50.33 139.16,49.82 139.16,48.04 139.54,47.66 139.54,45.12 139.72,44.93 139.73,44.93 143.6,41.05 v1(144.75,41.05)
  BOTTOM w0.102: v3(128.58,48.92) 128.36,48.92 U80.F43
N26714631: length 24.8
  TOP w0.102: v1(143.81,39.94) 144.24,39.5 TP272.1
  IN1 w0.102: v1(143.81,39.94) 143.81,40.47 143.55,40.73 139.29,44.99 139.29,47.53 139.03,47.79 138.4,47.79 138.14,48.04 138.14,49.69 137.76,50.07 129.38,50.07 129,49.69 129,48.7 v3(128.58,48.28)
  BOTTOM w0.102: U80.E43 128.35,48.28 v3(128.58,48.28)
N26714753: length 13.1
  TOP w0.102: v1(108.8,74.48) 108.8,74.6 109.2,75.01 109.2,75.74 v1(109.06,75.88) 108.83,76.11 RAP3020.2 RAP1458.1 108.27,77.63 107.92,77.98 RAP1457.1
  BOTTOM w0.076: U80.BA15 112.33,68.03 112.33,69.56 110.95,70.94 109.82,72.07 109.82,72.4 109.81,72.41
  BOTTOM w0.102: v1(108.8,74.48) 108.8,74.29 109.17,73.91 109.17,73.1 109.81,72.46 109.81,72.41
N26719512: length 2
  TOP w0.203: v1(168.58,81.29) RAP1025.1
  TOP w0.381: RAP1025.1 CAP1024.1
N26719514: length 2
  TOP w0.203: v1(165.98,81.24) RAP1023.1
  TOP w0.381: RAP1023.1 165.95,82.11 CAP1022.1
N26719516: length 2.3
  TOP w0.203: CAP1020.1 170.67,83.83 v1(170.43,83.83)
  TOP w0.381: RAP1021.1 CAP1020.1
N26723495: length 12.1
  BOTTOM w0.076: U80.D56 135.64,47.41 135.72,47.14 135.72,47.02 135.8,46.75 135.84,46.59 135.86,46.54 135.86,46.3 135.85,46.28 135.84,46.26 135.84,46.24 135.82,46.21 135.82,46 135.86,45.93 135.86,45.56 135.71,45.41 135.71,44.46 136.88,43.29 136.88,42.85 137.05,42.69 137.05,42.35
  BOTTOM w0.102: 137.05,42.35 137.05,42 137.22,41.83 137.57,41.83 137.77,41.62 137.77,39.5 138.3,38.97 139.21,38.97 TP256.1
N26723498: length 7.6
  BOTTOM w0.076: 138.56,43.39 138.56,43.88 137.61,44.83 137.61,46.61 137.63,46.64 137.63,46.88 137.61,46.9 137.61,47.26 137.9,47.56 U80.D61
  BOTTOM w0.102: TP255.1 138.8,41.23 138.46,41.58 138.46,43.1 138.56,43.2 138.56,43.39
N26726690: length 1.1
  BOTTOM w0.102: R900.1 102.83,40.92 R5140.2
N26726693: length 11.3
  BOTTOM w0.076: U80.D7 107.33,47.44 107.33,45.65 106.85,45.17 106.04,45.17 105.84,44.97 105.84,44.69 105.01,43.87
  BOTTOM w0.102: R5143.2 101.08,40.9 102.25,42.06 103.68,42.06 103.83,42.21 103.98,42.21 104.05,42.28 104.05,42.91 105.01,43.87
N26726696: length 10
  TOP w0.102: v3(106.18,44.8) 105.75,44.37 103.01,44.37 102.71,44.08 102.71,43.11 101.59,41.99 R5141.2
  BOTTOM w0.076: U80.C8 107.48,46.63 107.48,45.4 106.89,44.8 v3(106.18,44.8)
N26727015: length 21
  IN2 w0.079: v1(92.25,54.77) 92.54,54.48 93.6,54.48 93.98,54.85 97.69,54.85 97.93,55.09 98.25,55.09 98.6,55.43 104.51,55.43 106,56.92 108.75,56.92 v3(109.23,56.43)
  BOTTOM w0.102: U80.W10 109.23,56.28 v3(109.23,56.43) ; v1(92.25,54.77) 92.25,55.33 92.84,55.92 R5009.1
N26779690: length 15
  BOTTOM w0.076: 57.88,47.33 57.55,47.33 57.42,47.45 57.42,47.68 57.28,47.82 57.08,47.82 56.92,47.98 56.92,48.18 56.78,48.32 56.55,48.32 56.55,48.32
  BOTTOM w0.102: R1129.1 47.58,46.96 v1(47.95,47.33) 48.48,47.86 Q111.1 48.48,49.06 48.86,49.44 49.88,49.44 50.51,50.07 53.43,50.07 55.19,48.32 56.55,48.32 ; 57.88,47.33 58.44,47.33 USM2006.K5
N26904437: length 5.7
  TOP w0.102: v1(189.25,15.45) 188.56,16.14 v1(187.76,16.14) 187.75,16.14 187.37,16.52 187.14,16.52 187.01,16.39 R1138.2 R1139.1
  BOTTOM w0.102: v1(189.25,15.45) 188.75,15.95 CN8.55
N26904440: length 7.8
  TOP w0.102: v1(189.93,15.45) 189.93,16.19 v1(189.65,16.47) 189.55,16.57 R3491.2 187.9,16.57 187.29,17.18 Q113.1
  BOTTOM w0.102: CN8.53 188.93,16.45 v1(189.93,15.45)
N28249672: length 11.6
  TOP w0.102: R899.2 105.12,42.07 104.34,42.85 v1(104.34,43.95)
  IN2 w0.079: v3(106.53,50.16) 106.51,50.16 106.51,50.17 106,49.66 105.07,49.66 104.28,48.88 104.28,47.99 103.73,47.43 103.73,44.56 v1(104.34,43.95)
  BOTTOM w0.102: U80.H5 106.22,50.45 106.51,50.17 106.51,50.16 v3(106.53,50.16)
N28980903: length 4.5
  TOP w0.102: R1162.2 34.54,56.3 34.54,55.89 TP245.1 35.02,54.84 35.63,54.23 35.63,53.63 35.39,53.38 U95.4
N28980950: length 4.2
  TOP w0.102: U95.22 29.63,47.84 29.05,47.26 27,47.26 TP61.1
N28980961: length 1.5
  TOP w0.102: U95.6 34.39,53.37 TP57.1
N29007898: length 34.9
  TOP w0.102: R981.2 34,43.17 v1(34.38,42.79) ; C887.1 28.08,54.3 28.03,54.25 R982.1 27.79,53.75 26.95,52.92 26.52,52.92 25.24,51.64 25.24,50.55 25.8,49.99 v1(26.17,49.99)
  BOTTOM w0.102: U124.1 15.68,53.98 15.87,53.79 16.44,53.79 16.55,53.91 R983.1 17.35,53.5 21.05,53.5 21.21,53.35 21.99,53.35 22.19,53.55 23.52,53.55 26,51.07 26,50.16 v1(26.17,49.99) 27.22,48.94 27.22,47.35 27.04,47.18 27.04,46.52 27.71,45.85 27.71,44.36 29.28,42.79 v1(31.83,42.79) v1(34.38,42.79)
N29008264: length 22.5
  TOP w0.102: v1(13.22,54.1) 13.85,53.47 14.06,53.47 14.23,53.64 U126.1 ; v1(27.36,50.74) 27.52,50.58 R988.1 C888.1 R987.1 27.78,52.74 27.15,52.11 R986.2
  IN1 w0.079: v1(27.36,50.74) 27.36,50.74 25.54,52.56 23.54,52.56 22.56,53.54 21.14,53.54 20.16,52.56 18.1,52.56 16.4,54.26 13.38,54.26 v1(13.22,54.1)
N29176585: length 2
  TOP w0.102: RCP4219.2 23.78,59.8 v1(23.78,59.37)
  BOTTOM w0.102: v1(23.78,59.37) 23.97,59.56 23.97,60.05 23.84,60.18 U96.14
N29176590: length 2.8
  BOTTOM w0.102: U96.35 20.98,67.02 v1(21.2,67.24) 21.13,67.31 20.56,67.31 RCP4220.2
N29248528: length 2.9
  TOP w0.102: R984.1 16.22,53.75 v1(16.17,53.8) 16.17,54.56 16.01,54.72 15.61,54.72 15.53,54.63 U126.3
N29442582: length 1.9
  TOP w0.102: R936.2 24.74,68.61 U90.9
N30351738: length 8.4
  BOTTOM w0.102: TP242.1 100.5,69.15 103.55,69.15 103.74,68.95 104.63,68.95 104.95,68.63 104.95,68.13 105.1,67.99 105.1,67.66 105.32,67.44 105.92,67.44 106.17,67.2 U80.AY5
N30351897: length 10.6
  BOTTOM w0.076: U80.C55 134.95,46.66 134.95,44.27 136.22,43 136.22,42.58 136.35,42.45 136.35,41.46
  BOTTOM w0.102: TP268.1 137.81,38.26 137.56,38.51 137.41,38.51 136.56,39.37 136.56,40.56 136.35,40.77 136.35,41.46
N30351899: length 10.6
  BOTTOM w0.076: 136.16,41.26 136.17,41.27 136.17,42.26 136.06,42.37 136.06,42.9 134.79,44.17 134.79,46.42 134.57,46.64 134.57,46.88 134.86,47.17 U80.D55
  BOTTOM w0.102: TP269.1 137.38,38.26 136.37,39.27 136.37,40.49 136.16,40.7 136.16,41.26
N30362779: length 3.9
  BOTTOM w0.076: TP213.1 101.21,54.14 102.74,52.61 U80.N1
N30362781: length 6.2
  BOTTOM w0.076: TP212.1 99.65,54.63 101.07,54.63 102.8,52.9 103.25,52.9 103.42,52.82 103.61,52.82 103.78,52.89 103.87,52.89 104.22,52.78 104.32,52.78 U80.N2
N30362883: length 17.3
  TOP w0.102: TP179.1 92.66,63.82 93.45,63.03 93.45,63.03 94.47,62.01 95.33,62.01 95.59,61.76 101.42,61.76 103.29,63.62 106.55,63.62 v1(106.64,63.71)
  BOTTOM w0.102: v1(106.64,63.71) 106.55,63.71 U80.AP5
N30362885: length 17
  TOP w0.102: TP178.1 92.11,62.59 93.61,62.59 94.29,61.9 94.29,61.49 94.57,61.2 95.01,61.2 95.36,61.55 101.5,61.55 103.37,63.42 106.31,63.42 v1(106.64,63.09)
  BOTTOM w0.102: U80.AN7 106.7,63.09 v1(106.64,63.09)
N30362887: length 14.6
  TOP w0.102: v1(106.64,62.43) 106.52,62.55 103.07,62.55 101.67,61.15 95.53,61.15 95.18,60.8 94.18,60.8 93.93,61.04 TP177.1
  BOTTOM w0.102: v1(106.64,62.43) 106.57,62.43 U80.AM5
N30362896: length 18.5
  TOP w0.102: RAP1035.1 90.85,63 90.8,62.95 TP180.1 91.25,62.14 92.35,62.14 92.55,62.34 93.57,62.34 94.08,61.82 94.08,61.4 94.49,61 95.1,61 95.45,61.35 101.59,61.35 103.25,63.01 v3(105.7,63.01)
  BOTTOM w0.102: v3(105.7,63.01) 106.02,62.69 U80.AN5
N30363404: length 10
  BOTTOM w0.079: U80.AY8 107.58,67.05 107.58,67.52 107.59,67.54 107.59,67.56 107.61,67.62 107.85,67.86 107.85,68.64 107.62,68.88
  BOTTOM w0.102: 107.62,68.88 107.44,69.05 106.56,69.05 103.09,72.52 TP221.1
N30363406: length 8.7
  BOTTOM w0.102: TP222.1 101.72,72.94 101.72,71.41 102.28,70.85 103.64,70.85 104.86,69.63 105.11,69.63 106.03,68.71 106.15,68.71 106.45,68.41 U80.BB7
N30363918: length 15.6
  BOTTOM w0.076: U80.AU4 105.15,64.89 103.71,64.89 103.67,64.85 101.85,64.85 101.39,65.32 101.39,66.56
  BOTTOM w0.102: R891.1 93.37,70.57 v1(97.21,70.57) 97.62,70.57 101.39,66.8 101.39,66.56
N30475256: length 1.7
  TOP w0.102: TP48.1 117.79,62.44 v3(117.61,62.44)
  BOTTOM w0.076: U80.AM23 117.39,62.25 v3(117.61,62.44)
N30475258: length 1.3
  TOP w0.102: TP49.1 116.69,61.82 v3(116.69,62.44)
  BOTTOM w0.076: v3(116.69,62.44) U80.AM22
N30480410: length 1.5
  TOP w0.102: v3(109.37,62.44) 109.37,61.82 TP51.1
  BOTTOM w0.102: v3(109.37,62.44) 109.58,62.44 U80.AN11
N30480412: length 1.4
  TOP w0.102: TP52.1 111.21,62.56 v3(111.21,63.09)
  BOTTOM w0.102: v3(111.21,63.09) 110.81,62.69 U80.AN13
N30494257: length 2.9
  BOTTOM w0.102: CN17.41 99.13,10.68 98.9,10.45 98.39,10.45 97.6,9.66 RAP1364.2
N30904684: length 15.1
  BOTTOM w0.076: 141.73,44.91 141.62,45.02 141.62,45.33 141.47,45.48 141.47,45.89 141.53,46 141.53,46.22 U80.B67
  BOTTOM w0.102: 141.73,44.91 141.89,44.75 142.4,44.75 142.52,44.86 145.89,44.86 146.27,44.48 148.53,44.48 148.71,44.66 148.71,45.02 148.71,45.02 148.71,45.35 148.94,45.58 150.97,45.58 151.33,45.93 151.33,47.15 151.68,47.51 151.78,47.66 TP257.1
N30904810: length 14.5
  IN2 w0.079: v3(142.39,46.3) 142.9,46.3 148.55,40.66 152.52,40.66 v1(153.09,41.22)
  BOTTOM w0.076: v3(142.39,46.3) 142.39,46.5 142.32,46.57 U80.C67
  BOTTOM w0.102: v1(153.09,41.22) TP258.1
N30904937: length 8.2
  BOTTOM w0.076: 144.11,48.85 143.6,49.07 143.34,49.07 143.27,49.14 142.49,49.14 U80.G68
  BOTTOM w0.102: TP259.1 148.23,47.66 146.55,47.66 145.36,48.85 144.11,48.85
N30904939: length 6.9
  BOTTOM w0.102: TP260.1 149.29,50.2 146.35,50.2 146.28,50.12 145.96,50.12 145.88,50.2 145.77,50.2 145.67,50.1 145.35,50.1 145.25,50.2 145.2,50.2 144.92,50.48 144.41,50.48 144.3,50.37 143.54,50.37 U80.H70
N30904941: length 8.6
  BOTTOM w0.102: TP261.1 151.85,49.25 148.66,49.25 148.19,48.78 147.82,48.78 147.66,48.61 146.46,48.61 145.74,49.34 U80.G71
N30905052: length 8.8
  BOTTOM w0.076: 147.54,49.77 144.01,49.77 143.89,49.72 143.78,49.72 143.56,49.79 143.41,49.79 143.26,49.73 142.79,49.73 U80.H69
  BOTTOM w0.102: 147.54,49.77 147.72,49.94 149.01,49.94 149.34,49.61 150.39,49.61 TP262.1
N30905054: length 4.9
  BOTTOM w0.076: 144.44,49.04 144.26,49.04 144.03,49.08 143.79,49.19 143.79,49.19 143.79,49.2 143.65,49.34 U80.G70
  BOTTOM w0.102: 144.44,49.04 145.6,49.04 146.41,48.23 146.58,48.06 TP263.1
N30905112: length 10.6
  TOP w0.102: v1(144.06,41.71) 143.98,41.64 TP264.1
  IN1 w0.079: v3(139.66,48.28) 139.88,48.51 140.03,48.51 140.1,48.44 140.1,45.3 143.48,41.92 143.86,41.92 v1(144.06,41.71)
  BOTTOM w0.102: v3(139.66,48.28) U80.E63
N30905114: length 11.7
  TOP w0.102: v1(144.67,41.74) 145.61,40.8 TP265.1
  IN1 w0.079: v3(139.66,48.92) 139.88,48.69 140.11,48.69 140.28,48.52 140.28,45.37 143.54,42.12 144.29,42.12 v1(144.67,41.74)
  BOTTOM w0.102: v3(139.66,48.92) U80.F63
N30905174: length 17.9
  IN2 w0.079: v1(154.36,41.22) 153.78,41.8 148.52,41.8 145.81,44.51 145.81,46.01 143.32,48.5 141.9,48.5 v3(141.69,48.28)
  BOTTOM w0.102: v1(154.36,41.22) TP266.1 ; v3(141.69,48.28) 141.53,48.44 U80.E66
N30905176: length 19.3
  IN2 w0.079: v3(141.69,48.92) 141.85,48.75 143.43,48.75 146.04,46.13 146.04,44.58 148.61,42.02 154.83,42.02 v1(155.63,41.22)
  BOTTOM w0.102: U80.F66 141.36,48.92 v3(141.69,48.92) ; v1(155.63,41.22) TP267.1
N30905354: length 11.8
  TOP w0.102: RAP1322.2 104.45,39.41 v1(104.84,39.81)
  IN1 w0.079: v3(106.64,48.21) 105.68,47.25 105.68,44.05 104.77,43.13 104.77,42.22 105.02,41.97 105.02,39.99 v1(104.84,39.81)
  BOTTOM w0.102: v3(106.64,48.21) 106.75,48.09 107.59,48.09 U80.E8
N31079742: length 6.8
  BOTTOM w0.102: TP76.1 101.26,71.46 102.18,70.54 103.44,70.54 104.63,69.35 105.14,69.35 106.05,68.44 U80.BB5
N32035570: length 2.5
  BOTTOM w0.102: TP83.1 99.53,10.57 CN17.39
N32035571: length 1.9
  BOTTOM w0.102: TP81.1 102.73,10.43 CN17.23
N32035572: length 2.5
  BOTTOM w0.102: CN17.47 97.93,10.75 97.5,10.32 96.84,10.32 TP84.1
N32035573: length 3.3
  BOTTOM w0.102: CN17.49 97.44,10.77 97.25,10.57 96.52,10.57 95.79,9.84 TP85.1
N32035574: length 1.8
  BOTTOM w0.102: TP82.1 101.93,9.96 CN17.27
N32035627: length 1.8
  BOTTOM w0.102: CN17.26 102.33,17.56 TP90.1
N32035628: length 1.4
  BOTTOM w0.102: CN17.46 98.33,17.29 TP88.1
N32035629: length 1.6
  BOTTOM w0.102: TP86.1 97.44,16.93 CN17.50
N32035630: length 5.3
  BOTTOM w0.102: TP91.1 103.24,19.69 103.24,17.9 102.73,17.38 CN17.24
N32035631: length 3.6
  BOTTOM w0.102: TP89.1 101.73,18.61 101.73,16.77 101.53,16.58 CN17.30
N32035632: length 2.7
  BOTTOM w0.102: CN17.48 97.93,18.37 TP87.1
N32755302: length 7.9
  TOP w0.102: TP238.1 132.99,71.41 132.99,66.19 132.77,65.97 132.77,65.35 v3(133.15,64.97)
  BOTTOM w0.076: v3(133.15,64.97) 132.82,64.64 U80.AT52
N32759666: length 11
  BOTTOM w0.076: 140.29,44.91 140.29,45.68 U80.A65
  BOTTOM w0.102: 140.29,44.91 140.29,44.76 141.11,43.93 145.04,43.93 146.4,42.57 147.9,42.57 148.4,42.07 TP98.1
N33306658: length 1.2
  TOP w0.102: TP146.1 16.1,56.7 16.51,56.29 U98.4
N33307497: length 2
  TOP w0.102: U95.41 38.01,48.84 38.81,48.04 TP147.1
N33438171: length 7
  BOTTOM w0.076: 101.59,56.82 101.83,56.59 102.94,56.59 103.21,56.85 104.08,56.85 104.21,56.98 104.32,56.98 104.59,57.25 U80.AB3
  BOTTOM w0.102: TP191.1 101.06,57.35 101.59,56.82
N33482633: length 1.6
  TOP w0.102: TP159.1 20.69,71.01 U90.16
N34031444: length 3.2
  BOTTOM w0.102: R1158.1 83.71,33.53 84.07,33.89 84.07,34.23 83.83,34.47 83.69,34.47 82.96,35.2 EUPM3247.A8
N34032189: length 5
  BOTTOM w0.102: EUPM3247.B35 78.71,45.83 78.22,46.31 77.39,46.31 76.93,46.77 76.93,47.88 77.21,48.16 77.72,48.16 78.04,48.49 R895.1
N34033106: length 2.1
  TOP w0.102: v1(82.39,37.35) 82.39,37.37 TP249.1
  BOTTOM w0.102: v1(82.39,37.35) 82.39,37.02 82.71,36.7 EUPM3247.B9
N34033220: length 2.1
  TOP w0.102: TP246.1 79.88,42.81 v1(79.11,42.81)
  BOTTOM w0.102: v1(79.11,42.81) 78.95,42.81 78.72,43.04 EUPM3247.B30
N34033282: length 2.4
  BOTTOM w0.102: EUPM3247.A50 88.57,44.29 88.77,44.48 89.07,44.48 TP211.1
N34033404: length 3.2
  BOTTOM w0.102: EUPM3247.A32 76.5,44.79 76.17,44.46 75.35,44.46 75,44.1 R1179.1
N34033440: length 1.6
  BOTTOM w0.102: EUPM3247.A16 78.96,34.32 TP232.1
N34033647: length 2.1
  TOP w0.102: TP204.1 86.07,40.6 v1(86.58,40.09)
  BOTTOM w0.102: v1(86.58,40.09) 86.63,40.04 EUPM3247.B62
N34176799: length 12.3
  BOTTOM w0.076: 140.73,44.91 140.69,44.95 140.69,45.29 140.81,45.41 140.81,45.95 140.79,46.01 140.76,46.05 140.76,46.18 140.81,46.26 140.81,46.59 140.72,46.78 140.67,46.89 140.48,47.08 U80.C65
  BOTTOM w0.102: 140.73,44.91 140.73,44.88 141.28,44.34 145.42,44.34 146.39,43.38 148.64,43.38 R1180.2 149.14,43.3 v1(149.14,43.9)
N34797635: length 6.8
  BOTTOM w0.076: TP148.1 134.83,41.14 135.05,41.36 135.05,41.94 134.45,42.54 134.45,43.25 132.68,45.02 132.68,45.94 132.95,46.2 U80.B52
N34797754: length 12.4
  TOP w0.102: TP230.1 134.5,39.62 135.49,40.61 135.49,42.01 135.06,42.44 135.06,43.1 131.53,46.63 131.53,47.5 131.32,47.7 v3(131.32,48.28)
  BOTTOM w0.102: U80.E48 130.87,48.23 130.94,48.16 131.21,48.16 v3(131.32,48.28)
N34797764: length 11.7
  TOP w0.102: TP231.1 134.75,40.51 135.26,41.02 135.26,41.88 134.86,42.29 134.86,43.01 130.77,47.11 130.77,47.42 130.94,47.6 130.94,48.53 v3(131.32,48.92)
  BOTTOM w0.102: U80.F48 131.11,48.92 v3(131.32,48.92)
N35698555: length 2.4
  BOTTOM w0.102: v1(164.05,23.73) R790.1 164.7,22.9 164.71,22.89 QPM3362.3
N176432920: length 4
  BOTTOM w0.102: SW1.4 111.52,17.89 111.52,20.53 TP243.1
N176432980: length 2
  BOTTOM w0.102: SW1.1 115.63,9.33 TP244.1
N232682640: length 2.4
  BOTTOM w0.102: R6008.2 C6004.1 v1(91.94,88.93)
N232686630: length 1
  BOTTOM w0.076: R6009.2 146.06,38.62 C6005.1

## Copper pours and planes (outline as drawn)
+V1P00A on TOP (solid shape): 75.48,69.73 77.67,69.73 77.82,69.58 77.82,68.87 75.4,66.45 73.2,66.45 72.99,66.66 72.99,69.88 73.41,70.3 74.91,70.3
+V1P00A on TOP (solid shape): 80.56,62.11 81.32,62.11 81.58,61.85 81.58,60.97 81.25,60.64 80.84,60.64 80.59,60.38 79.82,60.38 79.44,60.76 79.44,61.71 81.35,61.71 81.35,61.9 80.56,61.9 80.56,61.71 79.44,61.71 79.44,61.73 79.66,61.94 80.16,61.94 80.33,62.11 80.56,62.11
+V1P00A on TOP (solid shape): 79.21,59.4 79.22,59.37 79.22,59.33 79.22,59.28 79.23,59.23 79.25,59.17 79.27,59.13 79.31,59.08 79.35,59.04 79.39,59.01 79.44,58.99 79.49,58.97 79.55,58.96 79.6,58.96 79.65,58.97 79.71,58.99 79.76,59.01 79.8,59.04 79.84,59.08 79.87,59.13 79.89,59.16 79.92,59.18 80.9,59.18 81.07,59.01 81.07,58.07 81.06,58.04 81.05,58.03 81.02,58.02 79.51,58.02 79.35,58.19 79.12,58.19 78.61,58.7 78.06,58.7 77.97,58.79 80.76,58.79 80.76,58.98 79.97,58.98 79.97,58.79 77.97,58.79 77.82,58.94 77.82,59.29 78.35,59.82 78.78,59.82
+V1P00A on TOP (solid shape): outline of 233 points within 99.87,31.28 109.8,40.77
+V1P00A on TOP (solid shape): outline of 419 points within 87.21,49.51 94.95,61.83
+V1P00A on BOTTOM (solid shape): 107.89,32.44 107.89,31.91 107.05,31.07 106.55,31.07 105.64,30.16 103.73,30.16 103.7,30.17 103.68,30.19 103.34,30.44 103.01,30.19 102.99,30.17 102.96,30.16 102.89,30.16 102.05,31 102.05,31.94 102.38,32.27 103.78,32.27 103.93,32.11 103.93,31.83 104.13,31.63 105.55,31.63 105.88,31.96 105.88,32.29 106.11,32.52 107.82,32.52
+V1P00A on BOTTOM (solid shape): outline of 82 points within 73.2,65.54 83.81,70.5
+V1P00A on SVCC (solid shape): 82.64,69.55 82.64,57.32 82.68,57.12 82.79,56.95 85.08,54.66 85.25,54.55 85.44,54.52 87.94,54.52 88.02,54.51 88.1,54.52 90.04,54.52 90.24,54.45 90.45,54.52 91.47,54.52 91.51,54.46 91.56,54.41 92.68,53.29 92.68,46.01 92.71,45.81 92.83,45.65 95.75,42.73 95.91,42.62 96.11,42.58 102.54,42.58 102.89,42.3 103.24,42.58 105,42.58 105.35,42.27 105.7,42.58 108.3,42.58 108.3,38.56 108.02,38.23 108.26,37.87 107.97,37.5 108.3,37.17 107.97,36.81 108.3,36.46 108.3,31.36 107.83,30.89 107.67,30.89 107.36,31.07 107.05,30.89 83.11,30.89 82.81,31.05 82.51,30.89 75.99,30.89 74.67,32.14 74.56,32.37 74.32,32.46 71.98,34.67 71.98,50.31 72.23,50.66 71.98,51 71.98,69.04 72.09,69.15 72.2,69.22 72.28,69.34 73.2,70.26 81.93,70.26
+V1P00S_VCCST on TOP (solid shape): 116.37,52.19 116.97,52.19 117.05,52.11 117.05,51.63 116.93,51.51 116.34,51.51 116.17,51.34 115.78,51.34 115.65,51.47 115.65,51.77 115.66,51.78 115.53,51.91 115.53,52.45 115.63,52.55 116.01,52.55
+V1P00S_VCCST on TOP (solid shape): outline of 223 points within 97.38,27.87 114.29,44.71
+V1P00S_VCCST on IN2 (solid shape): outline of 628 points within 112.73,44.24 123.52,51.86
+V1P00S_VCCSTG on TOP (solid shape): 128.11,62.59 128.11,61.88 127.98,61.76 127.5,61.76 127.04,62.21 126.61,62.21 126.51,62.31 126.51,62.61 126.59,62.69 128.01,62.69
+V1P00S_VCCSTG on TOP (solid shape): 138.96,39.1 139.49,39.1 139.72,38.87 139.72,38.54 139.44,38.26 138.8,38.26 138.01,39.05 137.97,39.11 137.91,39.15 137.91,39.61 137.99,39.68 138.37,39.68
+V1P00S_VCCSTG on TOP (solid shape): 84.85,61.76 84.89,61.74 84.9,61.7 84.9,61.63 85.22,61.32 85.22,58.57 84.95,58.3 84.65,58.3 84.52,58.43 84.52,58.58 84.13,58.98 84.13,60.49 84.02,60.6 84.02,61.3 84.47,61.76
+V1P00S_VCCSTG on TOP (solid shape): 121.63,62.47 122.08,62.47 122.13,62.42 122.13,61.93 121.91,61.71 121.91,61.65 121.84,61.58 120.67,61.58 120.54,61.45 120.54,61 120.63,60.92 120.63,60.14 120.62,60.13 120.16,60.13 120.06,60.03 119.85,60.03 119.83,60.05 119.83,62.43 120.07,62.67 121.43,62.67
+V1P00S_VCCSTG on BOTTOM (solid shape): 116.75,45.96 116.77,45.93 116.77,45.9 116.75,45.87 116.75,45.83 116.75,45.74 116.86,45.55 117.08,45.57 117.11,45.58 117.14,45.57 118.84,43.87 118.84,42.43 118.74,42.32 116.22,42.32 116.12,42.43 116.12,45.14 115.94,45.32 115.94,46.03 116.2,46.29 116.43,46.29
+V1P00S_VCCSTG on BOTTOM (solid shape): outline of 442 points within 119.77,59.59 129.75,62.69
+V1P00S_VCCSTG on IN1 (solid shape): outline of 271 points within 138.5,55.86 145.18,58.27
+V1P00S_VCCSTG on IN1 (solid shape): outline of 789 points within 116.28,57.1 124.92,62.72
+V1P00S_VCCSTG on SVCC (solid shape): 105.92,61.67 105.96,61.64 106.01,61.63 107.54,61.63 107.59,61.64 107.63,61.67 108.1,62.14 108.25,62.14 108.71,61.67 108.75,61.64 108.81,61.63 110.82,61.63 111.13,61.41 111.44,61.63 111.81,61.63 112.09,61.47 112.37,61.63 113.2,61.63 113.41,61.41 113.45,61.38 113.5,61.37 116.04,61.37 116.04,60.24 116.06,60.14 116.12,60.05 117.06,59.11 117.06,56.68 116.2,56.68 115.87,57 115.54,56.68 114.14,56.68 114.09,56.66 114.05,56.63 113.49,56.08 113.04,56.06 113.02,55.61 112.56,55.15 112.33,55.15 112.24,55.24 112.12,55.28 111.96,55.32 111.79,55.28 111.52,55.28 111.36,55.32 111.19,55.28 109.5,55.28 109.18,55.52 108.86,55.28 108.85,55.28 108.53,55.54 108.21,55.28 108.2,55.28 107.88,55.54 107.56,55.28 107.55,55.28 107.23,55.54 106.91,55.28 105.44,55.28 105.25,55.46 105,55.53 85.65,55.53 84.71,56.47 84.62,56.83 84.27,56.91 83.66,57.52 83.66,61.78 84.02,62.14 99.51,62.14 99.76,62.03 100.01,62.14 101.06,62.14 101.19,62.17 101.28,62.26 105.32,62.26
+V1P8A on TOP (solid shape): 58.25,83.56 58.25,79.71 58.07,79.54 57.34,79.54 57.09,79.79 57.09,83.57 57.2,83.69 58.12,83.69
+V1P8A on TOP (solid shape): 28.67,28.95 28.67,27.31 28.62,27.26 27.81,27.26 27.79,27.28 27.79,28.4 26.78,29.41 26.78,29.79 26.95,29.97 27.65,29.97
+V1P8A on TOP (solid shape): 97.3,76.66 97.3,75.93 96.46,75.09 96.46,74.25 96.7,74.01 96.7,73.65 96.57,73.52 96.15,73.52 96.03,73.64 96.03,76.79 96.23,77 96.97,77
+V1P8A on TOP (solid shape): 47.24,51.32 47.24,50.66 47.37,50.52 47.37,50.49 47.41,50.49 47.41,50.48 48.38,50.48 48.61,50.25 48.61,48.98 48.28,48.65 47.72,48.65 47.64,48.66 47.57,48.65 47.13,48.65 46.47,49.31 46.47,50.15 46.42,50.2 46.42,51.3 46.44,51.33 46.47,51.35 47.04,51.35 47.06,51.37 47.19,51.37
+V1P8A on TOP (solid shape): 42.92,62.62 42.92,62.42 42.93,62.41 42.94,62.38 42.93,62.35 42.92,62.01 43.18,61.81 43.2,61.81 43.22,61.78 43.22,60.43 43.1,60.31 42.36,60.31 42.04,60.62 42.04,62 42.38,62.34 42.38,62.67 42.51,62.8 42.74,62.8
+V1P8A on TOP (solid shape): 54.73,70.24 54.78,70.24 55.39,69.63 55.82,69.63 56.1,69.91 56.1,70.44 56.33,70.67 57.09,70.67 57.23,70.53 57.23,68.84 56.78,68.38 55.79,68.38 55.73,68.32 55.71,68.31 55.69,68.31 54.96,68.31 54.84,68.42 54.84,68.7 54.33,69.22 54.32,69.23 54.24,69.35 54.13,69.43 54.12,69.43 54.04,69.5 53.59,69.5 53.28,69.81 53.28,69.85 53.3,69.87 53.3,70.48 53.28,70.5 53.28,70.65 53.31,70.67 54.3,70.67
+V1P8A on BOTTOM (solid shape): 40.15,41.21 40.15,39.73 39.79,39.38 38.83,39.38 38.65,39.56 38.65,40.5 39.54,41.38 39.97,41.38
+V1P8A on BOTTOM (solid shape): 212.67,18.8 212.67,17.25 212.29,16.87 211.35,16.87 211.07,17.15 211.07,18.88 211.32,19.13 212.34,19.13
+V1P8A on BOTTOM (solid shape): 88.23,57.06 88.23,56.62 88.05,56.45 86.73,56.45 86.64,56.54 86.64,56.89 86.77,57.01 87.47,57.01 87.79,57.34 87.95,57.34
+V1P8A on BOTTOM (solid shape): 100.12,94.88 100.12,93.28 100.08,93.24 99.88,93.24 99.88,93.24 99.26,93.24 99.26,93.24 98.76,93.24 97.99,94.01 97.99,94.72 98.29,95.03 99.97,95.03
+V1P8A on BOTTOM (solid shape): 54.22,85.71 54.22,84.01 54.88,83.35 57.45,83.35 58.19,82.6 58.19,80.16 57.32,79.29 53.07,79.29 52.92,79.45 52.92,85.72 53.1,85.91 54.02,85.91
+V1P8A on BOTTOM (solid shape): 47.95,49.82 47.95,49.31 47.77,49.13 47.77,47.79 46.68,46.69 45.82,46.69 45.74,46.62 45.69,46.62 45.43,46.87 45.43,47.93 46.61,49.11 46.61,49.7 46.93,50.02 47.74,50.02
+V1P8A on BOTTOM (solid shape): 227.22,28.07 227.22,27.85 227.21,27.81 227.17,27.8 225.9,27.8 225.9,27.8 225.72,27.8 225.42,27.49 225.42,26.7 225.19,26.47 223.21,26.47 223,26.68 223,27.74 223.36,28.1 227.2,28.1
+V1P8A on BOTTOM (solid shape): 57.14,68.99 57.14,68.36 56.51,67.72 55.75,67.72 54.37,66.35 45.23,66.35 42.77,63.89 42.77,63.15 42.89,63.03 42.89,62.25 42.88,62.16 42.89,62.08 42.89,61.78 42.74,61.63 41.72,61.63 41.54,61.81 41.53,61.84 41.53,61.87 41.49,62.18 41.21,62.34 41.14,62.37 41.11,62.44 41.11,64.83 44.21,67.93 53.71,67.93 55.08,69.3 56.84,69.3
+V1P8A on BOTTOM (solid shape): 96.82,84.41 96.82,83.22 96.31,82.71 96.31,82.41 96.31,82.4 96.28,82.28 96.31,82.15 96.31,82.15 96.31,81.35 96.29,81.32 96.28,81.31 96.18,81.24 96.15,81.13 96.15,80.83 96.18,80.71 96.3,80.62 96.31,80.59 96.31,80.16 96.3,80.13 96.3,80.1 96.3,79.82 96.3,79.79 96.31,79.76 96.31,79.38 96.3,79.35 96.3,79.32 96.3,79.04 96.36,78.9 96.5,78.84 96.67,78.84 97.11,78.4 97.11,76.98 97.3,76.79 97.3,75.98 97.12,75.8 96.92,75.8 96.46,76.26 96.46,77.99 96.44,78.01 96.44,78.02 96.36,78.14 96.24,78.21 96.23,78.22 95.5,78.95 95.5,83.78 96.23,84.51 96.72,84.51
+V1P8A on IN1 (solid shape): 100.47,94.75 100.47,93.68 100.14,93.35 98.93,93.35 98.57,93.71 98.57,94.72 98.8,94.95 100.27,94.95
+V1P8A on IN1 (solid shape): 57.52,68.69 57.52,67.95 57.27,67.7 55.9,67.7 55.31,68.28 55.31,69.27 55.49,69.45 56.76,69.45
+V1P8A on IN1 (solid shape): 97.53,84.18 97.53,83.55 97.51,83.53 95.55,83.53 95.51,83.55 95.5,83.58 95.5,84.23 95.8,84.54 97.17,84.54
+V1P8A on IN1 (solid shape): 91.97,58.02 91.97,57.69 91.76,57.48 90.72,57.48 90.07,56.83 89.22,56.83 88.97,56.93 88.72,56.83 88.61,56.83 88.32,56.54 87.84,56.54 87.75,56.62 87.75,56.91 88.29,57.45 90.15,57.45 90.78,58.08 91.9,58.08
+V1P8A on IN1 (solid shape): outline of 121 points within 87.98,71.71 97.3,78.01
+V1P8A on IN2 (solid shape): 48.79,50.66 48.79,48.88 48.62,48.71 47.23,48.71 46.7,49.24 46.7,49.9 47.66,50.86 48.58,50.86
+V1P8A on IN2 (solid shape): 41.45,41.13 41.45,40.17 41.19,39.91 40.51,39.91 40.36,39.76 40.31,39.73 40.28,39.69 38.8,38.22 38.51,38.22 38.25,37.96 37.38,37.96 37.25,38.08 37.25,38.77 39.77,41.28 41.29,41.28
+V1P8A on IN2 (solid shape): 56.81,69.2 56.81,67.88 56.58,67.65 56.56,67.65 56.38,67.7 56.2,67.65 55.26,67.65 54.98,67.93 54.98,68.36 56.1,69.48 56.53,69.48
+V1P8A on IN2 (solid shape): 212.46,17.81 212.46,17.03 211.98,16.54 210.46,16.54 210.44,16.55 210.42,16.57 210.15,16.72 209.86,16.6 209.79,16.57 209.71,16.6 209.36,16.95 209.36,17.76 209.82,18.22 212.06,18.22
+V1P8A on IN2 (solid shape): outline of 226 points within 25.06,22.36 32.99,32.16
+V1P8S on TOP (solid shape): 28.7,26.57 28.72,26.55 28.72,26.53 28.82,26.28 29.11,26.16 29.13,26.12 29.13,25.13 29.05,25.05 27.98,25.05 27.88,25.15 27.88,26.5 28.01,26.63 28.64,26.63
+V1P8S on IN2 (solid shape): 67.28,79.83 67.28,79.66 67.23,79.61 66.95,79.61 64.18,76.83 63.13,76.83 63.04,76.93 63.04,77.2 63.15,77.31 64.25,77.31 66.82,79.89 67.22,79.89
+V1P8S on IN2 (solid shape): outline of 175 points within 26.28,23.22 32.8,29.05
+V1P8S_AUDIO_AVDD on TOP (solid shape): 19.94,18.83 20.44,18.83 20.72,18.55 20.72,17.89 20.57,17.74 18.56,17.74 18.33,17.97 18.33,18.83 18.38,18.88 19.89,18.88
+V1P8S_AUDIO_AVDD on TOP (solid shape): 24.83,23.15 24.83,22.31 24.38,21.85 23.87,21.85 23.79,21.93 23.79,21.95 23.76,22.03 23.72,22.1 23.72,22.31 23.41,22.62 23.41,22.62 23.41,23.5 23.43,23.54 23.46,23.55 24.43,23.55
+V1P8S_AUDIO_AVDD on TOP (solid shape): 27.36,11.23 27.41,11.23 27.44,11.23 27.53,11.14 27.63,11.11 27.67,11.11 28.03,10.75 28.03,10.45 27.75,10.17 26.1,10.17 25.98,10.29 25.98,11.18 25.99,11.22 26.03,11.23 26.04,11.23 26.22,11.41 27.18,11.41
+V1P8S_AUDIO_AVDD on BOTTOM (solid shape): outline of 191 points within 19.96,9.23 27.83,12.63
+V1P8S_AUDIO_AVDD on IN1 (solid shape): 27.7,12.12 27.7,10.83 27.32,10.45 26.13,10.45 25.98,10.6 25.98,12.07 26.36,12.45 27.37,12.45
+V1P8S_AUDIO_AVDD on IN1 (solid shape): 24.99,22.99 24.99,21.45 24.76,21.22 24.25,21.22 24.21,21.23 24.2,21.27 24.2,21.59 23.76,22.03 23.74,22.06 23.74,22.86 23.72,22.88 23.72,22.99 24.05,23.32 24.66,23.32
+V1P8S_AUDIO_AVDD on IN1 (solid shape): outline of 155 points within 19.14,10.83 21.53,18.75
+V1P8S_AUDIO_AVDD on IN2 (solid shape): 27.45,11.69 27.45,11.12 26.93,10.6 25.39,10.6 25.36,10.61 25.34,10.65 25.34,11.29 25.68,11.62 25.69,11.62 25.88,11.72 25.97,11.92 25.98,11.92 27.22,11.92
+V1P8S_AUDIO_DVDD on TOP (solid shape): 23.03,20.48 23.03,20.1 23.74,19.39 23.74,19.16 23.51,18.93 19.98,18.93 19.86,19.05 19.86,19.05 19.93,19.3 19.8,19.53 19.8,20.02 19.88,20.1 20.41,20.1 20.9,20.58 22.93,20.58
+V1P8S_EMMC on TOP (solid shape): outline of 247 points within 55.21,43.85 69.05,53.37
+V1P8S_EMMC on BOTTOM (solid shape): outline of 205 points within 48.09,45.09 57.93,49.18
+V1P8S_R on TOP (solid shape): 25.93,29.67 26.21,29.67 27.4,28.48 27.4,23.15 27.27,23.02 26.97,23.02 26.87,23.12 26.87,23.73 26.56,24.04 23.46,24.04 23.41,24.09 23.41,24.87 23.46,24.93 24.35,24.93 24.86,25.43 24.86,26.45 25.11,26.7 26.26,26.7 26.51,26.96 26.51,28.61 26.08,29.04 25.57,29.04 25.11,29.5 25.11,29.93 25.19,30 25.6,30
+V1P8S_R951 on TOP (solid shape): 55.32,72.54 55.32,71.36 55.16,71.2 55.16,70.47 55.11,70.42 54.7,70.42 54.3,70.82 53.38,70.82 53.29,70.91 53.29,71.07 53.3,71.07 53.3,71.7 53.61,72.02 54.46,72.02 54.46,72.57 54.59,72.7 55.15,72.7
+V1P8U on BOTTOM (solid shape): 124.13,95.31 124.13,94.6 123.65,94.12 122.21,94.12 121.95,94.39 121.95,94.62 122.82,95.49 123.95,95.49
+V1P8U on BOTTOM (solid shape): 105.63,91.78 105.66,91.72 105.64,91.65 105.59,91.42 105.75,91.25 105.81,91.2 105.82,91.13 105.84,90.89 106,90.72 106,90.54 105.83,90.24 106,89.94 106,89.73 105.81,89.42 106,89.11 106,88.93 105.81,88.67 105.91,88.37 105.94,88.3 105.91,88.23 105.84,88.17 103.35,88.17 102.91,88.6 102.2,88.6 101.77,89.03 101.04,89.03 100.57,89.5 100.57,90.13 100.7,90.27 104.02,90.27 104.62,90.87 104.62,91.52 105.08,91.98 105.44,91.98
+V1P8U on BOTTOM (solid shape): 140.85,93.5 140.85,89.89 142.98,87.76 144.71,87.76 145.63,88.68 147.16,88.68 147.22,88.61 147.3,88.56 147.3,88.39 147.1,88.08 147.3,87.76 147.3,87.59 147.1,87.28 147.3,86.96 147.3,86.79 147.11,86.54 147.2,86.23 147.23,86.16 147.2,86.09 147.14,86.03 146.74,86.03 146.03,86.74 142.57,86.74 140.79,88.52 136.17,88.52 135.82,88.17 134.9,88.17 134.9,88.38 134.99,88.62 134.9,88.86 134.9,89.18 134.99,89.42 134.9,89.66 134.9,89.98 134.99,90.22 134.9,90.46 134.9,90.78 134.98,90.93 134.98,91.11 134.98,91.14 135.13,91.29 135.16,91.32 135.69,91.85 138.17,91.85 138.27,91.75 138.27,90.74 138.32,90.69 138.32,89.93 138.56,89.69 139.37,89.69 139.68,89.99 139.68,93.75 139.97,94.04 140.31,94.04
+V1P8U on BOTTOM (solid shape): 121.13,91.81 123.94,91.81 123.95,91.81 124.32,91.44 124.32,91.42 124.39,91.31 124.5,91.24 124.52,91.24 124.58,91.18 124.56,91.15 124.55,90.95 124.64,90.77 124.64,90.47 124.54,90.22 124.64,89.97 124.64,89.67 124.54,89.42 124.64,89.17 124.64,88.87 124.54,88.63 124.63,88.39 124.64,88.37 124.64,88.27 124.54,88.17 123.83,88.17 123.22,88.78 123.22,89.99 122.25,90.96 122.01,90.96 121.91,90.97 121.8,90.96 121.39,90.96 121.24,90.81 120.53,90.81 120.37,90.66 120.37,89.23 119.92,88.78 117.11,88.78 116.86,88.52 116.86,88.38 116.7,88.22 116.1,88.22 116.1,88.33 116.12,88.37 116.13,88.37 116.24,88.62 116.13,88.87 116.12,88.87 116.1,88.91 116.1,89.13 116.12,89.17 116.13,89.17 116.24,89.42 116.13,89.67 116.12,89.67 116.1,89.71 116.1,89.93 116.12,89.97 116.13,89.97 116.24,90.22 116.13,90.47 116.12,90.47 116.1,90.51 116.1,90.73 116.12,90.77 116.17,90.82 116.21,90.88 116.22,90.91 116.61,90.91 117.58,89.94 119.52,89.94 119.6,90.03 119.6,91.33 120.1,91.82 121.11,91.82
+V1P8U on BOTTOM (solid shape): outline of 136 points within 172.03,74.75 174.77,82.71
+V1P8U on BOTTOM (solid shape): outline of 199 points within 157.41,74.76 165.86,89.44
+V1P8U on IN1 (solid shape): 124.64,95.58 124.64,95.18 124.54,95.07 124.54,87.45 124.49,87.4 123.67,88.22 123.67,93.97 123.53,94.12 122.64,94.12 122.21,94.55 122.21,94.95 122.51,95.25 123.29,95.25 123.68,95.63 124.59,95.63
+V3_LDO on TOP (solid shape): 155.44,16.9 155.44,15.81 155.14,15.5 153.92,15.5 153.71,15.7 153.71,16.85 153.99,17.13 155.21,17.13
+V3_LDO on TOP (solid shape): 22.17,24.8 22.78,24.8 23.26,24.32 23.26,23.68 23.11,23.53 22.22,23.53 21.96,23.78 21.25,23.78 21.18,23.86 21.18,25.03 21.23,25.08 21.89,25.08
+V3_LDO on TOP (solid shape): 158.82,24.57 158.82,23.53 158.65,23.36 157.76,23.36 157.24,22.84 155.75,22.84 155.54,23.05 155.54,23.32 155.31,23.55 154.65,23.55 154.37,23.83 154.37,24.95 154.93,25.51 157.88,25.51
+V3_LDO on BOTTOM (solid shape): 38.98,62.54 38.98,61.83 38.88,61.73 37.81,61.73 37.69,61.86 37.69,62.54 37.86,62.72 38.8,62.72
+V3_LDO on BOTTOM (solid shape): 15.28,12.07 16.02,12.07 16.06,12.06 16.07,12.02 16.07,11.59 15.94,11.46 14.93,11.46 14.72,11.67 14.72,12.17 14.83,12.28 15.07,12.28
+V3_LDO on BOTTOM (solid shape): 83.53,26.45 83.53,24.8 84.93,23.4 85.44,23.4 85.95,23.91 85.95,24.07 85.97,24.1 85.97,24.73 85.95,24.76 85.95,24.93 86.07,25.05 86.83,25.05 86.96,24.93 86.96,24.04 86.71,23.78 86.71,23.02 86.83,22.89 88.99,22.89 90.04,23.94 90.05,23.94 90.16,24 90.21,24.1 90.21,24.11 90.39,24.29 90.39,26.45 90.52,26.58 90.9,26.58 91.15,26.32 91.15,23.93 89.61,22.39 84.68,22.39 82.64,24.42 82.64,26.45 82.77,26.58 83.41,26.58
+V3_LDO on IN1 (solid shape): 23.26,24.8 23.26,23.5 23.08,23.32 18.33,23.32 18.2,23.45 18.2,24.7 18.43,24.93 23.13,24.93
+V3_LDO on IN2 (solid shape): 24.15,23.86 23.82,23.53 22.17,23.53 22.04,23.66 22.04,24.65 22.24,24.85 24.15,24.85
+V3_LDO on IN2 (solid shape): 38.98,62.24 38.98,61.22 38.6,60.84 37.13,60.84 37,60.97 37,61.7 37.64,62.34 38.88,62.34
+V3_LDO on IN2 (solid shape): 56.61,33.82 56.61,32.67 55.59,31.66 54.07,31.66 53.31,32.42 53.31,33.82 53.69,34.2 56.23,34.2
+V3_LDO on IN2 (solid shape): 155.16,16.14 155.16,15.5 154.86,15.2 153.23,15.2 152.93,15.5 152.93,16.19 153.21,16.47 154.83,16.47
+V3P3_BIOS_SPI on TOP (solid shape): 76.95,62.39 76.95,58.94 76.69,58.67 76.69,57.78 76.55,57.64 76.44,57.64 76.14,57.64 76.11,57.64 75.34,57.64 75.3,57.64 75,57.64 74.97,57.64 74.19,57.64 74.16,57.64 73.86,57.64 73.82,57.64 71.77,57.64 71.54,57.87 71.54,58.66 71.82,58.94 73.65,58.94 74.39,59.67 74.82,59.67 75.38,59.11 75.76,59.11 75.96,59.32 75.96,59.75 75.46,60.26 75.46,62.24 75.74,62.52 76.83,62.52
+V3P3_BIOS_SPI on BOTTOM (solid shape): 75.05,59.55 75.05,58.17 74.57,57.69 71.7,57.69 71.54,57.84 71.54,58.84 71.63,58.99 71.64,59.2 71.65,59.22 71.67,59.24 72.08,59.24 72.26,59.06 73.17,59.06 73.45,59.34 73.45,59.77 73.5,59.82 74.77,59.82
+V3P3_TP on TOP (solid shape): 174.64,26.47 174.64,25.97 174.67,25.94 174.67,25.69 174.66,25.68 174.64,25.56 174.66,25.44 174.67,25.43 174.67,25.25 174.85,25.08 174.85,24.26 174.8,24.21 174.58,24.21 174.58,24.73 174.36,24.73 174.36,24.21 172.66,24.21 172.48,24.39 172.48,26.12 172.48,26.55 172.59,26.65 174.46,26.65
+V3P3_TP_OUT on BOTTOM (solid shape): 173.25,24.54 173.25,23.99 173.17,23.91 172.1,23.91 172.04,23.91 171.99,23.91 169.99,23.91 169.59,23.5 169.59,22.23 169.49,22.13 168.57,22.13 168.45,22.26 168.45,22.56 168.39,22.61 166.9,22.61 166.77,22.74 166.77,24.39 167.05,24.67 173.12,24.67
+V3P3_TP_OUT on IN1 (solid shape): outline of 124 points within 168.24,22.28 180.71,24.01
+V3P3_USBPD on TOP (solid shape): 12.37,67.33 12.37,66.57 12.54,66.4 12.87,66.4 13,66.28 13,65.9 12.67,65.57 11.68,65.57 11.5,65.74 11.5,66.9 11.36,67.04 10.16,67.04 10.16,67.55 12.16,67.55
+V3P3_USBPD on TOP (solid shape): 20.64,64.45 20.64,60.38 19.91,59.65 19.91,59.06 19.75,58.91 19.5,58.91 19.12,59.29 19.12,60.26 19.42,60.56 19.42,61.41 19.43,61.48 19.42,61.54 19.42,62.31 19.12,62.62 19.12,64.57 19.42,64.88 20.21,64.88
+V3P3_USBPD on TOP (solid shape): 24.48,65.57 24.48,65.33 24.47,65.32 24.43,65.15 24.47,64.99 24.48,64.98 24.48,64.59 24.47,64.58 24.43,64.41 24.47,64.25 24.48,64.24 24.48,64.19 24.91,63.76 24.91,61.76 25.52,61.15 25.52,60.51 25.52,60.51 25.52,59.7 25.52,59.7 25.52,58.48 25.52,58.4 25.32,58.2 24.53,58.2 24.48,58.25 24.48,58.86 24.17,59.16 24.17,60.18 23.33,61.02 23.33,65.44 23.59,65.69 24.35,65.69
+V3P3_USBPD on IN1 (solid shape): outline of 129 points within 19.47,62.69 24.5,65.65
+V3P3_USBPD on IN2 (solid shape): 13.71,66.02 13.3,66.02 13.12,65.84 12.06,65.84 11.87,66.03 11.87,66.31 12.06,66.5 13.71,66.5
+V3P3A on TOP (solid shape): 19.27,25.03 19.27,24.32 19.12,24.16 18.41,24.16 17.26,25.31 17.26,25.99 17.47,26.2 18.1,26.2
+V3P3A on TOP (solid shape): 74.49,62.29 74.49,61.76 74.29,61.55 72.23,61.55 72.05,61.73 72.05,62.49 72.13,62.57 74.21,62.57
+V3P3A on TOP (solid shape): 192.02,12 192.02,11.69 190.57,10.24 189.12,10.24 188.89,10.47 188.89,11.54 189.93,12.58 191.43,12.58
+V3P3A on TOP (solid shape): 217.24,28.38 217.24,26.6 217.16,26.53 215.54,26.53 215.36,26.7 215.36,28.4 215.44,28.48 217.14,28.48
+V3P3A on TOP (solid shape): 53.03,38.29 53.03,36 52.44,35.42 51.27,35.42 49.34,37.34 49.34,38.26 49.75,38.67 52.65,38.67
+V3P3A on TOP (solid shape): 92.96,72.7 92.96,70.47 92.88,70.39 92.45,70.39 91.41,71.43 91.4,71.48 91.38,71.53 91.38,73.21 91.76,73.59 92.07,73.59
+V3P3A on TOP (solid shape): 44.67,48.39 44.67,47.63 44.67,47.62 44.93,47.37 46,47.37 47.11,46.26 47.85,46.26 48.1,46.01 48.1,45.33 47.58,44.81 45.99,44.81 45.81,44.98 45.81,45.77 45.3,46.29 44.64,46.29 43.75,47.18 43.73,47.18 43.45,47.46 43.45,48.45 43.58,48.57 44.49,48.57
+V3P3A on TOP (solid shape): 18.86,37.68 18.86,36.58 21.61,33.84 21.61,29.55 21.79,29.37 23.87,29.37 24.17,29.07 24.17,26.26 24.02,26.11 22.56,26.11 22.06,26.6 21.28,26.6 20.29,27.59 20.29,27.69 21.71,27.69 21.71,27.39 22.04,27.06 22.36,27.06 22.46,26.96 23.68,26.96 23.68,27.87 22.24,27.87 22.21,27.9 21.92,27.9 21.71,27.69 20.29,27.69 20.29,31.53 17.39,34.42 17.39,37.78 17.54,37.93 18.61,37.93
+V3P3A on TOP (solid shape): 46.72,63.43 46.95,63.26 47.23,63.31 47.26,63.32 47.29,63.3 47.34,63.25 50.08,63.25 50.13,63.2 50.13,62.75 50.08,62.69 47.52,62.69 47.21,62.39 46.47,62.39 46.19,62.11 46.19,61.38 46.06,61.25 46.06,60.32 46.04,60.31 45.2,60.31 45.15,60.36 45.15,61.17 45.51,61.53 45.51,61.59 45.51,61.61 45.52,61.63 45.59,62.04 45.21,62.23 45.19,62.24 45.17,62.25 44.98,62.44 44.98,63.25 45.18,63.46 46.68,63.46
+V3P3A on TOP (solid shape): outline of 232 points within 96.97,72.8 103.14,76.54
+V3P3A on TOP (solid shape): outline of 526 points within 97.86,10.22 124.63,16.61
+V3P3A on BOTTOM (solid shape): 209.01,15.37 209.01,13.77 208.78,13.55 207.23,13.55 206.62,14.16 206.62,15.96 206.85,16.19 208.2,16.19
+V3P3A on BOTTOM (solid shape): 88.89,56.12 88.89,54.62 88.79,54.52 87.22,54.52 86.83,54.9 84.93,54.9 84.17,54.14 82.64,54.14 82.52,54.26 82.52,54.64 82.9,55.02 83.74,55.02 84.68,55.96 88.18,55.96 88.41,56.19 88.82,56.19
+V3P3A on BOTTOM (solid shape): 47.22,45.4 47.22,44.9 47.23,44.9 47.23,44.83 47.67,44.38 47.74,44.38 47.77,44.36 52.16,44.36 53.31,45.5 55.21,45.5 55.47,45.25 55.47,43.98 52.49,41 47.72,41 47.44,40.72 47.06,40.72 46.04,41.74 46.04,44.46 46.07,44.49 46.07,45.32 46.04,45.34 46.04,45.85 46.17,45.98 46.64,45.98
+V3P3A on BOTTOM (solid shape): 97.33,53.04 97.33,52.59 96.82,52.08 96.82,50.99 96.8,50.96 96.77,50.94 96.47,50.94 96.34,50.81 94.43,50.81 94.28,50.66 94.28,50.27 94.18,50.17 93.01,50.17 92.99,50.18 92.99,50.63 92.98,50.64 92.98,51.14 93.11,51.26 94.68,51.26 94.69,51.26 94.84,51.23 94.98,51.26 94.99,51.26 95.34,51.26 95.35,51.26 95.63,51.28 95.81,51.5 95.82,51.51 95.86,51.56 95.86,52.17 96.84,53.14 97.22,53.14
+V3P3A on BOTTOM (solid shape): 106.19,40.7 106.19,39.86 106,39.67 105.44,39.67 105.37,39.7 105.3,39.71 105.23,39.74 105.2,39.81 104.83,40.17 104.49,39.78 104.46,39.7 104.39,39.67 103.87,39.15 103.32,39.15 103.22,39.25 103.22,39.57 103.27,39.76 103.22,39.94 103.22,40.65 103.4,40.83 106.06,40.83
+V3P3A on BOTTOM (solid shape): outline of 166 points within 93.57,73.92 98.09,89.31
+V3P3A on BOTTOM (solid shape): outline of 231 points within 90.95,58.63 94.96,73.64
+V3P3A on BOTTOM (solid shape): outline of 243 points within 214.11,23.91 227.22,31.07
+V3P3A on IN1 (solid shape): 54.83,46.74 54.83,46.72 55.34,46.21 55.34,44.81 55.16,44.64 54.35,44.64 53.81,45.17 53.81,46.52 54.07,46.77 54.8,46.77
+V3P3A on IN1 (solid shape): 96.61,75.52 97.71,75.52 98.09,75.14 98.09,74.35 97.96,74.23 96.51,74.23 95.61,75.13 94.09,75.13 93.11,74.14 93.11,73.92 91.71,72.52 91.33,72.52 90.98,72.88 90.98,73.89 91.95,73.89 91.95,73.84 91.96,73.78 91.97,73.73 92,73.69 92.03,73.64 92.06,73.6 92.1,73.57 92.15,73.54 92.2,73.52 92.25,73.51 92.3,73.51 92.36,73.51 92.41,73.52 92.46,73.54 92.51,73.57 92.55,73.6 92.58,73.64 92.61,73.69 92.64,73.73 92.65,73.78 92.66,73.84 92.66,73.89 92.65,73.94 92.64,73.99 92.61,74.04 92.58,74.09 92.55,74.13 92.51,74.16 92.46,74.19 92.41,74.2 92.36,74.22 92.3,74.22 92.25,74.22 92.2,74.2 92.15,74.19 92.1,74.16 92.06,74.13 92.03,74.09 92,74.04 91.97,73.99 91.96,73.94 91.95,73.89 90.98,73.89 90.98,74.58 91.51,75.12 91.55,75.12 91.61,75.13 91.65,75.15 91.7,75.17 91.74,75.2 91.78,75.24 91.81,75.28 91.83,75.33 91.85,75.37 91.86,75.42 91.86,75.47 92.45,76.05 96.08,76.05
+V3P3A on IN1 (solid shape): outline of 229 points within 44.47,55.02 49.75,63.43
+V3P3A on IN2 (solid shape): 209.09,14.49 209.09,13.8 208.58,13.29 205.78,13.29 205.55,13.52 205.55,14.79 205.81,15.04 208.53,15.04
+V3P3A on IN2 (solid shape): 192.7,13.37 192.7,11.97 191.9,11.17 191.82,11.11 191.75,11.03 189.88,11.03 189.7,11.21 189.7,12.68 190.84,13.82 192.25,13.82
+V3P3A on IN2 (solid shape): outline of 122 points within 87.09,53.5 92.55,61
+V3P3A on IN2 (solid shape): outline of 281 points within 17.32,22.11 51.48,45.98
+V3P3A_DSW on TOP (solid shape): 62.2,89.26 62.2,87.38 61.66,86.84 56.96,86.84 55.95,85.83 55.95,83.07 55.42,82.53 54.5,82.53 54.16,82.88 54.16,89.24 54.26,89.34 62.12,89.34
+V3P3A_DSW on TOP (solid shape): 25.98,57.67 25.98,57.18 26.31,56.85 26.31,56.55 26.3,56.55 26.3,55.76 26.31,55.76 26.31,55.63 26.23,55.56 25.24,55.56 25.06,55.38 24,55.38 23.99,55.4 23.38,55.4 23.36,55.38 23.26,55.38 23.21,55.43 23.21,55.76 26.1,55.76 26.1,56.55 25.91,56.55 25.91,55.76 23.21,55.76 23.21,56.19 23.45,56.43 23.75,56.43 24.38,57.06 24.38,57.64 24.48,57.74 25.9,57.74
+V3P3A_DSW on TOP (solid shape): 44.67,54.64 44.8,54.52 44.8,53.12 44.72,53.04 44.72,52.87 44.72,52.87 44.72,52.08 44.72,52.08 44.72,51.93 44.57,51.77 43.45,51.77 43.27,51.6 43.07,51.6 43.04,51.61 43.02,51.65 42.99,51.69 42.96,51.73 42.92,51.76 42.87,51.79 42.82,51.81 42.77,51.82 42.72,51.82 42.66,51.82 42.61,51.81 42.56,51.79 42.51,51.76 42.47,51.73 42.44,51.69 42.41,51.65 42.39,51.61 42.36,51.6 40.99,51.6 40.86,51.72 40.86,52.08 44.52,52.08 44.52,52.87 44.32,52.87 44.32,52.08 40.86,52.08 40.86,53.12 40.99,53.25 41.62,53.25 41.75,53.37 41.75,53.8 41.97,54.01 41.97,54.03 41.98,54.06 42,54.1 42.02,54.15 42.03,54.21 42.03,54.26 42.03,54.29 42.03,54.31 42.03,54.36 42.02,54.4 42.01,54.45 42,54.5 42.13,54.64 44.36,54.64
+V3P3A_DSW on BOTTOM (solid shape): 58.86,92.09 58.86,89.5 61.84,86.52 63.42,86.52 63.67,86.27 63.67,85.95 63.59,85.88 61.47,85.88 61.03,86.32 54.6,86.32 54.42,86.5 54.42,87.92 53.33,89.01 53.07,89.01 52.9,89.18 52.9,92.36 53,92.54 53.08,92.72 58.24,92.72
+V3P3A_DSW on BOTTOM (solid shape): outline of 311 points within 23.97,51.85 43.22,57.49
+V3P3A_DSW on IN1 (solid shape): outline of 1333 points within 16.25,55.43 60.09,88.48
+V3P3A_DSW on IN2 (solid shape): outline of 3669 points within 16.43,51.62 60.09,88.48
+V3P3A_EC on TOP (solid shape): 82.71,48.08 82.71,47.57 82.64,47.51 82.64,47.2 83.38,46.46 83.38,46.13 83.32,46.06 83.31,46 83.29,45.99 83.27,45.98 81.48,45.98 81.45,46.01 81.45,46.4 81.37,46.48 81.37,47.3 81.6,47.3 81.6,47.25 81.61,47.2 81.62,47.15 81.65,47.1 81.68,47.05 81.71,47.02 81.75,46.98 81.8,46.96 81.85,46.94 81.9,46.92 81.95,46.92 82.01,46.92 82.06,46.94 82.11,46.96 82.16,46.98 82.2,47.02 82.23,47.05 82.26,47.1 82.29,47.15 82.3,47.2 82.31,47.25 82.31,47.3 82.3,47.36 82.29,47.41 82.26,47.45 82.23,47.5 82.2,47.54 82.16,47.57 82.11,47.6 82.06,47.62 82.01,47.63 81.95,47.63 81.9,47.63 81.85,47.62 81.8,47.6 81.75,47.57 81.71,47.54 81.68,47.5 81.65,47.45 81.62,47.41 81.61,47.36 81.6,47.3 81.37,47.3 81.37,47.38 81.39,47.4 81.42,47.42 81.47,47.45 81.51,47.49 81.54,47.53 81.56,47.58 81.58,47.63 81.59,47.67 82.14,48.22 82.57,48.22
+V3P3A_EC on TOP (solid shape): outline of 421 points within 72.43,32.04 87.32,39.66
+V3P3A_EC on BOTTOM (solid shape): 69.87,41.46 69.87,40.88 69.74,40.75 68.57,40.75 68.27,41.05 68.27,41.51 68.45,41.69 69.64,41.69
+V3P3A_EC on BOTTOM (solid shape): 86.39,33.09 86.39,33.01 86.68,32.72 87.14,32.72 87.24,32.62 87.24,32.21 87.17,32.14 85.95,32.14 85.82,32.27 85.82,33.15 85.87,33.21 86.28,33.21
+V3P3A_EC on BOTTOM (solid shape): 90.76,45.47 91.31,45.47 91.33,45.47 91.35,45.45 91.54,45.29 91.78,45.29 91.79,45.29 91.82,45.29 91.89,45.22 91.89,43.24 91.81,43.15 91.77,43.12 91.74,43.09 91.66,43.01 91.66,42.68 91.41,42.43 89.33,42.43 89.31,42.44 88.72,42.44 88.56,42.6 87.85,42.6 87.72,42.73 87.72,42.83 87.85,42.96 88.79,42.96 88.8,42.96 88.93,42.93 89.07,42.96 89.07,42.96 90.57,42.96 90.84,43.23 90.86,43.24 90.89,43.24 91.33,43.43 91.18,43.88 91.17,43.89 91.15,43.92 91.15,44.56 90.64,45.07 90.34,45.07 90.21,45.19 90.21,45.58 90.24,45.6 90.63,45.6
