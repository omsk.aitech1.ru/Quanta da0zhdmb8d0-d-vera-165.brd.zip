# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Nets (continued)
GND: C1.2 C1C4.1 C1C7.2 C1C28.2 C1C29.2 C1C41.2 C1C42.1 C1C43.2 C1C44.1 C1C50.2 C1D8.2 C1D17.2 C1M4.2 C1M5.2 C1M6.2 C1M7.2 C1M8.2 C1M9.2 C1P4.2 C1P5.2 C1P6.1 C1P7.1 C2.1 C2B3.2 C2M1.2 C2M2.2 C2M3.2 C2M4.2 C2M5.2 C3.1 C4.1 C8L3.1 C8L7.2 C8L9.2 C8L11.2 C8L13.2 C8L14.2 C8L15.2 C8L16.2 C8L17.2 C8L18.2 C8L19.2 C8L20.2 C32.2 C35.2 C43.1 C51.1 C62.1 C63.1 C64.1 C65.1 C67.2 C72.2 C130.2 C131.2 C132.1 C133.2 C135.2 C136.2 C137.2 C153.2 C186.1 C187.1 C289.2 C291.2 C340.1 C341.1 C343.1 C344.1 C386.1 C437.2 C590.1 C783.2 C785.2 C789.2 C790.2 C791.1 C831.2 C832.2 C842.1 C843.1 C849.1 C850.1 C867.1 C868.1 C870.1 C871.1 C872.1 C873.1 C893.1 C946.2 C947.2 C948.2 C952.2 C968.2 C1009.2 C1024.2 C1025.2 C1026.2 C1029.1 C1030.1 C1031.1 C1032.1 C1033.1 C1080.1 C1087.1 C1088.1 C1089.1 C1102.1 C1103.1 C1104.1 C1105.2 C1106.2 C1107.2 C1109.1 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.1 C1136.2 C1137.2 C1138.2 C1139.2 C1140.1 C1141.1 C1142.1 CAP1073.1 CAP1079.1 CAP1101.2 CAP1102.1 CAP1103.1 CAP1108.2 CAP1109.1 CAP1110.1 CAP1115.2 CAP1116.1 CAP1117.1 CAP1122.2 CAP1123.1 CAP1124.1 CAP1129.2 CAP1130.1 CAP1131.1 CAP1136.2 CAP1137.1 CAP1138.1 CAP1141.2 CAP1142.1 CAP1147.2 CAP1148.1 CAP1150.2 CAP1152.2 CAP1155.1 CAP1156.2 CAP1157.2 CAP1159.1 CAP1161.1 CAP1162.2 CAP1164.1 CAP1165.2 CAP1166.1 CAP1167.2 CAP1168.1 CAP1169.2 CAP1171.1 CAP1172.1 CAP1173.1 CAP1174.2 CAP1176.1 CAP1177.1 CAP1178.1 CAP1179.2 CAP1181.1 CAP1183.1 CAP1184.2 CAP1186.1 CAP1187.1 CAP1189.2 CAP1191.1 CAP1192.1 CAP1193.1 CAP1194.2 CAP1196.1 CAP1197.1 CAP1199.2 CAP1201.1 CAP1203.1 CAP1204.2 CAP1206.1 CAP1207.1 CAP1208.1 CAP1210.1 CAP1211.2 CAP1213.1 CAP1214.1 CAP1215.1 CAP1217.1 CAP1218.2 CAP1220.1 CAP1221.1 CAP1223.1 CAP1224.2 CAP1226.1 CAP1227.1 CAP1229.1 CAP1231.1 CAP1232.1 CAP1234.1 CAP1235.1 CAP1236.1 CAP1240.2 CAP1241.2 CAP1242.2 CAP1243.1 CAP1244.2 CAP1245.1 CAP1247.2 CAP1248.1 CAP1249.2 CAP1250.1 CAP1252.1 CAP1253.2 CAP1254.1 CAP1255.1 CAP1256.2 CAP1257.2 CAP1258.1 CAP1259.1 CAP1260.2 CAP1261.2 CAP1262.2 CAP1264.1 CAP1265.2 CAP1267.2 CAP1268.2 CAP1270.1 CAP1271.2 CAP1272.2 CAP1274.1 CAP1275.2 CAP1276.2 CAP1277.1 CAP1278.1 CAP1279.2 CAP1280.1 CAP1281.2 CAP1282.1 CAP1283.1 CAP1284.2 CAP1285.2 CAP1286.1 CAP1287.2 CAP1288.1 CAP1289.2 CAP1290.2 CAP1291.1 CAP1292.1 CAP1293.2 CAP1294.2 CAP1295.1 CAP1296.2 CAP1297.2 CAP1298.1 CAP1299.2 CAP1300.2 CAP1301.1 CAP1302.1 CAP1303.2 CAP1304.2 CAP1305.1 CAP1306.1 CAP1307.2 CAP1308.1 CAP1309.2 CAP1310.1 CAP1311.2 CAP1312.1 CAP1313.2 CAP1316.1 CAP1317.2 CAP1318.2 CAP1319.1 CAP1320.1 CAP1321.1 CAP1422.1 CAP1423.1 CAP1424.1 CAP1425.1 CAP1426.1 CAP1427.1 CAP1428.1 CAP1429.1 CAP1430.1 CAP1431.1 CAP1432.1 CAP1433.1 CAP1434.1 CAP1435.1 CAP1436.1 CAP1437.1 CAP1438.1 CAP1439.1 CAP1441.1 CAP1442.2 CAP1443.2 CAP1444.2 CAP1445.2 CAP1446.2 CAP1447.2 CAP1448.2 CAP1449.2 CAP1450.2 CAP1451.2 CAP1452.2 CAP1456.2 CAP1457.2 CAP1458.2 CAP1459.2 CAP1460.2 CAP1461.2 CAP1462.2 CAP1463.2 CAP1464.2 CAP1465.2 CAP1467.2 CAP1468.2 CAP1469.2 CAP1470.2 CAP1471.2 CAP1472.2 CAP1473.2 CAP1474.2 CAP1475.2 CAP1476.1 CAP1477.1 CAP1478.1 CAP1479.1 CAP1480.1 CAP1481.1 CAP1482.1 CAP1483.1 CAP1484.1 CAP1485.1 CAP1486.1 CAP1487.1 CAP1488.1 CAP1489.1 CAP1490.1 CAP1491.1 CAP1492.1 CAP1493.1 CAP1494.1 CAP1495.1 CAP1498.1 CAP1499.1 CAP1500.1 CAP14466.2 CAP14472.1 CAP14473.1 CAP14474.1 CAP14475.1 CAP14476.1 CAP14477.1 CAP14478.1 CAP14479.1 CAP14480.1 CAP14481.2 CAP14482.1 CAP14483.1 CAP14490.2 CAP14491.2 CAP14493.1 CCP4019.2 CCP4089.2 CCP4090.2 CCP4197.2 CCP4198.1 CCP4215.1 CCP4216.2 CN2.11 CN2.14 CN2.17 CN2.20 CN2.23 CN2.26 CN2.29 CN2.31 CN2.32 CN3.4 CN3.9 CN3.10 CN4.2 CN4.5 CN4.6 CN8.1 CN8.7 CN8.18 CN8.33 CN8.39 CN8.45 CN8.51 CN8.57 CN8.63 CN8.69 CN8.75 CN8.76 CN8.77 CN12.2(D2_SHIELD) CN12.5(D1_SHIELD) CN12.8(D0_SHIELD) CN12.11(CLK_SHIELD) CN12.17(GND#1) CN12.20 CN12.21 CN12.22 CN12.23 CN17.1 CN17.8 CN17.15 CN17.20 CN17.31 CN17.36 CN17.42 CPM3428.1 CPM3432.1 CPM3433.1 CPM3435.1 CPM3436.1 CPM3438.1 CPM3439.1 CPM3440.1 CPM3479.1 CPM4346.2 CPM4429.2 CPM4431.1 CRCP4008.3(GND) CRCP4008.8(GND#1) CRCP4009.3(GND) CRCP4009.8(GND#1) CRCP4010.3(GND) CRCP4010.8(GND#1) CRCP4011.3(GND) CRCP4011.8(GND#1) CRCP4014.3(GND) CRCP4014.8(GND#1) CRCP4028.2 CRCP4042.3(GND) CRCP4042.8(GND#1) CRCP4043.3(GND) CRCP4043.8(GND#1) CSM1017.2 CSM1018.2 CSM1019.2 CSM1020.2 CSM1021.1 CSM1022.1 CSM1023.2 CSM1024.1 CSM1025.2 CSM1026.1 CSM1027.1 CSM1028.1 CSM1029.1 CSM1030.1 CSM2029.2 CSM2030.2 CSM2031.2 CSM2032.2 CSM2033.2 CSM2034.1 CSM2035.1 CSM2036.2 CSM2037.1 CSM2038.2 CSM2039.1 CSM2040.1 CSM2041.1 CSM2042.1 CSM2043.1 CSM2097.2 CSM2098.2 CSM2099.2 CSM2100.2 CSM2101.2 CSM2102.1 CSM2103.1 CSM2104.2 CSM2105.1 CSM2106.2 CSM2107.1 CSM2108.1 CSM2109.1 CSM2110.1 CSM2111.1 CSM2129.2 CSM2130.2 CSM2131.2 CSM2133.1 CSM2134.1 CSM2135.2 CSM2136.1 CSM2137.2 CSM2138.1 CSM2139.1 CSM2140.1 CSM2141.1 CSM2142.1 CSM2156.1 CSM2157.1 CSM2158.1 CSM2159.1 CSM2160.1 CSM3132.2 D4.1 D21.2 D46.2 D47.2 D48.2 D49.2 D50.2 D51.2 D60.3(GND#1) D61.3(GND#1) EC1.2 EC2.2 EC3.2 EU1B2.14(GND) EU1B2.17(EPAD) EUCP4040.14(GND) EUCP4040.17(EPAD) EUPM3247.133(TPAD) EUPM3247.A5(VSS) EUPM3247.A35(VSS_VBAT) HOLE2.1 HOLE2.2 HOLE2.5 HOLE4.1 HOLE4.2 HOLE4.3 HOLE4.4 HOLE4.5 HOLE4.6 HOLE4.7 HOLE4.8 HOLE4.9 HOLE7.1 HOLE9.1 HOLE18.1 HOLE19.1 HOLE34.1 HOLE34.2 HOLE34.3 HOLE34.4 HOLE34.5 HOLE34.6 HOLE34.7 HOLE34.8 HOLE34.9 HOLE35.1 HOLE35.2 HOLE35.3 HOLE35.4 HOLE35.5 HOLE35.6 HOLE35.7 HOLE35.8 HOLE35.9 HOLE36.1 HOLE36.2 HOLE36.3 HOLE36.4 HOLE36.5 HOLE36.6 HOLE36.7 HOLE36.8 HOLE36.9 HOLE42.1 HOLE43.1 HOLE44.1 HOLE44.2 HOLE44.3 HOLE44.4 HOLE44.5 HOLE44.6 HOLE44.7 HOLE44.8 HOLE44.9 HOLE45.1 J1C1.7(MS) J1P2.5 J1P2.6 J2.4(GND) J2.7(GND_DRAIN) J2.10(SHIELD#2) J2.11(SHIELD#1) J2.12(SHIELD#4) J2.13(SHIELD#3) J8L1.8 J8L1.11 J8L1.14 J8L1.17 J8L1.31 J8L1.34 J8L1.37 J8L1.40 J8L1.41 J8L1.42 JCP4038.1(GND#5) JCP4038.2(GND#6) JCP4038.3(GND#7) JCP4038.4(GND#8) JCP4038.A1(GND#1) JCP4038.A12(GND#2) JCP4038.B1(GND#3) JCP4038.B12(GND#4) JCP4056.27 JCP4056.31 JCP4056.32 MR1.3(GND) PC1.2 PC2.1 PC4.2 PC5.2 PC6.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC14.1 PC15.1 PC16.2 PC17.1 PC18.2 PC19.1 PC20.2 PC21.1 PC22.1 PC27.2 PC46.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.1 PC310.1 PC1051.1 PC1142.2 PC1143.2 PC1144.1 PC1146.1 PC1147.1 PC1148.1 PC1149.1 PC1150.1 PC1151.2 PC1152.2 PC1153.2 PC1154.2 PC1155.2 PC1156.2 PC1157.2 PC1158.2 PC1159.2 PC1160.2 PC1161.2 PC1162.2 PC1163.2 PC1164.2 PC1165.2 PC1166.2 PC1167.2 PC1168.2 PC1169.2 PC1170.2 PC1171.2 PC1172.2 PC1173.2 PC1174.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1182.2 PC1185.1 PC1188.2 PC1189.2 PC1190.2 PC1191.2 PC1192.2 PC1193.2 PC1194.1 PC1195.1 PC1198.2 PC1199.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1249.2 PC1250.2 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PC1255.2 PC1256.2 PC1257.2 PC1259.2 PC1260.2 PC1267.1 PC1268.1 PC1269.2 PC1270.2 PC1271.2 PC1272.2 PC1273.2 PC1274.2 PC1275.2 PC1276.2 PC1277.2 PC1278.2 PC1279.2 PC1280.2 PC1281.1 PC1282.1 PC1283.1 PC1284.1 PC1285.1 PC1286.1 PC1287.1 PC1288.1 PC1289.1 PC1290.1 PC1291.1 PC1292.1 PC1293.1 PC1294.1 PC1295.2 PC1296.2 PC1297.2 PC1298.2 PC1299.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.1 PC1321.1 PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC9091.1 PC9094.1 PC9099.1 PC9100.2 PC9101.2 PC9102.2 PC9103.2 PC9104.2 PC9105.2 PC9106.2 PC9110.1 PC9111.2 PC9112.2 PC9113.2 PC9114.2 PC9115.2 PC9116.2 PC9117.2 PC9118.2 PC9119.2 PC9120.1 PC9121.2 PC9122.1 PC9123.1 PC9124.2 PD1.2 PD2.2 PD3.2 PJ2.1 PJ2.2 PJ2.9 PJ2.10 PQ2.9(PGND) PQ3.9(PGND) PQ129.1(S) PQ130.1(S) PR15.2 PR19.2 PR23.2 PR25.2 PR27.2 PR29.2 PR31.2 PR90.2 PR92.2 PR97.2 PR98.2 PR99.2 PR110.1 PR113.1 PR114.1 PR116.1 PR134.1 PR138.1 PR147.1 PR148.2 PR157.2 PR162.1 PR163.1 PR165.1 PR166.1 PR167.1 PR170.2 PR171.2 PR175.1 PR176.1 PR177.1 PR178.1 PR180.2 PR182.1 PR185.1 PR187.2 PR188.1 PU1.2(GND) PU1.4(HYST) PU2.A2(GND#1) PU2.B2(GND#2) PU3.B3(OVLO) PU3.C3(GND#1) PU3.D3(GND#2) PU3.E3(GND#3) PU4.33(GND) PU5.41(EPAD) PU6.9(GND) PU6.20(PGND) PU6.23(CGND) PU7.9(GND) PU7.20(PGND) PU7.23(CGND) PU8.9(GND) PU8.20(PGND) PU8.23(CGND) PU9.4(GND#1) PU9.9(GND#2) PU10.5(S2#1) PU10.6(S2#2) PU10.7(S2#3) PU11.2(GND) PU12.8(GND) PU13.8(GND) PU14.8(GND) PU15.2(GND) PU16.8(GND) PU17.8(GND) PU18.8(GND) PU19.8(GND) PU20.8(GND) PU21.8(GND) PU22.8(GND) PU23.8(GND) PU50.3(GND) PU51.11(GND#1) PU51.15(GND#2) PU3044.3(PGND) PU3045.3(PGND) PU3047.3(PGND) PU3048.3(PGND) PU3254.A5(PGNDVR4) PU3254.A7(VINLDO1_A7) PU3254.A8(PGNDLDO1_A8) PU3254.A12(PGNDVR3) PU3254.B7(VINLDO1_B7) PU3254.B8(PGNDLDO1_B8) PU3254.C2(DDRID) PU3254.D15(ENC) PU3254.E1(AGND1) PU3254.E16(AGND4) PU3254.F9(FBLDO1) PU3254.H1(BAT1) PU3254.H3(ACIN) PU3254.H9(VINLDO1S) PU3254.J1(BAT2) PU3254.J15(PGNDVR2_J15) PU3254.J16(PGNDVR2_J16) PU3254.L6(VCOMP) PU3254.N1(AGND2) PU3254.N16(AGND3) PU3254.P5(ENLVA) PU3254.P13(ENH) PU3254.T5(PGNDVR5) PU3254.T12(PGNDVR1) Q10.2(GND) Q109.1(EMITTER) Q110.1(EMITTER) Q112.1(S) Q114.1(S) Q121.1(EMITTER) Q125.1(EMITTER) Q136.1(S) QAP1009.1(S) QCP4007.1(S) QCP4112.1(S) QPM3251.1(S) QPM3360.1(S) QPM3371.1(S) QPM3372.1(S) QPM3373.1(S) QPM3374.1(S) QPM3382.1(S) QPM3387.1(S) QPM3391.1(S) R1A2.2 R1C5.2 R1C10.2 R1D11.2 R1D12.2 R1D19.1 R1D21.1 R1D22.1 R1M4.1 R1M5.1 R41.1 R45.2 R46.2 R47.2 R48.2 R136.2 R138.2 R529.2 R619.1 R679.1 R739.1 R936.1 R979.2 R984.2 R1000.1 R1023.2 R1044.1 R1045.1 R1046.1 R1047.1 R1052.2 R1053.2 R1054.2 R1056.1 R1064.1 R1082.2 R1097.1 R1115.2 R1116.2 R1117.2 R1118.2 R1119.2 R1120.2 R1141.1 R1142.1 R1143.1 R1182.1 R3587.2 R3593.2 R3594.2 R3608.2 R3609.2 R3611.2 R3614.2 R5037.2 R5080.2 R5102.2 R5106.1 R5147.1 R5150.2 R6001.1 R6002.1 R6003.1 R6008.1 R6009.1 RAP1017.2 RAP1018.2 RAP1019.2 RAP1021.2 RAP1023.2 RAP1025.2 RAP1030.2 RAP1032.2 RAP1034.2 RAP1035.2 RAP1050.2 RAP1054.2 RAP1055.2 RAP1067.2 RAP1323.2 RAP1325.1 RAP1326.1 RAP1327.2 RAP1328.2 RAP1330.2 RAP1331.2 RAP1332.2 RAP1333.2 RAP1335.2 RAP1336.2 RAP1337.2 RAP1422.1 RAP1431.2 RAP1433.2 RAP1455.2 RAP3040.2 RAP3041.1 RAP3047.2 RCP4021.2 RCP4029.2 RCP4162.1 RCP4184.1 RCP4186.1 RCP4193.2 RCP4194.2 RCP4219.1 RCP4220.1 RCP4221.2 RPM3426.1 RPM3431.2 RPM3465.2 RPM3562.2 RPM3573.1 RSM1012.1 RSM1014.1 RSM2007.1 RSM2008.1 RSM2075.1 RSM2076.1 RSM2112.1 RSM2113.1 RSM2150.2 RSM2152.2 SW1.3 SW1.5 SW1.6 U1.5(VSSA) U1.8(VSSCP) U1.21(VSSD) U1.29(VSSMIC) U1.33(EPAD) U3.3(GND_3) U3.11(GND_11) U3.15(GND_15) U3.17(EXPOSED_PAD) U4.2(GND) U5.3(GND_3) U5.11(GND_11) U5.15(GND_15) U5.17(EXPOSED_PAD) U6.9(GND#1) U6.11(GND#2) U8.2(GND) U23.3(GND) U23.8(GND#1) U26.14(GND) U26.33(EPAD) U26.34(THM#1) U26.35(THM#2) U26.36(THM#3) U26.37(THM#4) U26.38(THM#5) U26.39(THM#6) U26.40(THM#7) U26.41(THM#8) U80.A5(VSS_A5) U80.A67(VSS_A67) U80.A70(VSS_A70) U80.AA2(VSS_AA2) U80.AA4(VSS_AA4) U80.AA65(VSS_AA65) U80.AA68(VSS_AA68) U80.AB8(VSS_AB8) U80.AB15(VSS_AB15) U80.AB16(VSS_AB16) U80.AB18(VSS_AB18) U80.AB21(VSS_AB21) U80.AD8(VSS_AD8) U80.AD13(VSS_AD13) U80.AD16(VSS_AD16) U80.AD19(VSS_AD19) U80.AD20(VSS_AD20) U80.AD21(VSS_AD21) U80.AD62(VSS_AD62) U80.AE64(VSS_AE64) U80.AE65(VSS_AE65) U80.AE66(VSS_AE66) U80.AE67(VSS_AE67) U80.AE68(VSS_AE68) U80.AE69(VSS_AE69) U80.AF1(VSS_AF1) U80.AF2(VSS_AF2) U80.AF4(VSS_AF4) U80.AF10(VSS_AF10) U80.AF15(VSS_AF15) U80.AF17(VSS_AF17) U80.AF63(VSS_AF63) U80.AG16(VSS_AG16) U80.AG17(VSS_AG17) U80.AG18(VSS_AG18) U80.AG19(VSS_AG19) U80.AG20(VSS_AG20) U80.AG21(VSS_AG21) U80.AG71(VSS_AG71) U80.AH6(VSS_AH6) U80.AH13(VSS_AH13) U80.AH63(VSS_AH63) U80.AH64(VSS_AH64) U80.AH67(VSS_AH67) U80.AJ4(VSS_AJ4) U80.AJ15(VSS_AJ15) U80.AJ18(VSS_AJ18) U80.AJ20(VSS_AJ20) U80.AK8(VSS_AK8) U80.AK11(VSS_AK11) U80.AK16(VSS_AK16) U80.AK18(VSS_AK18) U80.AK21(VSS_AK21) U80.AK22(VSS_AK22) U80.AK27(VSS_AK27) U80.AK63(VSS_AK63) U80.AK68(VSS_AK68) U80.AK69(VSS_AK69) U80.AL2(VSS_AL2) U80.AL4(VSS_AL4) U80.AL28(VSS_AL28) U80.AL32(VSS_AL32) U80.AL35(VSS_AL35) U80.AL38(VSS_AL38) U80.AL45(VSS_AL45) U80.AL48(VSS_AL48) U80.AL52(VSS_AL52) U80.AL55(VSS_AL55) U80.AL58(VSS_AL58) U80.AL64(VSS_AL64) U80.AL65(VSS_AL65) U80.AL66(VSS_AL66) U80.AM8(VSS_AM8) U80.AM13(VSS_AM13) U80.AM21(VSS_AM21) U80.AM25(VSS_AM25) U80.AM27(VSS_AM27) U80.AM43(VSS_AM43) U80.AM45(VSS_AM45) U80.AM46(VSS_AM46) U80.AM55(VSS_AM55) U80.AM60(VSS_AM60) U80.AM61(VSS_AM61) U80.AM68(VSS_AM68) U80.AM71(VSS_AM71) U80.AN20(VSS_AN20) U80.AN23(VSS_AN23) U80.AN28(VSS_AN28) U80.AN30(VSS_AN30) U80.AN32(VSS_AN32) U80.AN33(VSS_AN33) U80.AN35(VSS_AN35) U80.AN37(VSS_AN37) U80.AN38(VSS_AN38) U80.AN40(VSS_AN40) U80.AN42(VSS_AN42) U80.AN58(VSS_AN58) U80.AN63(VSS_AN63) U80.AP10(VSS_AP10) U80.AP18(VSS_AP18) U80.AP20(VSS_AP20) U80.AP23(VSS_AP23) U80.AP28(VSS_AP28) U80.AP32(VSS_AP32) U80.AP35(VSS_AP35) U80.AP38(VSS_AP38) U80.AP42(VSS_AP42) U80.AP58(VSS_AP58) U80.AP63(VSS_AP63) U80.AP68(VSS_AP68) U80.AP70(VSS_AP70) U80.AR5(VSS_AR5) U80.AR8(VSS_AR8) U80.AR11(VSS_AR11) U80.AR15(VSS_AR15) U80.AR16(VSS_AR16) U80.AR20(VSS_AR20) U80.AR23(VSS_AR23) U80.AR28(VSS_AR28) U80.AR35(VSS_AR35) U80.AR42(VSS_AR42) U80.AR43(VSS_AR43) U80.AR45(VSS_AR45) U80.AR46(VSS_AR46) U80.AR48(VSS_AR48) U80.AR50(VSS_AR50) U80.AR52(VSS_AR52) U80.AR53(VSS_AR53) U80.AR55(VSS_AR55) U80.AR58(VSS_AR58) U80.AR63(VSS_AR63) U80.AT2(VSS_AT2) U80.AT4(VSS_AT4) U80.AT20(VSS_AT20) U80.AT23(VSS_AT23) U80.AT28(VSS_AT28) U80.AT35(VSS_AT35) U80.AT42(VSS_AT42) U80.AT56(VSS_AT56) U80.AT58(VSS_AT58) U80.AT63(VSS_AT63) U80.AT68(VSS_AT68) U80.AT71(VSS_AT71) U80.AU10(VSS_AU10) U80.AU15(VSS_AU15) U80.AU20(VSS_AU20) U80.AU32(VSS_AU32) U80.AU38(VSS_AU38) U80.AV1(VSS_AV1) U80.AV68(VSS_AV68) U80.AV69(VSS_AV69) U80.AV70(VSS_AV70) U80.AV71(VSS_AV71) U80.AW6(VSS_AW6) U80.AW8(VSS_AW8) U80.AW10(VSS_AW10) U80.AW12(VSS_AW12) U80.AW14(VSS_AW14) U80.AW16(VSS_AW16) U80.AW18(VSS_AW18) U80.AW21(VSS_AW21) U80.AW23(VSS_AW23) U80.AW26(VSS_AW26) U80.AW28(VSS_AW28) U80.AW30(VSS_AW30) U80.AW32(VSS_AW32) U80.AW34(VSS_AW34) U80.AW36(VSS_AW36) U80.AW38(VSS_AW38) U80.AW41(VSS_AW41) U80.AW43(VSS_AW43) U80.AW45(VSS_AW45) U80.AW47(VSS_AW47) U80.AW49(VSS_AW49) U80.AW51(VSS_AW51) U80.AW53(VSS_AW53) U80.AW55(VSS_AW55) U80.AW57(VSS_AW57) U80.AW60(VSS_AW60) U80.AW62(VSS_AW62) U80.AW64(VSS_AW64) U80.AW66(VSS_AW66) U80.AY66(VSS_AY66) U80.B10(VSS_B10) U80.B14(VSS_B14) U80.B18(VSS_B18) U80.B22(VSS_B22) U80.B30(VSS_B30) U80.B34(VSS_B34) U80.B39(VSS_B39) U80.B44(VSS_B44) U80.B48(VSS_B48) U80.B53(VSS_B53) U80.B58(VSS_B58) U80.B62(VSS_B62) U80.B66(VSS_B66) U80.B71(VSS_B71) U80.BA1(VSS_BA1) U80.BA2(VSS_BA2) U80.BA6(VSS_BA6) U80.BA10(VSS_BA10) U80.BA14(VSS_BA14) U80.BA18(VSS_BA18) U80.BA23(VSS_BA23) U80.BA28(VSS_BA28) U80.BA32(VSS_BA32) U80.BA36(VSS_BA36) U80.BA41(VSS_BA41) U80.BA45(VSS_BA45) U80.BA49(VSS_BA49) U80.BA53(VSS_BA53) U80.BA57(VSS_BA57) U80.BA62(VSS_BA62) U80.BA66(VSS_BA66) U80.BA71(VSS_BA71) U80.BB6(VSS_BB6) U80.BB18(VSS_BB18) U80.BB26(VSS_BB26) U80.BB30(VSS_BB30) U80.BB34(VSS_BB34) U80.BB38(VSS_BB38) U80.BB43(VSS_BB43) U80.BB55(VSS_BB55) U80.BB60(VSS_BB60) U80.BB64(VSS_BB64) U80.BB67(VSS_BB67) U80.BB70(VSS_BB70) U80.C1(VSS_C1) U80.C5(VSS_C5) U80.C25(VSS_C25) U80.D6(VSS_D6) U80.D10(VSS_D10) U80.D11(VSS_D11) U80.D14(VSS_D14) U80.D18(VSS_D18) U80.D22(VSS_D22) U80.D25(VSS_D25) U80.D26(VSS_D26) U80.D30(VSS_D30) U80.D34(VSS_D34) U80.D39(VSS_D39) U80.D44(VSS_D44) U80.D45(VSS_D45) U80.D47(VSS_D47) U80.D48(VSS_D48) U80.D53(VSS_D53) U80.D58(VSS_D58) U80.D62(VSS_D62) U80.D66(VSS_D66) U80.D69(VSS_D69) U80.E6(VSS_E6) U80.E11(VSS_E11) U80.E15(VSS_E15) U80.E18(VSS_E18) U80.E21(VSS_E21) U80.E46(VSS_E46) U80.E50(VSS_E50) U80.E53(VSS_E53) U80.E56(VSS_E56) U80.E65(VSS_E65) U80.E71(VSS_E71) U80.F1(VSS_F1) U80.F2(VSS_F2) U80.F4(VSS_F4) U80.F8(VSS_F8) U80.F13(VSS_F13) U80.F22(VSS_F22) U80.F23(VSS_F23) U80.F27(VSS_F27) U80.F28(VSS_F28) U80.F32(VSS_F32) U80.F33(VSS_F33) U80.F35(VSS_F35) U80.F37(VSS_F37) U80.F38(VSS_F38) U80.F40(VSS_F40) U80.F42(VSS_F42) U80.F68(VSS_F68) U80.G5(VSS_G5) U80.G6(VSS_G6) U80.G10(VSS_G10) U80.G22(VSS_G22) U80.G43(VSS_G43) U80.G45(VSS_G45) U80.G48(VSS_G48) U80.G52(VSS_G52) U80.G55(VSS_G55) U80.G58(VSS_G58) U80.G60(VSS_G60) U80.G63(VSS_G63) U80.G66(VSS_G66) U80.H15(VSS_H15) U80.H18(VSS_H18) U80.H71(VSS_H71) U80.J8(VSS_J8) U80.J11(VSS_J11) U80.J13(VSS_J13) U80.J25(VSS_J25) U80.J28(VSS_J28) U80.J32(VSS_J32) U80.J35(VSS_J35) U80.J38(VSS_J38) U80.J42(VSS_J42) U80.K16(VSS_K16) U80.K18(VSS_K18) U80.K22(VSS_K22) U80.K61(VSS_K61) U80.K63(VSS_K63) U80.K64(VSS_K64) U80.K65(VSS_K65) U80.K66(VSS_K66) U80.K67(VSS_K67) U80.K68(VSS_K68) U80.K70(VSS_K70) U80.K71(VSS_K71) U80.L2(VSS_L2) U80.L4(VSS_L4) U80.L8(VSS_L8) U80.L11(VSS_L11) U80.L16(VSS_L16) U80.L17(VSS_L17) U80.L18(VSS_L18) U80.L20(VSS_L20) U80.N6(VSS_N6) U80.N10(VSS_N10) U80.N13(VSS_N13) U80.N19(VSS_N19) U80.N21(VSS_N21) U80.N65(VSS_N65) U80.N68(VSS_N68) U80.P17(VSS_P17) U80.P19(VSS_P19) U80.P20(VSS_P20) U80.P21(VSS_P21) U80.R6(VSS_R6) U80.R13(VSS_R13) U80.T2(VSS_T2) U80.T4(VSS_T4) U80.T15(VSS_T15) U80.T17(VSS_T17) U80.T18(VSS_T18) U80.T21(VSS_T21) U80.U10(VSS_U10) U80.U63(VSS_U63) U80.U64(VSS_U64) U80.U66(VSS_U66) U80.U67(VSS_U67) U80.U69(VSS_U69) U80.U70(VSS_U70) U80.V16(VSS_V16) U80.V17(VSS_V17) U80.V18(VSS_V18) U80.W6(VSS_W6) U80.W9(VSS_W9) U80.W13(VSS_W13) U80.Y17(VSS_Y17) U80.Y19(VSS_Y19) U80.Y20(VSS_Y20) U80.Y21(VSS_Y21) U82.2(GND[0]) U82.9(GND[1]) U82.16(NCI/GND[2]) U82.23(GND[3]) U82.32(GND[4]) U82.33(EPAD) U83.7(GND) U86.5(GND) U86.9(EPAD) U90.1(GND) U90.21(EPAD) U95.8(VSSA) U95.23(VSS#1) U95.47(VSS#2) U95.49(EPAD) U96.15(GND#1) U96.18(GND#2) U96.37(GND#3) U96.41(GND#4) U97.1(GND) U97.7(EPAD) U98.1(GND) U98.7(EPAD) U108.3(GND) U111.3(GND) U123.4(GND) U130.1(S1) U132.2(GND) U133.5(GND) U135.3(GND) U138.7(GND) UAP1008.3(GND) UAP1012.4(GND) UCP4006.6(GND) UCP4007.5(GND) UCP4034.3(GND) UCP4034.8(GND#1) UCP4036.3(GND) UCP4036.8(GND#1) UPM3253.4(GND) USM2000.B2(VSS#1) USM2000.B5(VSS#2) USM2000.B6(VSSQ#2) USM2000.B12(VSSQ#1) USM2000.C3(VSSCA#1) USM2000.C5(VSS#3) USM2000.C6(VSSQ#3) USM2000.D3(VSSCA#2) USM2000.D8(DM3) USM2000.D12(VSSQ#4) USM2000.E4(VSS#4) USM2000.E5(VSS#5) USM2000.E6(VSSQ#5) USM2000.F4(VSSCA#3) USM2000.F5(VSS#6) USM2000.F6(VSSQ#7) USM2000.F12(VSSQ#6) USM2000.G3(VSSCA#4) USM2000.G4(VSSCA#5) USM2000.G6(VSSQ#8) USM2000.G8(DM1) USM2000.G9(VSSQ#9) USM2000.H2(VSS#7) USM2000.H10(VSSQ#10) USM2000.J4(VSSCA#6) USM2000.J12(VSS#8) USM2000.K2(VSS#9) USM2000.K10(VSSQ#11) USM2000.L6(VSS#10) USM2000.L8(DM0) USM2000.L9(VSSQ#12) USM2000.M4(VSSCA#7) USM2000.M5(VSS#11) USM2000.M6(VSSQ#14) USM2000.M12(VSSQ#13) USM2000.N4(VSS#12) USM2000.N5(VSS#13) USM2000.N6(VSSQ#15) USM2000.P3(VSSCA#8) USM2000.P8(DM2) USM2000.P12(VSSQ#16) USM2000.R4(VSS#14) USM2000.R5(VSS#15) USM2000.R6(VSSQ#17) USM2000.T2(VSS#16) USM2000.T3(VSS#17) USM2000.T4(VSS#18) USM2000.T5(VSS#19) USM2000.T6(VSSQ#19) USM2000.T12(VSSQ#18) USM2001.B2(VSS#1) USM2001.B5(VSS#2) USM2001.B6(VSSQ#2) USM2001.B12(VSSQ#1) USM2001.C3(VSSCA#1) USM2001.C5(VSS#3) USM2001.C6(VSSQ#3) USM2001.D3(VSSCA#2) USM2001.D8(DM3) USM2001.D12(VSSQ#4) USM2001.E4(VSS#4) USM2001.E5(VSS#5) USM2001.E6(VSSQ#5) USM2001.F4(VSSCA#3) USM2001.F5(VSS#6) USM2001.F6(VSSQ#7) USM2001.F12(VSSQ#6) USM2001.G3(VSSCA#4) USM2001.G4(VSSCA#5) USM2001.G6(VSSQ#8) USM2001.G8(DM1) USM2001.G9(VSSQ#9) USM2001.H2(VSS#7) USM2001.H10(VSSQ#10) USM2001.J4(VSSCA#6) USM2001.J12(VSS#8) USM2001.K2(VSS#9) USM2001.K10(VSSQ#11) USM2001.L6(VSS#10) USM2001.L8(DM0) USM2001.L9(VSSQ#12) USM2001.M4(VSSCA#7) USM2001.M5(VSS#11) USM2001.M6(VSSQ#14) USM2001.M12(VSSQ#13) USM2001.N4(VSS#12) USM2001.N5(VSS#13) USM2001.N6(VSSQ#15) USM2001.P3(VSSCA#8) USM2001.P8(DM2) USM2001.P12(VSSQ#16) USM2001.R4(VSS#14) USM2001.R5(VSS#15) USM2001.R6(VSSQ#17) USM2001.T2(VSS#16) USM2001.T3(VSS#17) USM2001.T4(VSS#18) USM2001.T5(VSS#19) USM2001.T6(VSSQ#19) USM2001.T12(VSSQ#18) USM2002.B2(VSS#1) USM2002.B5(VSS#2) USM2002.B6(VSSQ#2) USM2002.B12(VSSQ#1) USM2002.C3(VSSCA#1) USM2002.C5(VSS#3) USM2002.C6(VSSQ#3) USM2002.D3(VSSCA#2) USM2002.D8(DM3) USM2002.D12(VSSQ#4) USM2002.E4(VSS#4) USM2002.E5(VSS#5) USM2002.E6(VSSQ#5) USM2002.F4(VSSCA#3) USM2002.F5(VSS#6) USM2002.F6(VSSQ#7) USM2002.F12(VSSQ#6) USM2002.G3(VSSCA#4) USM2002.G4(VSSCA#5) USM2002.G6(VSSQ#8) USM2002.G8(DM1) USM2002.G9(VSSQ#9) USM2002.H2(VSS#7) USM2002.H10(VSSQ#10) USM2002.J4(VSSCA#6) USM2002.J12(VSS#8) USM2002.K2(VSS#9) USM2002.K10(VSSQ#11) USM2002.L6(VSS#10) USM2002.L8(DM0) USM2002.L9(VSSQ#12) USM2002.M4(VSSCA#7) USM2002.M5(VSS#11) USM2002.M6(VSSQ#14) USM2002.M12(VSSQ#13) USM2002.N4(VSS#12) USM2002.N5(VSS#13) USM2002.N6(VSSQ#15) USM2002.P3(VSSCA#8) USM2002.P8(DM2) USM2002.P12(VSSQ#16) USM2002.R4(VSS#14) USM2002.R5(VSS#15) USM2002.R6(VSSQ#17) USM2002.T2(VSS#16) USM2002.T3(VSS#17) USM2002.T4(VSS#18) USM2002.T5(VSS#19) USM2002.T6(VSSQ#19) USM2002.T12(VSSQ#18) USM2003.B2(VSS#1) USM2003.B5(VSS#2) USM2003.B6(VSSQ#2) USM2003.B12(VSSQ#1) USM2003.C3(VSSCA#1) USM2003.C5(VSS#3) USM2003.C6(VSSQ#3) USM2003.D3(VSSCA#2) USM2003.D8(DM3) USM2003.D12(VSSQ#4) USM2003.E4(VSS#4) USM2003.E5(VSS#5) USM2003.E6(VSSQ#5) USM2003.F4(VSSCA#3) USM2003.F5(VSS#6) USM2003.F6(VSSQ#7) USM2003.F12(VSSQ#6) USM2003.G3(VSSCA#4) USM2003.G4(VSSCA#5) USM2003.G6(VSSQ#8) USM2003.G8(DM1) USM2003.G9(VSSQ#9) USM2003.H2(VSS#7) USM2003.H10(VSSQ#10) USM2003.J4(VSSCA#6) USM2003.J12(VSS#8) USM2003.K2(VSS#9) USM2003.K10(VSSQ#11) USM2003.L6(VSS#10) USM2003.L8(DM0) USM2003.L9(VSSQ#12) USM2003.M4(VSSCA#7) USM2003.M5(VSS#11) USM2003.M6(VSSQ#14) USM2003.M12(VSSQ#13) USM2003.N4(VSS#12) USM2003.N5(VSS#13) USM2003.N6(VSSQ#15) USM2003.P3(VSSCA#8) USM2003.P8(DM2) USM2003.P12(VSSQ#16) USM2003.R4(VSS#14) USM2003.R5(VSS#15) USM2003.R6(VSSQ#17) USM2003.T2(VSS#16) USM2003.T3(VSS#17) USM2003.T4(VSS#18) USM2003.T5(VSS#19) USM2003.T6(VSSQ#19) USM2003.T12(VSSQ#18) USM2006.A6(VSS#5/NC) USM2006.C4(VSSQ#1) USM2006.E7(VSS#1) USM2006.G5(VSS#2) USM2006.H10(VSS#3) USM2006.J5(VSS#6/NC) USM2006.K8(VSS#4) USM2006.N2(VSSQ#2) USM2006.N5(VSSQ#3) USM2006.P4(VSSQ#4) USM2006.P6(VSSQ#5) X5.2 X5.4
V1P00S_PG: PR38.1 PR105.2 PU3254.G4(PGG)
V1P8U_LSW: PR37.1 PR108.2 PU3254.A10(PGB)
V3P3A_PCH_LSW: PR40.1 PR109.2 PU3254.D5(PGE)
V3P3A_PCH_PG: PR36.1 PR107.2 PU3254.C12(PGA)
V3P3DSW_ENA: CR15.2(ANODE) PR54.1 R5049.2 R5050.2 R5051.1 R5151.1
V5A_DS3_PG: PU3254.B15(ENA) PU3254.P7(EN5VSW) PU3254.R6(PGVR5)
VBATTBKUP: PR132.2 PU3254.C16(VBATTBKUP)
VCCCORE_SENSE: PR58.2 U80.E32(VCCCORE_SENSE)
VCCGT_SENSE: PR56.1 U80.J70(VCCGT_SENSE)
VCCIO_LSW: PR71.2 PR106.2 PU15.3(A) PU3254.J4(PGD)
VCCIO_PG: PU3254.P11(PGVR1) TP63.1
VCCIO_PG_EN: PR38.2 PR39.2 PU3254.L16(END)
VCCRTCEXT: CAP1282.2 U80.BB10(VCCRTCEXT_BB10)
VCCSA_SENSE: PR60.1 U80.H20(VCCSA_SENSE)
VCCST_PWRGD_MCP: RAP1064.2 U80.B65(VCCST_PWRGD)
VCCSTG_EN: PR62.2 PR71.1 PR81.2 PU14.9(ON) PU16.9(ON)
VCCSTG_OVR_EN_R: PR62.1 PU15.4(Y)
VDDQ_PG: PR39.1 PU3254.C6(PGVR4)
VSSCORE_SENSE: PR59.2 U80.E33(VSSCORE_SENSE)
VSSGT_SENSE: PR57.1 U80.J69(VSSGT_SENSE)
VSSSA_SENSE: PR61.1 U80.H21(VSSSA_SENSE)
1A5_EN_C0: QPM3383.2(G) QPM3384.2(G) R5040.1 R5041.2
+GT_VRCTL: PC16.1 PC18.1 PC9102.1 PC9103.1 PR49.1 PU7.2(VCIN) PU7.21(VDRV) PU8.2(VCIN) PU8.21(VDRV)
+ISL_5VLDO: PC1313.1 PR161.2 PU4.8(VDDP)
+PMIC_VRCTL: PC1323.2 PC1324.2 PC1325.2 PR48.2 PU3254.B5(VREGVR4) PU3254.G16(VREGVR2) PU3254.R12(VREGVR1)
+USB3_P4_VBUS: C386.2 CCP4197.1 CCP4198.2 CRCP4028.1 F104.1 J2.1(VBUS) U6.2(VDD)
+USB3_P4_VBUS_FUSE: EUCP4040.12(OUT) F104.2
+V_BOOSTIN: C8L13.1 C8L14.1 PC1142.1 PC1143.1 PC1153.1 PD4.1(CATHODE1) PR2.1 PR125.2 PR179.2 PU3.A1(VINT#1) PU3.B1(VINT#2) PU3.C1(VINT#3) PU3.D1(VINT#4) PU4.16(ADP) R1022.1
+V_USB2PWR: CN2.5 CN2.6 CN2.7 CN2.8 CN2.9 F2B1.2
+V_USB2PWR_R: EU1B2.12(OUT) F2B1.1
+VR1_VBATA: JP3535.1 PC1169.1 PC1182.1 PC1285.2 PU3045.2(VIN)
+VR3_VBATA: JP3536.1 PC1170.1 PC1171.1 PC1286.2 PU3044.2(VIN) PU3254.H11(VINVR3)
+VR4_VBATA: JP3537.1 PC1174.1 PC1175.1 PC1288.2 PU3047.2(VIN)
+VR5_VBATA: JP3538.1 PC1172.1 PC1173.1 PC1287.2 PU3048.2(VIN) PU3254.N8(VINVR5)
+VRTC_EC: CRPM3518.2(ANODE) PC9112.1 PU3254.P9(VOUT3V3SW)
+VUSBC1_VBUS_CONN: C8L17.1 C8L18.1 C8L19.1 C8L20.1 C1111.1 C1112.1 EC1.1 JCP4038.A4(VBUS#1) JCP4038.A9(VBUS#2) JCP4038.B4(VBUS#3) JCP4038.B9(VBUS#4) PC1196.1 PC1197.1 PD3.1 PR137.2 PR160.2 PU2.A3(VOUT#1) PU2.B3(VOUT#2) PU3.B2(VBUS#1) PU3.C2(VBUS#2) PU3.D2(VBUS#3) PU3.E1(VBUS#4) PU3.E2(VBUS#5) U90.17(VBUSIN)
ALL_SYS_PWRGD: PR103.2 PU5.40(VR_ENABLE) PU3254.F15(ALL_SYS_PWRGD) TP109.1
AUDIO_I2S_MCLK_R: R851.1 R1124.2 U108.4(OUT Y)
AUDIO_INT_WAK*: QPM3388.3(D) R1131.1 U80.AT10(GPP_B_8_SRCCLKREQB_3)
AUDIO_IRQ*: QPM3388.1(S) R5088.2 U1.15(IRQ) U80.AD11(GPP_F_10_I2C5_SDA_ISH_I2C2_SDA)
AUDIO_JACK_JD: J1C1.5 R1C5.1
BATT_ENABLE*: PJ2.6 Q135.3(D)
BC_ACOK: C1028.2 PR20.1 PR47.1 PU3254.F13(ACOK) U83.2(ACOK)
BC_IBAT: PC1051.2 PU4.29(AMON/BMON) R3526.1
BC_IBAT_C: C1116.2 EUPM3247.A20(ADC3/GPIO061) R3526.2
BKUP_BAT: PR132.1 TP165.1
BOOT_BEEP: U80.AF13(GPP_F_23) U138.1(1O\E\) U138.4(2O\E\) U138.10(3O\E\)
BUF_PCH_PLT_RST*: Q111.3(D) Q127.3(D) R1104.1 RAP3047.1 RAP3048.2 U135.4(OUT Y)
BUF_PCH_PLT_RST*_R: EUPM3247.A27(LRESET#/GPIO116) R1104.2
CA_VREF: CSM1019.1 CSM2032.1 CSM2100.1 CSM2131.1 RAP1026.2 RAP1029.2 RAP1030.1 USM2000.H4(VREF_CA) USM2001.H4(VREF_CA) USM2002.H4(VREF_CA) USM2003.H4(VREF_CA)
CAP1_GND: PC1302.1 PU18.7(CAP)
CAP2_GND: PC1303.1 PU23.7(CAP)
CAP3_GND: PC1308.1 PU21.7(CAP)
CAP5_GND: PC1309.1 PU22.7(CAP)
CCD_PWR: J8L1.22 J8L1.23 R5010.1
CFG<0>: RAP1328.1 RAP1344.2 U80.E68(NOA_N_0)
CFG<2>: RAP1330.1 U80.D65(NOA_N_2)
CFG<3>: RAP1331.1 U80.D67(NOA_N_3)
CFG<4>: RAP1332.1 U80.E70(NOA_N_4)
CFG<5>: RAP1327.1 U80.C68(NOA_N_5)
CFG<6>: RAP1333.1 U80.D68(NOA_N_6)
CFG<8>: RAP1335.1 U80.F71(NOA_N_8)
CFG<9>: RAP1336.1 U80.G69(NOA_N_9)
CFG<10>: RAP1337.1 U80.F70(NOA_N_10)
CHARGE_LED1: EUPM3247.A57(LED1/GPIO155) Q125.2(BASE)
CHARGE_LED2: EUPM3247.B61(LED2/GPIO156) Q121.2(BASE)
CONN_SLEEVE_FET: Q112.2(G) Q114.2(G) Q136.3(D) R1B32.2
CORE_CSN: PC26.2 PC1281.2 PC9098.1 PC9108.2 PR34.1 PR140.1 PR146.1 PR186.2
CORE_CSP: PC26.1 PC9108.1 PR121.1 PR146.2 PR154.1 PU5.19(ISUMP_A)
CORE_FCCM: PU5.21(FCCM_A) PU6.1(ZCD_EN#)
CORE_PWM1: PU5.22(PWM_A) PU6.22(PWM)
CORE_SW_DRV: PL4.1 PR5.2 PR121.2 PU6.12(VSWH)
CPU_JTAG_TCLK: R138.1 RAP1351.2 U80.B61(CPU_JTAG_TCK)
CPU_JTAG_TDI: R129.2 RAP1381.1 U80.D60(CPU_JTAG_TDI)
CPU_JTAG_TDO: R130.2 RAP1376.1 U80.A61(CPU_JTAG_TDO)
CPU_JTAG_TMS: R131.2 RAP1383.1 U80.C60(CPU_JTAG_TMS)
CPU_POPIRCOMP: R45.1 U80.AT16(CPU_POPIRCOMP)
CPU_SVIDALRT*: PU5.36(ALTERT#) RAP1451.1 RPM3558.2
CPU_SVIDALRT*_R: RPM3558.1 U80.B63(VIDALERT_N)
CPU_SVIDCLK: PR164.2 PR174.1 U80.A63(VIDSCK)
CPU_SVIDDAT: PR118.2 PR158.2 RAP1450.1 U80.D64(VIDSOUT)
CSI2_COMP: RAP1055.1 U80.E13(CSI2_COMP)
DCIN_EN: R5108.2 U26.8(DCIN_EN)
DDI1_AUX_DN*: CCP4156.2 U80.G50(DDI1_AUXN)
DDI1_AUX_DP: CCP4157.2 U80.F50(DDI1_AUXP)
DDI1_C_AUX_DN: CCP4156.1 RCP4160.2 U96.20(AUX-)
DDI1_C_AUX_DP: CCP4157.1 RCP4162.2 U96.19(AUX+)
DDI1_CTRL_DATA: R879.1 U80.L12(GPP_E_19_DDPB_CTRLDATA)
DDI1_HPD: EUPM3247.A33(PS2_CLK0/GPIO046) R1134.2 U80.L9(GPP_E_13_DDSP_HPD_0)
DDI1_LANE_DN*<0>: U80.E55(DDI1_TXN_0) U96.40(DP0-)
DDI1_LANE_DN*<1>: U80.E58(DDI1_TXN_1) U96.3(DP1-)
DDI1_LANE_DN*<2>: U80.F53(DDI1_TXN_2) U96.6(DP2-)
DDI1_LANE_DN*<3>: U80.F56(DDI1_TXN_3) U96.9(DP3-)
DDI1_LANE_DP<0>: U80.F55(DDI1_TXP_0) U96.39(DP0+)
DDI1_LANE_DP<1>: U80.F58(DDI1_TXP_1) U96.2(DP1+)
DDI1_LANE_DP<2>: U80.G53(DDI1_TXP_2) U96.5(DP2+)
DDI1_LANE_DP<3>: U80.G56(DDI1_TXP_3) U96.8(DP3+)
DDI2_CTRL_CLK: R682.2 U26.31(SCL_SRC) U80.N7(GPP_E_20_DDPC_CTRLCLK)
DDI2_CTRL_DATA: R681.2 R877.1 U26.32(SDA_SRC) U80.N8(GPP_E_21_DDPC_CTRLDATA)
DDI2_HPD: U26.3(HPD_SRC) U80.L7(GPP_E_14_DDSP_HPD_1)
DDI2_LANE_DN*<0>: C982.1 U80.C50(DDI2_TXN_0)
DDI2_LANE_DN*<1>: C141.1 U80.C52(DDI2_TXN_1)
DDI2_LANE_DN*<2>: C984.1 U80.A50(DDI2_TXN_2)
DDI2_LANE_DN*<3>: C151.1 U80.D51(DDI2_TXN_3)
DDI2_LANE_DP<0>: C981.1 U80.D50(DDI2_TXP_0)
DDI2_LANE_DP<1>: C139.1 U80.D52(DDI2_TXP_1)
DDI2_LANE_DP<2>: C129.1 U80.B50(DDI2_TXP_2)
DDI2_LANE_DP<3>: C983.1 U80.C51(DDI2_TXP_3)
DDR_CA_VREF: CAP1020.2 RAP1026.1 U80.AY67(DDR_VREF_CA)
DDR_VREFDQ_CHA: CAP1022.2 RAP1027.1 U80.AY68(DDR_VREF_DQ_0)
DDR_VREFDQ_CHB: CAP1024.2 RAP1028.1 U80.BA67(DDR_VREF_DQ_1)
DDR_VTT_CTRL: PR64.1 U80.AW67(DDR_VTT_CNTL)
DDR_VTT_CTRL_R: PR64.2 PU3254.E4(DDR_VTT_CTRL)
DEVICE_PROCHOT*: PR41.2 PR46.1 PR63.2 QPM3387.2(G) R1076.2 RAP1364.1 RAP3042.2 RCP4072.2 RCP4074.1
DMIC_CLK0_L: R772.2 R5140.1 R5142.1
DMIC_CLK0_R: R900.2 U80.D8(GPP_D_17_DMIC_CLK_1)
DMIC_CLK_L2: C1110.1 J8L1.39 R772.1
DMIC_DAT_L2: C67.1 J8L1.38 R771.1
DMIC_DATA0_L: R771.2 R5141.1 R5143.1
DRVH1: PU3045.1(TG) PU3254.T14(DRVHVR1)
DRVH3: PU3044.1(TG) PU3254.A14(DRVHVR3)
DRVH4: PU3047.1(TG) PU3254.A3(DRVHVR4)
DRVHVR5: PU3048.1(TG) PU3254.T3(DRVHVR5)
DRVL1: PU3045.4(BG) PU3254.T11(DRVLVR1)
DRVL3: PU3044.4(BG) PU3254.A11(DRVLVR3)
DRVL4: PU3047.4(BG) PU3254.A6(DRVLVR4)
DRVLVR5: PU3048.4(BG) PU3254.T6(DRVLVR5)
EAR_N: RAP1343.1 RAP1344.1
EC_3P3DSW_EN: EUPM3247.A18(GPIO211) QPM3382.2(G) RAP3041.2
EC_ACIN_R: EUPM3247.B57(GPIO030) RPM3455.1
EC_BATT_TMP: EUPM3247.B24(ADC0/GPIO056) PR22.1 PR119.2 R1A4PD1.2
EC_BL_DISABLE*: EUPM3247.A41(GPIO202) U111.2(INA)
EC_BRD_ID0: EUPM3247.A2(KSO13/GPIO006) R1051.2 R1054.1
EC_BRD_ID1: EUPM3247.B43(GPIO007/KSO14) R1050.2 R1053.1
EC_BRD_ID2: EUPM3247.B44(GPIO010/KSO15) R1049.2 R1052.1
EC_CAP: CPM3439.2 EUPM3247.A7(CAP)
EC_ENTERING_RW: EUPM3247.A30(GPIO041) U83.8(EC_ENTERING_RW)
EC_FAN_PWM: EUPM3247.B64(GPIO034/PWM2/TACH2PWM_OUT) Q5.1(EMITTER)
EC_FAN_TACH: C130.1 CN4.3 EUPM3247.B54(GPIO140/TACH2/TACH2PWM_IN) R874.2
EC_HID_INT*: TP21.1 U80.AU11(GPP_A_11_PMEB)
EC_IN_RW: R56.2 U80.W3(GPP_C_6_SML1CLK) U83.9(EC_IN_RW)
EC_JTAG_TRST*: EUPM3247.A25(JTAG_RST#) RPM3426.2
EC_LPC_CLK: EUPM3247.B29(PCI_CLK/GPIO117) RPM3429.2
EC_LPC_CLK_R: RPM3429.1 U80.AW9(GPP_A_9_CLKOUT_LPC_0_ESPI_CLK)
EC_MUX_CLK: EUPM3247.A55(I2C0_CLK1/GPIO134) R1168.2 U90.14(SCL) U96.36(CONF1/SCL)
EC_MUX_SDA: EUPM3247.B58(I2C0_DAT1/GPIO017) R1169.2 U90.13(SDA) U96.38(CONF2/SDA)
EC_PCH_ACPRESENT: EUPM3247.B39(GPIO110) R5150.1 RAP1081.2 U80.AY15(GPD_1_ACPRESENT)
EC_PCH_PROCHOT: EUPM3247.B18(PS2_DAT2/GPIO052) QPM3251.2(G) RPM3465.1
EC_PCH_PWRBTN*: EUPM3247.A51(GPIO045/A20M/PVT_CS1#) RAP1457.2
EC_PCH_RCIN*: EUPM3247.A61(GPIO135/KBRST) RAP1000.2 U80.AW13(GPP_A_0_RCINB)
EC_PCH_WAKE*: EUPM3247.A62(GPIO066) RAP1008.2 U80.AM15(GPD_2_LAN_WAKEB)
EC_PD_I2C_CLK: EUPM3247.B47(GPIO022/I2C1_CLK0) RPM3467.1 U95.42(PB6)
EC_PD_I2C_SDA: EUPM3247.A44(GPIO023/I2C1_DAT0) RPM3458.1 U95.43(PB7)
EC_ROP_I2C_CLK: EUPM3247.A56(I2C0_CLK0/GPIO015) PU3254.M1(SCLK) RPM3472.1 RPM3592.1
EC_ROP_I2C_SDA: EUPM3247.B59(I2C0_DAT0/GPIO016) PU3254.K1(SDA) RPM3470.1 RPM3591.1
EC_ROP_SLP_SUS*: PR53.1 PR77.2 PR78.2 PR83.2 PU3254.J12(ENE) PU3254.R2(ENVR5) R5026.2 R5027.2 RAP3040.1
EC_RST: R1C10.1 R5151.2 U83.10(EC_RST_L)
EC_RST*: EUPM3247.B41(VCC1_RST#/GPIO131) PU3254.L4(EC_RST*) RPM3427.1
EC_RTCRST: EUPM3247.A58(GPIO163) QPM3360.2(G) QPM3391.2(G) RPM3562.1
EC_SCI*: EUPM3247.A38(NEC_SCI/GPIO026) RAP1014.2 U80.N9(GPP_E_16_DDSP_HPD_3)
EC_SHD_CS0*: EUPM3247.B52(GPIO150/SHD_CS0#) RPM3452.2
EC_SMB_CLK: EUPM3247.A63(GPIO024/I2C3_CLK0) PC8.1 PD1.1 PR7.1 PR44.1 RPM3475.1 UCP4006.10(SCL) UCP4007.8(SCL)
EC_SMB_CLK_B1: PJ2.4 PR7.2
EC_SMB_SDA: EUPM3247.B66(GPIO025/I2C3_DAT0) PC9.1 PD2.1 PR6.1 PR45.1 RPM3476.1 UCP4006.9(SDA) UCP4007.7(SDA)
EC_SMB_SDA_B1: PJ2.3 PR6.2
EC_SMI*: EUPM3247.B65(GPIO044/NSMI) RAP1016.2 U80.L6(GPP_E_15_DDSP_HPD_2)
EC_SPI_CLK: RPM3579.2 UPM3253.6(CLK)
EC_SPI_CLK_R: EUPM3247.B1(GPIO153/PVT_SCLK) RPM3462.2
EC_SPI_CS*: RPM3578.2 UPM3253.1(C\S\)
EC_SPI_CS*_R: EUPM3247.A48(GPIO146/PVT_CS0#) RPM3463.2
EC_SPI_HOLD*: RPM3473.2 UPM3253.7(H\O\L\D\(IO3))
EC_SPI_MISO: RPM3581.2 UPM3253.2(DO(IO1))
EC_SPI_MISO_R: EUPM3247.A47(GPIO164/PVT_MISO) RPM3461.2
EC_SPI_MOSI: RPM3580.2 UPM3253.5(DI(IO0))
EC_SPI_MOSI_R: EUPM3247.B67(GPIO054/PVT_MOSI) RPM3460.2
EC_USBA_ILIM_SEL: R5100.1 R5101.2 R5104.2
EC_USBPD_RST*: C1.1 CN17.45 EUPM3247.A37(GPIO130) R1084.2 U95.7(NRST)
EC_VCCSFR_OC: PR79.1 PR80.1 PR81.1 PU13.9(ON)
EC_XTAL_IN: C831.1 EUPM3247.B37(XTAL2) RPM3453.1 X8.2
EC_XTAL_OUT: C832.1 EUPM3247.B38(XTAL1) RPM3453.2 X8.1
ECGND: CPM3434.1 CPM3437.1 EUPM3247.A23(AVSS) RPM3431.1
ECRXD_SERVOTXD: CN17.32 EUPM3247.A43(GPIO162/RXD)
ECTXD_SERVORXD: CN17.33 EUPM3247.B46(GPIO165/TXD/SHD_CS1#)
EDP_AUX_DN*: C8L6.2 U80.E45(EDP_AUXN)
EDP_AUX_DP: C7L15.2 U80.F45(EDP_AUXP)
EDP_AUXN_C_DN: C8L6.1 J8L1.16
EDP_AUXP_C_DP: C7L15.1 J8L1.15
EDP_BKLEN_OUT: J8L1.26 U111.4(OUT Y)
EDP_COMP: RAP1013.2 U80.E52(DP_COMP)
EDP_HPD: C783.1 R788.2 RAP1455.1 U80.L10(GPP_E_17_EDP_HPD)
EDP_TX_DN*<0>: C7L13.2 U80.C47(EDP_TXN_0)
EDP_TX_DN*<1>: C7L11.2 U80.D46(EDP_TXN_1)
EDP_TX_DP<0>: C7L14.2 U80.C46(EDP_TXP_0)
EDP_TX_DP<1>: C7L12.2 U80.C45(EDP_TXP_1)
EDP_TXN0_C_DN: C7L13.1 J8L1.12
EDP_TXN1_C_DN: C7L11.1 J8L1.9
EDP_TXP0_C_DP: C7L14.1 J8L1.13
EDP_TXP1_C_DP: C7L12.1 J8L1.10
EDRAM_EDM: RAP1325.2 U80.AY71(EDRAM_EDM)
EDRAM_OPIO_RCOMP: R47.1 U80.H66(EDRAM_OPIO_RCOMP)
EMMC<0>: R5126.1 RSM2143.2 USM2006.A3(DAT0)
EMMC<1>: R5127.1 RSM2144.2 USM2006.A4(DAT1)
EMMC<2>: R5128.1 RSM2145.2 USM2006.A5(DAT2)
EMMC<3>: R5129.1 RSM2146.2 USM2006.B2(DAT3)
EMMC<4>: R5130.1 RSM2147.2 USM2006.B3(DAT4)
EMMC<5>: R5131.1 RSM2148.2 USM2006.B4(DAT5)
EMMC<6>: R5132.1 RSM2149.2 USM2006.B5(DAT6)
EMMC<7>: R5133.1 RSM2151.2 USM2006.B6(DAT7)
EMMC_3P3: CSM2159.2 CSM2160.2 R958.2 USM2006.E6(VCC#1) USM2006.F5(VCC#2) USM2006.J10(VCC#3) USM2006.K9(VCC#4)
EMMC_C2: CSM2156.2 USM2006.C2(VDDI)
EMMC_CLK: R5135.2 U80.AM3(GPP_F_22_EMMC_CLK)
EMMC_CLK_D: C1136.1 R5135.1 RSM2152.1 USM2006.M6(CLK)
EMMC_CMD: R5134.2 U80.AP4(GPP_F_12_EMMC_CMD)
EMMC_CMD_D: C1137.1 R5134.1 RSM2155.2 USM2006.M5(CMD)
EMMC_D<0>: R5126.2 U80.AP2(GPP_F_13_EMMC_DATA0)
EMMC_D<1>: R5127.2 U80.AP1(GPP_F_14_EMMC_DATA1)
EMMC_D<2>: R5128.2 U80.AP3(GPP_F_15_EMMC_DATA2)
EMMC_D<3>: R5129.2 U80.AN3(GPP_F_16_EMMC_DATA3)
EMMC_D<4>: R5130.2 U80.AN1(GPP_F_17_EMMC_DATA4)
EMMC_D<5>: R5131.2 U80.AN2(GPP_F_18_EMMC_DATA5)
EMMC_D<6>: R5132.2 U80.AM4(GPP_F_19_EMMC_DATA6)
EMMC_D<7>: R5133.2 U80.AM1(GPP_F_20_EMMC_DATA7)
EMMC_RCLK: R5136.2 U80.AM2(GPP_F_21_EMMC_RCLK)
EMMC_RCLK_D: R5136.1 RSM2150.1 USM2006.H5(DS/NC)
EMMC_RCOMP: RAP1054.1 U80.AT1(EMMC_RCOMP)
EN_PP1800_DX_AUDIO: R1143.2 U80.U1(GP_D13_ISH_UART0_RXD_SML0BDAT)
EN_PWR_WIFI: EUPM3247.A52(GPIO203) PU21.2(ON)
EN_USB_C0_5V_OUT: EUPM3247.B60(LED0/GPIO154) PQ130.2(G) PR99.1 PU2.C3(ON)
EN_USB_C0_CHARGE*: EUPM3247.A64(GPIO064/SHD_MOSI) PU3.A3(\\E\N\)
EN_VCCST: PR72.1 PR79.2 PU11.4(Y) PU12.9(ON)
EOPIO_RCOMP: R48.1 U80.H65(CPU_EOPIO_RCOMP)
EQ0: R5109.2 U26.13(EQ)
EXT_BOOT_STALL_STRAP: TP80.1 U80.AM7(GPP_B_23_SML1ALERTB_PCHHOTB)
FAN_PWM_CN: C952.1 CN4.4 Q5.3(COLLECTOR) R872.2
FAN_PWR_DIS*: EUPM3247.B53(GPIO160/BC_DAT) PC308.1 PU50.1(INB) PU50.4(OUT Y) PU51.3(ON1)
FBVR1P: PR30.1 PU3254.J10(FBVR1P)
FBVR3P: PR24.1 PU3254.F11(FBVR3P)
FBVR4P: PR26.1 PU3254.F5(FBVR4P)
FBVR5P: PR19.1 PR28.1 PU3254.J6(FBVR5P)
FLASH_DSC_OVERRIDE*: EUPM3247.B33(PS2_DAT1/GPIO065) Q105.2(G) RAP1430.2
FLASH_SPI_CLK: R866.1 R888.1 U80.AV2(SPI0_CLK)
FLASH_SPI_CLK_R: R888.2 U82.19(SCLK)
FLASH_SPI_CS*: R865.1 U80.AU3(SPI0_FLASH_0_CSB)
FLASH_SPI_MISO: R868.1 R889.1 RAP3023.1 U80.AW3(SPI0_MISO_IO_1)
FLASH_SPI_MISO_R: R868.2 RAP1409.1 UAP1012.2(DO(IO1))
FLASH_SPI_MISO_TPM: R889.2 U82.24(MISO)
FLASH_SPI_MOSI: R869.1 R890.1 U80.AV3(SPI0_MOSI_IO_0)
FLASH_SPI_MOSI_R: R869.2 RAP1410.1 UAP1012.5(DI(IO0))
FLASH_SPI_MOSI_TPM: R890.2 U82.21(MOSI)
G3_SLEEP_ENA: QPM3371.2(G) R1158.2 RPM3573.2
GT_CSN: PC2.2 PC23.2 PC1327.2 PC1328.2 PC9109.2 PR85.2 PR91.2 PR129.1 PR139.1 PR145.1 PR181.1
GT_CSP: PC23.1 PC9109.1 PR122.1 PR123.1 PR145.2 PR152.1 PU5.7(ISUMP_B)
GT_FCCM: PU5.11(FCCM_B) PU7.1(ZCD_EN#) PU8.1(ZCD_EN#)
GT_PWM1: PU5.12(PWM1_B) PU7.22(PWM)
GT_PWM2: PU5.13(PWM2_B) PU8.22(PWM)
GT_SW_DRV1: PL5.1 PR3.1 PR93.1 PR122.2 PU7.12(VSWH)
GT_SW_DRV2: PL6.1 PR4.1 PR96.1 PR123.2 PU8.12(VSWH)
HDMI_5V: C153.1 CN12.18(+5V) D21.1 Q10.1(VOUT) U23.4(D2+) U23.7(NC#2)
HDMI_ALS_PD: R5110.2 U26.12(PD#)
HDMI_DDCCLK_MB: CN12.15(DDC_CLK) R5116.2 U23.1(D1+) U23.10(NC#4) U26.28(SCL_SNK)
HDMI_DDCDATA_MB: CN12.16(DDC_DATA) R680.2 U23.2(D1-) U23.9(NC#3) U26.29(SDA_SNK)
HDMI_MB_HPD: R527.1 R529.1 U23.5(D2-) U23.6(NC#1) U26.25(HPD_SNK)
HP_CN_OUT_L: C3.2 D48.1 J1C1.1(L) R1D9.1
HP_CN_OUT_R: C4.2 D46.1 J1C1.2(R) R1D10.1
HP_DET_CN: CN12.19(HP_DET) R527.2
HP_OUT_L: R1D9.2 R1D22.2 U1.12(JKTIP(HPL))
HP_OUT_R: R1D10.2 R1D21.2 U1.13(JKR1(HPR))
HP_RING2: C1C47.1 D49.1 J1C1.3(G/M) Q114.3(D) U1.30(JKR2)
HP_SLEEVE: C1C48.1 D47.1 J1C1.4(M/G) Q112.3(D) U1.28(JKSLV)
HSJ_DET_L*: C1M7.1 Q129.3(D) R1B26.2 R1D7.1 U1.27(JKDET)
HSJ_DET_PCH_L: Q129.1(S) R1B30.2 R1D4.2 R1D13.2 R1D18.1 R2B2.1 R3493.1
HSJ_MIC_DET: R3493.2 U80.AM11(GPP_B_2_VRALERTB)
I2C0_SCL: Q137.6(D) R1142.2 R5155.1 RAP3054.1 U80.N3(GPP_D_6_ISH_I2C0_SCL) U80.U6(GPP_C_17_I2C0_SCL)
I2C0_SDA: Q137.3(D) R1141.2 R5154.1 RAP3053.1 U80.M4(GPP_D_5_ISH_I2C0_SDA) U80.U7(GPP_C_16_I2C0_SDA)
I2C1_SCL: CN3.6 CRCP4042.5(D2-) CRCP4042.6(NC#1) RAP1010.1 U80.U9(GPP_C_19_I2C1_SCL)
I2C1_SDA: CN3.5 CRCP4042.4(D2+) CRCP4042.7(NC#2) RAP1009.1 U80.U8(GPP_C_18_I2C1_SDA)
I2C4_SCL: C1139.1 R5148.1 RAP1049.1 RAP3043.2 U80.AF12(GPP_F_9_I2C4_SCL)
I2C4_SCL_C: C1113.1 R5148.2 U1.18(SCLK)
I2C4_SDA: C1138.1 R5149.1 RAP1047.1 RAP3044.2 U80.AF11(GPP_F_8_I2C4_SDA)
I2C4_SDA_C: C1114.1 R5149.2 U1.17(SDIO)
I2C_SCL_INA: RAP1429.2 RPM3576.2
I2C_SCL_INA_R: CN17.38 RAP1429.1
I2C_SDA_INA: RAP1428.1 RPM3577.2
I2C_SDA_INA_R: CN17.37 RAP1428.2
I2S0_RXD: U80.BA21(AZA_SDI_0_SSP0_RXD) U138.11(4Y)
I2S0_SCLK: U80.AY22(AZA_BCLK_SSP0_SCLK) U138.5(2A)
I2S0_SFRM: U80.BA22(AZA_SYNC_SSP0_SFRM) U138.2(1A)
I2S0_TXD: Q105.3(D) RAP1431.1 U80.BB22(AZA_SDO_SSP0_TXD) U138.9(3A)
I2S1_PCHRXD_NAUTXD: R5057.1 U1.24(ADCOUT)
I2S1_PCHRXD_NAUTXD_C: R5057.2 U80.AY21(AZA_SDI_1_SSP1_RXD)
I2S1_PCHTXD_NAURXD: R5060.1 U1.25(DACIN)
I2S1_PCHTXD_NAURXD_C: R5060.2 U80.AW20(SSP1_TXD)
I2S1_SCL: R5058.1 U1.26(BCLK)
I2S1_SCLK_C: R5058.2 U80.AW22(AZA_RSTB_SSP1_SCLK)
I2S1_SFRM: R5059.1 U1.23(FS)
I2S1_SFRM_C: R5059.2 U80.AY20(SSP1_SFRM)
I2S2_RXD: R3504.2 U80.AK10(GPP_F_3_SSP2_RXD)
I2S2_SCLK: R3502.2 U80.AK6(GPP_F_0_SSP2_SCLK)
I2S2_SFRM: R3501.2 U80.AK7(GPP_F_1_SSP2_SFRM)
I2S2_TXD: R3503.2 U80.AK9(GPP_F_2_SSP2_TXD)
I2S_MCLK: R1106.1 R1124.1 U108.1(INB) U108.2(INA)
I2S_MCLK_C: R1106.2 U80.J5(GPP_D_23_SSP_MCLK)
I2S_MCLK_R: R851.2 U1.19(MCLK)
ILIM_HI: EU1B2.16(ILIM_HI) R1M4.2
ILIM_LO: EU1B2.15(ILIM_LO) R1M5.2
ILIMVRH3: PR147.2 PU3254.E12(ILIMVR3HS)
ILIMVRH5: PR138.2 PU3254.M7(ILIMVR5HS)
ILIMVRL3: PR170.1 PU3254.E10(ILIMVR3LS)
IMVP8_PROCHOT*: PR63.1 PU5.38(VR_HOT#)
IMVP_PSYS: PC9123.2 PR42.1 PR165.2 PU5.1(PSYS)
IMVP_SVID_CLK: PR164.1 PU5.37(SCLK) TP127.1
IMVP_SVID_DATA: PR158.1 PU5.35(SDA) TP125.1
INT_HDMICLK+_C: CN12.10(CLK+) D61.4(LINE-3) D61.7(NC#2) L19.2
INT_HDMICLK+_IC: C983.2 U26.9(IN_CKP)
INT_HDMICLK+_LS: L19.1 U26.19(OUT_CKP)
INT_HDMICLK-_C: CN12.12(CLK-) D61.5(LINE-4) D61.6(NC#1) L19.3
INT_HDMICLK-_IC: C151.2 U26.10(IN_CKN)
INT_HDMICLK-_LS: L19.4 U26.18(OUT_CKN)
INT_HDMITX0N_C: CN12.3(D2-) D61.2(LINE-2) D61.9(NC#3) L18.3
INT_HDMITX0N_IC: C982.2 U26.7(IN_D0N)
INT_HDMITX0N_LS: L18.4 U26.21(OUT_D0N)
INT_HDMITX0P_C: CN12.1(D2+) D61.1(LINE-1) D61.10(NC#4) L18.2
INT_HDMITX0P_IC: C981.2 U26.6(IN_D0P)
INT_HDMITX0P_LS: L18.1 U26.22(OUT_D0P)
INT_HDMITX1N_C: CN12.6(D1-) D60.5(LINE-4) D60.6(NC#1) L17.3
INT_HDMITX1N_IC: C141.2 U26.5(IN_D1N)
INT_HDMITX1N_LS: L17.4 U26.23(OUT_D1N)
INT_HDMITX1P_C: CN12.4(D1+) D60.4(LINE-3) D60.7(NC#2) L17.2
INT_HDMITX1P_IC: C139.2 U26.4(IN_D1P)
INT_HDMITX1P_LS: L17.1 U26.24(OUT_D1P)
INT_HDMITX2N_C: CN12.9(D0-) D60.2(LINE-2) D60.9(NC#3) L16.3
INT_HDMITX2N_IC: C984.2 U26.2(IN_D2N)
INT_HDMITX2N_LS: L16.4 U26.26(OUT_D2N)
INT_HDMITX2P_C: CN12.7(D0+) D60.1(LINE-1) D60.10(NC#4) L16.2
INT_HDMITX2P_IC: C129.2 U26.1(IN_D2P)
INT_HDMITX2P_LS: L16.1 U26.27(OUT_D2P)
ISEN1_B: PC1328.1 PR10.1 PR93.2 PR95.2 PU5.9(ISEN1_B)
ISEN2_B: PC1327.1 PR11.1 PR94.2 PR96.2 PU5.10(ISEN2_B)
ISL_ACIN_SNS: PC1298.1 PR176.2 PR179.1 PU4.19(ACIN)
ISL_ACOK: PR47.2 PU4.24(ACOK)
ISL_BAT_SRN: PC1258.2 PC1259.1 PR126.1 PU4.1(CSON)
ISL_BAT_SRP: PC1258.1 PC1260.1 PR127.1 PU4.2(CSOP)
ISL_BDET: PR22.2 PR92.1 PU4.25(BATGONE)
ISL_BGDRV: PC9122.2 PQ1.4(G) PU4.32(BGATE)
ISL_BOOST_BOOT: PC1261.2 PU4.4(BOOT2)
ISL_BOOST_LG: PQ2.5(BG) PU4.7(LGATE2)
ISL_BOOST_PHASE: PC1261.1 PQ2.4(TGR) PU4.6(PHASE2)
ISL_BOOST_UG: PQ2.3(G1) PU4.5(UGATE2)
ISL_BUCK_BOOT: PC1262.2 PU4.12(BOOT1)
ISL_BUCK_LG: PQ3.5(BG) PU4.9(LGATE1)
ISL_BUCK_PHASE: PC1262.1 PQ3.4(TGR) PU4.10(PHASE1)
ISL_BUCK_UG: PQ3.3(G1) PU4.11(UGATE1)
ISL_COMP: PC9094.2 PR133.2 PU4.28(COMP)
ISL_CSIN: PC1263.2 PC1283.2 PR124.1 PU4.14(CSIN)
ISL_CSIP: PC1263.1 PC1284.2 PR125.1 PU4.15(CSIP)
ISL_DCIN: PC1189.1 PR128.1 PU4.17(DCIN)
ISL_HOT*: PR46.2 PU4.23(PROCHOT#)
ISL_OTGEN: PR110.2 PU4.20(OTGEN/CMIN)
ISL_PGM: PR178.2 PU4.27(PROG)
ISL_PSYS: PR43.2 PU4.30(PSYS)
ITCH_SPI_CLK: TP137.1 U80.M2(GPP_D_1_SPI1_CLK)
ITCH_SPI_CS*: TP142.1 U80.M1(GPP_D_0_SPI1_CSB)
ITCH_SPI_IO2: TP140.1 U80.V1(GPP_D_21_SPI1_IO_2)
ITCH_SPI_IO3: TP141.1 U80.V2(GPP_D_22_SPI1_IO_3)
ITCH_SPI_MISO: TP138.1 U80.M3(GPP_D_2_SPI1_MISO_IO_1)
ITCH_SPI_MOSI: TP139.1 U80.J4(GPP_D_3_SPI1_MOSI_IO_0)
JACK_PLUG_DETECT_L: D50.1 J1C1.6 R1D7.2
KB_COL2_SW: CRCP4011.4(D2+) CRCP4011.7(NC#2) JCP4056.17 R5068.2
KB_COL[0]: CRCP4010.4(D2+) CRCP4010.7(NC#2) EUPM3247.B16(KSI0/GPIO125/TRACEDATA3) JCP4056.13
KB_COL[1]: CRCP4043.5(D2-) CRCP4043.6(NC#1) EUPM3247.A15(KSI1/GPIO126/TRACEDATA2) JCP4056.24
KB_COL[2]: EUPM3247.B15(KSI2/GPIO144/TRACEDATA1) R5063.2
KB_COL[3]: CRCP4011.5(D2-) CRCP4011.6(NC#1) EUPM3247.A14(KSI3/GPIO032/TRACEDATA0) JCP4056.16
KB_COL[4]: CRCP4014.5(D2-) CRCP4014.6(NC#1) EUPM3247.B14(KSI4/GPIO142/TRACECLK) JCP4056.20
KB_COL[5]: CRCP4011.1(D1+) CRCP4011.10(NC#4) EUPM3247.B13(KSI5/GPIO040) JCP4056.19
KB_COL[6]: CRCP4014.2(D1-) CRCP4014.9(NC#3) EUPM3247.A13(KSI6/GPIO042) JCP4056.22
KB_COL[7]: CRCP4014.1(D1+) CRCP4014.10(NC#4) EUPM3247.A12(KSI7/GPIO043) JCP4056.23
KB_ROW2_SW: CRCP4010.5(D2-) CRCP4010.6(NC#1) JCP4056.12 R5072.1
KB_ROW[0]: CRCP4011.2(D1-) CRCP4011.9(NC#3) EUPM3247.B12(KSO00/GPIO000/JTAG_TCK) JCP4056.18
KB_ROW[1]: CRCP4010.2(D1-) CRCP4010.9(NC#3) EUPM3247.A11(KSO01/GPIO100/JTAG_TMS) JCP4056.14
KB_ROW[2]: EUPM3247.B11(KSO02/GPIO101/JTAG_TDI) R5066.2
KB_ROW[3]: CRCP4009.1(D1+) CRCP4009.10(NC#4) EUPM3247.A10(KSO03/GPIO102/JTAG_TDO) JCP4056.11
KB_ROW[4]: CRCP4010.1(D1+) CRCP4010.10(NC#4) EUPM3247.B10(KSO04/GPIO103/TFDP_DATA/XNOR) JCP4056.15
KB_ROW[5]: CRCP4009.4(D2+) CRCP4009.7(NC#2) EUPM3247.A9(KSO05/GPIO104/TFDP_CLK) JCP4056.8
KB_ROW[6]: CRCP4009.2(D1-) CRCP4009.9(NC#3) EUPM3247.A6(KSO06/GPIO001) JCP4056.9
KB_ROW[7]: CRCP4014.4(D2+) CRCP4014.7(NC#2) EUPM3247.B6(KSO07/GPIO002) JCP4056.21
KB_ROW[8]: CRCP4008.4(D2+) CRCP4008.7(NC#2) EUPM3247.A4(KSO08/GPIO003) JCP4056.2
KB_ROW[9]: CRCP4008.2(D1-) CRCP4008.9(NC#3) EUPM3247.B5(KSO09/GPIO106) JCP4056.3
KB_ROW[10]: CRCP4009.5(D2-) CRCP4009.6(NC#1) EUPM3247.B4(KSO10/GPIO004) JCP4056.5
KB_ROW[11]: CRCP4008.1(D1+) CRCP4008.10(NC#4) EUPM3247.A3(KSO11/GPIO107) JCP4056.4
KB_ROW[12]: CRCP4008.5(D2-) CRCP4008.6(NC#1) EUPM3247.B3(KSO12/GPIO005) JCP4056.1
L_BKLT_EN: U80.R12(L_BKLTEN) U111.1(INB)
L_BRIGHTNESS: J8L1.27 R619.2 U80.R11(L_BKLTCTL)
L_VDD_EN: R739.2 U8.3(EN) U80.U13(L_VDDEN)
LCD_VCC: C72.1 F100.1 R956.1 U111.5(VCC)
LCD_VCC_OUT: C135.1 C136.1 C137.1 R956.2 U8.1(OUT)
LID_OPEN: C1027.2 C1106.1 CN17.44 D3.1(CATHODE) R5118.1
LID_OPEN_C: D3.2(ANODE) D51.1 EUPM3247.B34(GPIO027)
LIMVRL5: PR188.2 PU3254.N6(ILIMVR5LS)
LPC_CLKRUN*: EUPM3247.A28(CLKRUN#/GPIO014) RAP1001.2 U80.AW11(GPP_A_8_CLKRUNB)
LPC_FRAME*: EUPM3247.B28(LFRAME#/GPIO120) U80.BA12(GPP_A_5_LFRAMEB_ESPI_CSB)
LPC_LAD<0>: EUPM3247.B25(LAD0/GPIO112) U80.AY13(GPP_A_1_LAD_0_ESPI_IO_0)
LPC_LAD<1>: EUPM3247.B26(LAD1/GPIO114) U80.BA13(GPP_A_2_LAD_1_ESPI_IO_1)
LPC_LAD<2>: EUPM3247.B27(LAD2/GPIO113) U80.BB13(GPP_A_3_LAD_2_ESPI_IO_2)
LPC_LAD<3>: EUPM3247.A26(LAD3/GPIO111) U80.AY12(GPP_A_4_LAD_3_ESPI_IO_3)
LPC_SERIRQ: EUPM3247.A29(SER_IRQ/GPIO115) R894.2 U80.AY11(GPP_A_6_SERIRQ)
M_A_CA_A<0>: U80.BA51(DDR0_MA_5_CAA0) USM2000.R2(CA0)
M_A_CA_A<1>: U80.BB54(DDR0_MA_9_CAA1) USM2000.P2(CA1)
M_A_CA_A<2>: U80.BA52(DDR0_MA_6_CAA2) USM2000.N2(CA2)
M_A_CA_A<3>: U80.AY52(DDR0_MA_8_CAA3) USM2000.N3(CA3)
M_A_CA_A<4>: U80.AW52(DDR0_MA_7_CAA4) USM2000.M3(CA4)
M_A_CA_A<5>: U80.AY55(DDR0_BA_2_CAA5_BG0) USM2000.F3(CA5)
M_A_CA_A<6>: U80.AW54(DDR0_MA_12_CAA6) USM2000.E3(CA6)
M_A_CA_A<7>: U80.BA54(DDR0_MA_11_CAA7) USM2000.E2(CA7)
M_A_CA_A<8>: U80.BA55(DDR0_MA_15_CAA8_ACT_N) USM2000.D2(CA8)
M_A_CA_A<9>: U80.AY54(DDR0_MA_14_CAA9_BG1) USM2000.C2(CA9)
M_A_CA_B<0>: U80.AU46(DDR0_MA_13_CAB0) USM2001.R2(CA0)
M_A_CA_B<1>: U80.AU48(DDR0_CAS_N_CAB1_MA15) USM2001.P2(CA1)
M_A_CA_B<2>: U80.AT46(DDR0_WE_N_CAB2_MA14) USM2001.N2(CA2)
M_A_CA_B<3>: U80.AU50(DDR0_RAS_N_CAB3_MA16) USM2001.N3(CA3)
M_A_CA_B<4>: U80.AU52(DDR0_BA_0_CAB4) USM2001.M3(CA4)
M_A_CA_B<5>: U80.AY51(DDR0_MA_2_CAB5) USM2001.F3(CA5)
M_A_CA_B<6>: U80.AT48(DDR0_BA_1_CAB6) USM2001.E3(CA6)
M_A_CA_B<7>: U80.AT50(DDR0_MA_10_CAB7) USM2001.E2(CA7)
M_A_CA_B<8>: U80.BB50(DDR0_MA_1_CAB8) USM2001.D2(CA8)
M_A_CA_B<9>: U80.AY50(DDR0_MA_0_CAB9) USM2001.C2(CA9)
M_A_CKE<0>: U80.BA56(DDR0_CKE_0) USM2000.K3(CKE0)
M_A_CKE<1>: U80.BB56(DDR0_CKE_1) USM2000.K4(CKE1/NC)
M_A_CKE<2>: U80.AW56(DDR0_CKE_2) USM2001.K3(CKE0)
M_A_CKE<3>: U80.AY56(DDR0_CKE_3) USM2001.K4(CKE1/NC)
M_A_CLK_DDR_DN*<0>: U80.AU53(DDR0_CLK_N_0) USM2000.J2(CK_C)
M_A_CLK_DDR_DN*<1>: U80.AU55(DDR0_CLK_N_1) USM2001.J2(CK_C)
M_A_CLK_DDR_DP<0>: U80.AT53(DDR0_CLK_P_0) USM2000.J3(CK_T)
M_A_CLK_DDR_DP<1>: U80.AT55(DDR0_CLK_P_1) USM2001.J3(CK_T)
M_A_CS*<0>: U80.AU45(DDR0_CS_N_0) USM2000.L3(CS0_N) USM2001.L3(CS0_N)
M_A_CS*<1>: U80.AU43(DDR0_CS_N_1) USM2000.L4(CS1_N/NC) USM2001.L4(CS1_N/NC)
M_A_DQ<0>: U80.AL71(DDRDQ_IL00_NIL00_0) USM2000.N10(DQ2)
M_A_DQ<1>: U80.AL68(DDRDQ_IL00_NIL00_1) USM2000.M10(DQ6)
M_A_DQ<2>: U80.AN68(DDRDQ_IL00_NIL00_2) USM2000.M9(DQ5)
M_A_DQ<3>: U80.AN69(DDRDQ_IL00_NIL00_3) USM2000.M11(DQ7)
M_A_DQ<4>: U80.AL70(DDRDQ_IL00_NIL00_4) USM2000.N11(DQ3)
M_A_DQ<5>: U80.AL69(DDRDQ_IL00_NIL00_5) USM2000.M8(DQ4)
M_A_DQ<6>: U80.AN70(DDRDQ_IL00_NIL00_6) USM2000.N9(DQ1)
M_A_DQ<7>: U80.AN71(DDRDQ_IL00_NIL00_7) USM2000.P9(DQ0)
M_A_DQ<8>: U80.AR70(DDRDQ_IL01_NIL01_0) USM2000.E11(DQ12)
M_A_DQ<9>: U80.AR68(DDRDQ_IL01_NIL01_1) USM2000.F11(DQ8)
M_A_DQ<10>: U80.AU71(DDRDQ_IL01_NIL01_2) USM2000.F8(DQ11)
M_A_DQ<11>: U80.AU68(DDRDQ_IL01_NIL01_3) USM2000.F9(DQ10)
M_A_DQ<12>: U80.AR71(DDRDQ_IL01_NIL01_4) USM2000.D9(DQ15)
M_A_DQ<13>: U80.AR69(DDRDQ_IL01_NIL01_5) USM2000.E9(DQ14)
M_A_DQ<14>: U80.AU70(DDRDQ_IL01_NIL01_6) USM2000.E10(DQ13)
M_A_DQ<15>: U80.AU69(DDRDQ_IL01_NIL01_7) USM2000.F10(DQ9)
M_A_DQ<16>: U80.AF65(DDRDQ_IL10_NIL02_0) USM2000.C11(DQ24)
M_A_DQ<17>: U80.AF64(DDRDQ_IL10_NIL02_1) USM2000.B10(DQ29)
M_A_DQ<18>: U80.AK65(DDRDQ_IL10_NIL02_2) USM2000.B8(DQ31)
M_A_DQ<19>: U80.AK64(DDRDQ_IL10_NIL02_3) USM2000.C8(DQ27)
M_A_DQ<20>: U80.AF66(DDRDQ_IL10_NIL02_4) USM2000.B11(DQ28)
M_A_DQ<21>: U80.AF67(DDRDQ_IL10_NIL02_5) USM2000.C10(DQ25)
M_A_DQ<22>: U80.AK67(DDRDQ_IL10_NIL02_6) USM2000.B9(DQ30)
M_A_DQ<23>: U80.AK66(DDRDQ_IL10_NIL02_7) USM2000.C9(DQ26)
M_A_DQ<24>: U80.AF70(DDRDQ_IL11_NIL03_0) USM2000.R9(DQ21)
M_A_DQ<25>: U80.AF68(DDRDQ_IL11_NIL03_1) USM2000.R8(DQ20)
M_A_DQ<26>: U80.AH71(DDRDQ_IL11_NIL03_2) USM2000.T11(DQ19)
M_A_DQ<27>: U80.AH68(DDRDQ_IL11_NIL03_3) USM2000.T10(DQ18)
M_A_DQ<28>: U80.AF71(DDRDQ_IL11_NIL03_4) USM2000.T8(DQ16)
M_A_DQ<29>: U80.AF69(DDRDQ_IL11_NIL03_5) USM2000.T9(DQ17)
M_A_DQ<30>: U80.AH70(DDRDQ_IL11_NIL03_6) USM2000.R11(DQ23)
M_A_DQ<31>: U80.AH69(DDRDQ_IL11_NIL03_7) USM2000.R10(DQ22)
M_A_DQ<32>: U80.BB65(DDRDQ_IL02_NIL04_0) USM2001.T9(DQ17)
M_A_DQ<33>: U80.AW65(DDRDQ_IL02_NIL04_1) USM2001.R8(DQ20)
M_A_DQ<34>: U80.AW63(DDRDQ_IL02_NIL04_2) USM2001.R11(DQ23)
M_A_DQ<35>: U80.AY63(DDRDQ_IL02_NIL04_3) USM2001.T10(DQ18)
M_A_DQ<36>: U80.BA65(DDRDQ_IL02_NIL04_4) USM2001.T8(DQ16)
M_A_DQ<37>: U80.AY65(DDRDQ_IL02_NIL04_5) USM2001.R9(DQ21)
M_A_DQ<38>: U80.BA63(DDRDQ_IL02_NIL04_6) USM2001.R10(DQ22)
M_A_DQ<39>: U80.BB63(DDRDQ_IL02_NIL04_7) USM2001.T11(DQ19)
M_A_DQ<40>: U80.BA61(DDRDQ_IL03_NIL05_0) USM2001.F11(DQ8)
M_A_DQ<41>: U80.AW61(DDRDQ_IL03_NIL05_1) USM2001.F10(DQ9)
M_A_DQ<42>: U80.BB59(DDRDQ_IL03_NIL05_2) USM2001.E9(DQ14)
M_A_DQ<43>: U80.AW59(DDRDQ_IL03_NIL05_3) USM2001.D9(DQ15)
M_A_DQ<44>: U80.BB61(DDRDQ_IL03_NIL05_4) USM2001.E11(DQ12)
M_A_DQ<45>: U80.AY61(DDRDQ_IL03_NIL05_5) USM2001.E10(DQ13)
M_A_DQ<46>: U80.BA59(DDRDQ_IL03_NIL05_6) USM2001.F8(DQ11)
M_A_DQ<47>: U80.AY59(DDRDQ_IL03_NIL05_7) USM2001.F9(DQ10)
M_A_DQ<48>: U80.AT66(DDRDQ_IL12_NIL06_0) USM2001.P9(DQ0)
M_A_DQ<49>: U80.AU66(DDRDQ_IL12_NIL06_1) USM2001.M9(DQ5)
M_A_DQ<50>: U80.AP65(DDRDQ_IL12_NIL06_2) USM2001.N11(DQ3)
M_A_DQ<51>: U80.AN65(DDRDQ_IL12_NIL06_3) USM2001.M11(DQ7)
M_A_DQ<52>: U80.AN66(DDRDQ_IL12_NIL06_4) USM2001.M8(DQ4)
M_A_DQ<53>: U80.AP66(DDRDQ_IL12_NIL06_5) USM2001.N9(DQ1)
M_A_DQ<54>: U80.AT65(DDRDQ_IL12_NIL06_6) USM2001.M10(DQ6)
M_A_DQ<55>: U80.AU65(DDRDQ_IL12_NIL06_7) USM2001.N10(DQ2)
M_A_DQ<56>: U80.AT61(DDRDQ_IL13_NIL07_0) USM2001.C9(DQ26)
M_A_DQ<57>: U80.AU61(DDRDQ_IL13_NIL07_1) USM2001.C10(DQ25)
M_A_DQ<58>: U80.AP60(DDRDQ_IL13_NIL07_2) USM2001.B10(DQ29)
M_A_DQ<59>: U80.AN60(DDRDQ_IL13_NIL07_3) USM2001.B9(DQ30)
M_A_DQ<60>: U80.AN61(DDRDQ_IL13_NIL07_4) USM2001.B8(DQ31)
M_A_DQ<61>: U80.AP61(DDRDQ_IL13_NIL07_5) USM2001.C8(DQ27)
M_A_DQ<62>: U80.AT60(DDRDQ_IL13_NIL07_6) USM2001.B11(DQ28)
M_A_DQ<63>: U80.AU60(DDRDQ_IL13_NIL07_7) USM2001.C11(DQ24)
M_A_DQS_DN*<0>: U80.AM70(DDRDQSN_IL00_NIL00) USM2000.L11(DQS0_C)
M_A_DQS_DN*<1>: U80.AT69(DDRDQSN_IL01_NIL01) USM2000.G11(DQS1_C)
M_A_DQS_DN*<2>: U80.AH66(DDRDQSN_IL10_NIL02) USM2000.D11(DQS3_C)
M_A_DQS_DN*<3>: U80.AG69(DDRDQSN_IL11_NIL03) USM2000.P11(DQS2_C)
M_A_DQS_DN*<4>: U80.BA64(DDRDQSN_IL02_NIL04) USM2001.P11(DQS2_C)
M_A_DQS_DN*<5>: U80.AY60(DDRDQSN_IL03_NIL05) USM2001.G11(DQS1_C)
M_A_DQS_DN*<6>: U80.AR66(DDRDQSN_IL12_NIL06) USM2001.L11(DQS0_C)
M_A_DQS_DN*<7>: U80.AR61(DDRDQSN_IL13_NIL07) USM2001.D11(DQS3_C)
M_A_DQS_DP<0>: U80.AM69(DDRDQSP_IL00_NIL00) USM2000.L10(DQS0_T)
M_A_DQS_DP<1>: U80.AT70(DDRDQSP_IL01_NIL01) USM2000.G10(DQS1_T)
M_A_DQS_DP<2>: U80.AH65(DDRDQSP_IL10_NIL02) USM2000.D10(DQS3_T)
