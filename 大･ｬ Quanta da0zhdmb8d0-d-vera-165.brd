# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQS_DN*<7>: length 27.5
  IN2 w0.076: v3(138.64,64.36) 138.64,64.27 138.36,63.99 138.2,63.99 138.11,64.07 138.11,64.42 138.26,64.57 138.26,65.77 138.27,65.79 138.27,65.93 138.24,65.97 138.24,65.99 138.23,66
  IN2 w0.102: 138.23,66 138.13,66.09 138.13,66.85 139.32,68.04 139.32,69.97 142.26,72.9 143.43,72.9 147.48,76.96 147.48,78.41 147.57,78.5 147.78,78.5 147.89,78.39 147.89,78.01 148.11,77.79 148.51,77.79 148.99,78.27 148.99,79.46 148.77,79.68 148.32,79.68 148.22,79.78 148.22,80.3 148.68,80.76 148.68,81.56 v3(148.86,81.74)
  BOTTOM w0.076: U80.AR61 138.28,63.99 v3(138.64,64.36)
  BOTTOM w0.147: USM2001.D11 148.86,81.92 v3(148.86,81.74)
M_A_DQS_DP<0>: length 40.2
  IN2 w0.102: v3(168.4,68.01) 168.4,67.7 168.5,67.6 168.78,67.6 169.12,67.93 169.93,67.93 170.31,67.55 170.31,65.77 170,65.45 165.05,65.45 159.87,60.27 148.43,60.27 146.57,62.13 146.23,62.13 v3(146.09,61.99)
  BOTTOM w0.076: U80.AM69 142.55,62.15 142.7,62 142.7,62 142.86,61.84 142.88,61.84 143,61.84 143.01,61.82 143.33,61.82 143.35,61.84 143.65,61.84 143.66,61.82 143.98,61.82 144,61.84 144.31,61.84 144.53,61.62 145.55,61.62 145.92,61.99 v3(146.09,61.99) ; USM2000.L10 169.88,71.37 169.55,71.04 169.55,70.65 169.48,70.57 169.48,69.5 169.11,69.13 169.11,68.59 169.05,68.53
  BOTTOM w0.147: v3(168.4,68.01) 168.88,68.01 169.05,68.17 169.05,68.53
M_A_DQS_DP<1>: length 33.6
  IN2 w0.102: v3(166.3,71.31) 166.3,70.9 166.41,70.79 166.57,70.79 166.76,70.97 166.76,72.96 165.86,73.86 160.98,73.86 159.67,72.56 159.67,71.07 158.84,70.24 153.38,70.24 150.46,67.33 150.46,66.21 149.59,65.33 147.6,65.33 147.52,65.4 v3(147.1,65.4)
  BOTTOM w0.076: v3(147.1,65.4) 146.76,65.4 146.36,65.01 144.8,65.01 144.61,64.82 144.01,64.82 143.97,64.86 143.67,64.86 143.66,64.85 143.61,64.85 143.54,64.78 143.35,64.78 143.17,64.6 U80.AT70
  BOTTOM w0.147: v3(166.3,71.31) 166.89,71.31 USM2000.G10
M_A_DQS_DP<2>: length 33.6
  IN1 w0.102: v3(139.93,60.61) 140.5,61.18 141.33,61.18 141.35,61.2 141.91,61.2 142.16,61.45 146.56,61.45 147.04,61.93 155.55,61.93 160.66,67.03 160.66,71.4 161.14,71.88 162.34,71.88 162.6,71.63 163.28,71.63 163.57,71.34 164.66,71.34 164.98,71.34 v3(164.99,71.33)
  BOTTOM w0.076: v3(139.93,60.61) U80.AH65
  BOTTOM w0.147: v3(164.99,71.33) 164.99,71.37 USM2000.D10
M_A_DQS_DP<3>: length 49.3
  BOTTOM w0.076: 174.38,71.24 174.2,71.42 172.12,71.42 USM2000.P10 ; 145.05,59.78 145,59.83 144.78,59.83 144.78,59.83 144.05,59.83 144.04,59.84 143.98,59.84 143.97,59.85 143.67,59.85 143.58,59.76 143.34,59.76 U80.AG70
  BOTTOM w0.147: 145.05,59.78 145.1,59.78 145.43,59.45 145.43,59.36 146.04,58.74 151.21,58.74 151.69,59.22 156.39,59.22 159.68,62.51 160.34,62.51 160.49,62.36 160.49,61.92 160.81,61.6 161.34,61.6 161.65,61.92 161.65,62.36 161.8,62.51 162.1,62.51 162.24,62.36 162.24,61.92 162.56,61.6 163.09,61.6 163.41,61.92 163.41,62.36 163.55,62.51 163.85,62.51 164,62.36 164,61.92 164.31,61.6 164.84,61.6 165.16,61.92 165.16,62.36 165.31,62.51 165.6,62.51 165.75,62.36 165.75,61.92 166.06,61.6 166.6,61.6 166.91,61.92 166.91,62.36 167.06,62.51 167.35,62.51 167.5,62.36 167.5,61.92 167.82,61.6 168.35,61.6 168.67,61.92 168.67,62.36 168.81,62.51 170.39,62.51 174.96,67.07 174.96,70.67 174.79,70.84 174.79,70.84 174.38,71.24
M_A_DQS_DP<4>: length 35.7
  BOTTOM w0.076: 144.36,70.49 144.35,70.48 144.3,70.48 144.26,70.44 144.14,70.44 144.02,70.33 141.59,70.33 140.29,69.02 140.29,68.73 140.12,68.56 140.12,68.31 140.18,68.19 140.18,67.98 140.12,67.87 140.12,67.66 140.16,67.58 140.16,67.29 140.07,67.1 139.99,67.02 139.99,66.94 U80.AY64 ; 158.6,83.4 158.6,83.41 158.55,83.41 155.98,83.41 155.58,83 USM2001.P10
  BOTTOM w0.147: 144.36,70.49 145.15,71.28 148.93,71.28 152.28,74.63 154.94,74.63 156.17,75.85 156.17,76.25 156.41,76.49 156.81,76.49 157.14,76.83 157.14,77.38 157.29,77.53 157.84,77.53 158.23,77.91 158.23,78.31 158.48,78.56 158.96,78.56 159.53,79.12 159.53,79.79 159.16,80.15 159.14,80.15 159.01,80.28 159.01,80.52 159.62,81.12 159.62,81.86 159.45,82.03 159.45,82.39 159.65,82.59 159.65,83.07 159.3,83.42 158.63,83.42 158.62,83.4 158.6,83.4
M_A_DQS_DP<5>: length 26.7
  IN1 w0.102: v3(147.68,79.15) 147.77,79.24 151.86,79.24 152.12,79.5 v3(152.33,79.5)
  BOTTOM w0.076: v3(152.33,79.5) 152.33,79.66 151.91,80.08 151.91,80.46 152.11,80.66 152.11,81.22 152.09,81.24 152.09,81.44 152.1,81.46 152.1,81.59 151.87,81.82 151.55,81.82 151.36,82.02 151.36,82.62 USM2001.G10 ; 141.29,72.97 141.25,72.97 141.1,72.82 140.8,72.82 139.01,71.04 138.94,71.04 136.97,69.06 136.97,68.82 137.14,68.65 137.14,68.45 137.14,68.29 137.08,68.14 137.08,68.03 137.13,67.9 137.13,67.6 137.09,67.52 137.09,67.32 137.16,67.19 137.26,67.09 137.34,67.09 137.38,67.13 137.38,67.23 U80.BA60
  BOTTOM w0.147: 141.29,72.97 141.36,72.97 145.2,76.81 145.61,77.22 145.61,77.37 147.39,79.15 v3(147.68,79.15)
M_A_DQS_DP<6>: length 38
  IN1 w0.102: v3(140.46,64.39) 140.17,64.68 140.06,64.8 140.06,66.04 140.3,66.29 140.3,66.7 140.06,66.94 140.06,67.75 138.95,68.85 138.95,69.19 138.31,69.83 138.31,69.98 138.42,70.09 138.42,70.23 138.28,70.38 138.13,70.38 138.02,70.27 137.88,70.27 137.74,70.41 137.74,70.55 137.85,70.66 137.85,70.81 137.7,70.95 137.56,70.95 137.45,70.84 137.3,70.84 137.1,71.04 137.1,73.44 138.4,74.73 138.4,75.46 138.09,75.77 138.09,75.98 138.26,76.15 138.26,76.42 138.09,76.59 138.09,77.19 139.11,78.21 142.71,78.21 142.87,78.05 143.11,78.05 143.28,78.21 143.72,78.21 144.22,77.7 150.23,77.7 150.37,77.56 150.67,77.56 150.82,77.7 150.98,77.7 151.1,77.82 151.44,77.82 151.59,77.67 v3(151.59,77.64)
  IN2 w0.076: v3(153.95,82.61) 153.6,82.26 153.6,81.52
  IN2 w0.102: 153.6,81.52 153.7,81.41 153.7,79.93 152.01,78.24 152.01,77.74 151.91,77.64 v3(151.59,77.64)
  BOTTOM w0.076: U80.AR65 140.11,63.99 140.46,64.35 v3(140.46,64.39)
  BOTTOM w0.147: v3(153.95,82.61) 153.95,82.62 USM2001.L10
M_A_DQS_DP<7>: length 27.4
  IN2 w0.076: 138.09,65.86 138.09,64.72 v3(137.73,64.36)
  IN2 w0.102: 138.09,65.86 137.93,66.02 137.93,66.08 137.94,66.09 137.94,66.93 139.12,68.1 139.12,70.05 142.17,73.11 143.34,73.11 147.28,77.05 147.28,78.5 147.49,78.71 147.86,78.71 148.09,78.48 148.09,78.09 148.2,77.99 148.42,77.99 148.79,78.36 148.79,79.38 148.69,79.48 148.24,79.48 148.02,79.7 148.02,80.39 148.48,80.85 148.48,81.95 148.76,82.24 v3(148.76,82.61)
  BOTTOM w0.076: U80.AR60 137.36,63.99 v3(137.73,64.36)
  BOTTOM w0.147: v3(148.76,82.61) 148.76,82.62 USM2001.D10
M_A_ODT<0>: length 83.1
  IN1 w0.076: v3(129.5,64.99) 129.9,64.59 129.9,62.39 130.27,62.01 133.33,62.01 133.52,62.2 133.52,66.01
  IN1 w0.097: v3(161.62,82.57) 161.3,82.57 161.19,82.68 160.86,82.68 157.38,79.2 153.88,79.2 152.62,80.46 152.62,80.46 152.52,80.56 152.2,80.56 152.16,80.51 150.94,80.51 150.82,80.39 150.39,80.39 150.27,80.52 149.49,80.52 149.38,80.62 148.36,80.62 148.02,80.28 146.53,80.28 145.95,79.7 138.73,79.7 136.92,77.9 136.92,75.02 135.87,73.97 135.87,68.37 133.52,66.01
  IN2 w0.097: v3(152.65,84.21) 152.65,85.07 152.94,85.35 160.14,85.35 160.59,84.9 160.59,83.2 160.7,83.09 160.87,83.09 160.98,83.2 160.98,83.88 161.09,84 161.27,84 161.38,83.88 161.38,82.8 v3(161.62,82.57) 163.54,80.65 168.44,80.65 168.92,80.18 168.92,79.1 168.38,78.56 168.38,73.51 168.88,73 v3(168.88,72.96)
  BOTTOM w0.076: U80.AT45 v3(129.5,64.99)
  BOTTOM w0.132: USM2000.J8 168.88,73.01 v3(168.88,72.96) ; v3(152.65,84.21) 152.65,84.22 USM2001.J8
M_B_CA_A<0>: length 53.3
  IN1 w0.097: v3(134.37,76.91) 134.37,78.86 138.9,83.39 138.9,94.06 139.01,94.18 139.29,94.18 139.4,94.06 139.4,88.3 139.52,88.18 139.95,88.18 140.07,88.3 140.07,94.67 139.95,94.79 v3(136.57,94.79)
  BOTTOM w0.076: U80.AY48 130.42,67.31 130.42,67.47 130.35,67.66 130.35,67.87 130.39,67.95 130.39,68.2 130.39,68.22 130.35,68.31 130.35,68.56 130.48,68.69 130.48,69.34 130.58,69.44 130.58,69.83 130.69,69.95 130.69,70.42 131.97,71.7 131.97,73.54
  BOTTOM w0.132: v3(136.57,94.79) v1(136.57,94.13) 136.57,93.29 135.13,91.86 133.82,91.86 133.67,91.7 USM2002.R2 ; 131.97,73.54 132.16,73.73 132.16,75.39 133.68,76.91 v3(134.37,76.91)
M_B_CA_A<1>: length 51.4
  IN2 w0.076: v3(132.24,63.72) 131.86,64.1 131.86,65.96 132.3,66.4
  IN2 w0.097: v3(134.41,93.06) 135.46,93.06 135.56,93.15 135.56,93.23 135.65,93.33 135.85,93.33 135.94,93.23 135.94,93.15 136.04,93.06 136.23,93.06 136.33,93.15 136.33,93.23 136.42,93.33 136.62,93.33 136.71,93.23 136.71,93.15 136.81,93.06 137,93.06 137.1,93.15 137.1,93.23 137.2,93.33 137.39,93.33 137.49,93.23 137.49,93.15 137.58,93.06 137.82,93.06 139.9,90.98 139.9,80.21 137.32,77.63 137.32,75.4 135.33,73.41 135.33,71.37 133.99,70.02 133.99,68.45 132.3,66.76 132.3,66.4
  BOTTOM w0.076: U80.AP50 v3(132.24,63.72)
  BOTTOM w0.132: v3(134.41,93.06) 134.98,93.63 134.98,95.12 135.14,95.27 v1(135.42,95.27) 136.91,95.27 137.06,95.43 137.06,95.64 136.91,95.8 134.74,95.8 134.46,95.52 134.46,93.75 134.29,93.58 133.21,93.58 133.02,93.39 USM2002.P2
M_B_CA_A<2>: length 51.7
  IN1 w0.097: v3(133.76,75.8) 133.54,76.02 133.54,78.86 137.02,82.34 137.02,92.18 136.79,92.41 135.08,92.41 134.95,92.53 134.95,92.78 135.08,92.91 136.9,92.91 137.02,93.03 137.02,93.39 136.9,93.5 130.95,93.5 130.82,93.63 130.82,93.84 130.95,93.97 132.18,93.97 132.31,94.1 132.31,94.59 132.44,94.72 132.74,94.72 132.87,94.59 132.87,94.1 133,93.97 135.03,93.97 135.16,94.1 135.16,95.1 135.03,95.22 v1(133.73,95.22)
  BOTTOM w0.076: 132.47,73.03 132.47,71.64 131.02,70.2 131.02,69.81 130.91,69.7 130.91,69.3 130.81,69.2 130.81,68.66 130.89,68.57 130.89,68.25 130.62,67.99 U80.BA48
  BOTTOM w0.132: USM2002.N2 132.37,91.91 132.65,92.19 132.65,93.84 132.85,94.04 133.4,94.04 v1(133.73,94.37) v1(133.73,95.22) ; v3(133.76,75.8) 133.53,75.8 132.87,75.14 132.87,73.44 132.47,73.03
M_B_CA_A<3>: length 52.1
  IN1 w0.097: v3(135.81,94.81) 135.81,94.42 135.9,94.33 138.28,94.33 138.38,94.24 138.38,94.01 138.29,93.92 137.64,93.92 137.56,93.84 137.56,93.58 137.67,93.47 138.23,93.47 138.35,93.35 138.35,93.13 138.23,93.01 137.67,93.01 137.56,92.9 137.56,92.67 137.67,92.55 138.23,92.55 138.35,92.44 138.35,92.21 138.23,92.1 137.67,92.1 137.56,91.98 137.56,91.75 137.67,91.64 138.23,91.64 138.35,91.52 138.35,91.3 138.23,91.18 137.67,91.18 137.56,91.07 137.56,90.84 137.67,90.72 138.23,90.72 138.35,90.61 138.35,90.38 138.23,90.27 137.67,90.27 137.56,90.15 137.56,89.92 137.67,89.81 138.23,89.81 138.35,89.7 138.35,89.47 138.23,89.35 137.67,89.35 137.56,89.24 137.56,89.01 137.67,88.9 138.23,88.9 138.35,88.78 138.35,88.55 138.23,88.44 137.67,88.44 137.56,88.32 137.56,88.1 137.67,87.98 138.23,87.98 138.35,87.87 138.35,87.64 138.23,87.52 137.67,87.52 137.56,87.41 137.56,87.18 137.67,87.07 138.23,87.07 138.35,86.95 138.35,86.72 138.23,86.61 137.67,86.61 137.56,86.5 137.56,85.95 137.67,85.84 138.19,85.84 138.31,85.72 138.31,85.49 138.19,85.38 137.67,85.38 137.56,85.27 137.56,85.04 137.67,84.92 138.19,84.92 138.31,84.81 138.31,84.58 138.19,84.47 137.67,84.47 137.56,84.35 137.56,82.48 133.96,78.88 v3(133.96,76.41)
  BOTTOM w0.076: U80.BB48 130.62,68.6 130.64,68.62 130.64,69.27 130.74,69.37 130.74,69.77 130.85,69.88 130.85,70.31 132.22,71.68 132.22,73.32
  BOTTOM w0.132: v3(135.81,94.81) 135.42,94.42 135.42,93.06 134.97,92.61 133.71,92.61 133.35,92.26 133.35,91.26 133.13,91.03 132.71,91.03 USM2002.N3 ; v3(133.96,76.41) 133.68,76.41 132.54,75.27 132.54,73.63 132.22,73.32
M_B_CA_A<4>: length 53.6
  IN2 w0.076: 131.67,66.6 130.95,65.88 130.95,64.09 v3(131.32,63.72)
  IN2 w0.097: 131.67,66.6 131.67,67.03 133.29,68.65 133.29,70.44 134.19,71.33 134.19,72.29 134.72,72.82 134.72,73.67 136.75,75.7 136.75,77.88 139.33,80.47 139.33,90.4 137.37,92.37 132.61,92.37 v3(132.18,92.8)
  BOTTOM w0.076: U80.AP48 v3(131.32,63.72)
  BOTTOM w0.132: v3(132.18,92.8) 132.18,94.24 132.36,94.42 132.82,94.42 132.97,94.57 132.97,94.81 132.84,94.94 131.75,94.94 131.6,94.79 131.6,93.95 131.45,93.79 130.96,93.79 130.8,93.95 130.8,94.57 130.65,94.72 130.39,94.72 130.24,94.57 130.24,93.82 130.08,93.66 129.41,93.66 129.26,93.51 129.26,93.4 129.43,93.23 131.58,93.23 131.72,93.08 131.72,92.65 132.05,92.32 132.05,90.84 131.9,90.69 USM2002.M3
M_B_CA_A<5>: length 53.2
  IN2 w0.076: v3(133.15,63.72) 132.78,64.1 132.78,65.87 132.94,66.04
  IN2 w0.097: v3(127.43,93.68) 127.65,93.68 127.9,93.93 137.88,93.93 140.48,91.33 140.48,79.92 137.89,77.33 137.89,75.09 135.92,73.11 135.92,70.72 135.13,69.93 135.13,68.33 133.91,67.12 133.52,67.12 132.94,66.54 132.94,66.04
  BOTTOM w0.076: v3(133.15,63.72) 132.77,63.34 U80.AP52
  BOTTOM w0.132: USM2002.F3 127.5,91.01 127.5,91.77 127.9,92.17 127.9,92.17 128.02,92.3 128.05,92.3 128.17,92.42 128.17,94.52 127.93,94.77 127.7,94.77 v1(127.36,94.43) 126.79,93.85 126.79,93.64 126.97,93.46 127.2,93.46 v3(127.43,93.68)
M_B_CA_A<6>: length 53.3
  IN2 w0.076: 131.69,66.1 131.69,63.63 v3(132.24,63.09)
  IN2 w0.097: 131.69,66.1 131.98,66.38 131.98,66.9 133.68,68.6 133.68,70.25 135.04,71.6 135.04,73.54 137.03,75.54 137.03,77.75 139.62,80.34 139.62,90.8 137.69,92.72 134.89,92.72 134.83,92.66 134.15,92.66 133.94,92.86 133.94,93.17 133.83,93.28 133.69,93.28 133.61,93.2 133.61,92.81 133.49,92.69 133.34,92.69 133.27,92.77 133.27,93.16 133.16,93.28 132.99,93.28 132.91,93.2 132.91,93.01 132.82,92.92 132.69,92.92 132.61,93.01 132.61,93.11 132.49,93.22 130.27,93.22 130.15,93.11 130.15,92.85 130.06,92.76 129.85,92.76 129.73,92.88 129.73,93.18 129.59,93.32 129.3,93.32 129.15,93.18 129.15,92.93 129.04,92.82 127.2,92.82 127.1,92.72 127.1,92.11 127.2,92.01 127.59,92.01 127.68,91.92 127.68,91.79 127.59,91.7 127.24,91.7 127.22,91.72 126.88,91.72 126.79,91.62 126.79,91.49 126.88,91.4 127.63,91.4 127.72,91.3 127.72,91.06 127.63,90.97 126.9,90.97 v3(126.85,91.02)
  BOTTOM w0.076: U80.AN50 v3(132.24,63.09)
  BOTTOM w0.132: USM2002.E3 126.85,91.01 v3(126.85,91.02)
M_B_CA_A<7>: length 52.7
  IN2 w0.076: 130.79,65.97 130.79,62.22 130.61,62.04 130.34,62.04 130.28,61.98 130.28,61.77 130.35,61.71 131.76,61.71 131.84,61.78 131.84,61.96 131.7,62.09 131.7,63.01 131.63,63.09 v3(131.32,63.09)
  IN2 w0.097: v3(127.49,92.41) 127.51,92.39 128.5,92.39 128.61,92.29 128.61,91.42 128.71,91.32 128.85,91.32 128.95,91.42 128.95,92.29 129.05,92.39 130.26,92.39 130.37,92.28 131.79,92.28 132.03,92.05 137.26,92.05 139.04,90.27 139.04,80.6 136.46,78.01 136.46,75.84 134.42,73.8 134.42,72.95 133.85,72.38 133.85,71.54 132.87,70.57 132.87,68.66 131.29,67.08 131.05,67.08 130.78,66.81 130.78,66.43 130.7,66.36 130.4,66.36 130.33,66.28 130.33,66.13 130.4,66.05 130.7,66.05 130.79,65.97
  BOTTOM w0.076: U80.AN48 v3(131.32,63.09)
  BOTTOM w0.132: v3(127.49,92.41) 127.23,92.41 127.09,92.26 127.09,91.57 USM2002.E2
M_B_CA_A<8>: length 53.4
  IN2 w0.097: v3(134.07,63.09) 134.07,63.18 133.6,63.65 133.6,66.1 134.21,66.71 134.21,66.89 135.43,68.12 135.43,69.67 136.21,70.45 136.21,72.96 138.18,74.93 138.18,77.2 140.77,79.79 140.77,91.51 138.04,94.23 127.67,94.23 127.54,94.1 126.58,94.1 124.51,92.03 124.51,91.54 124.63,91.42 125.81,91.42 126.2,91.81 v3(126.2,91.82)
  BOTTOM w0.076: U80.AN53 v3(134.07,63.09)
  BOTTOM w0.132: USM2002.D2 126.2,91.81 v3(126.2,91.82)
M_B_CA_A<9>: length 52.7
  IN2 w0.076: v3(133.15,63.09) 133.15,62.83 133.08,62.76 132.83,62.76 132.7,62.89 132.7,63.54 132.61,63.63 132.61,66.6
  IN2 w0.097: v3(125.55,91.82) 125.55,92.58 125.66,92.69 125.84,92.69 125.95,92.58 125.95,92.37 126.07,92.25 126.3,92.25 126.38,92.33 126.38,93.42 126.64,93.68 126.87,93.68 126.98,93.57 126.98,93.28 127.09,93.17 127.75,93.17 127.93,93.36 127.93,93.53 128,93.6 128.2,93.6 128.32,93.49 128.32,93.27 128.43,93.16 128.66,93.16 128.77,93.27 128.77,93.49 128.91,93.62 137.69,93.62 140.19,91.12 140.19,80.04 137.61,77.46 137.61,75.25 135.62,73.27 135.62,71.12 134.31,69.81 134.31,68.06 133.77,67.52 133.53,67.52 132.61,66.6
  BOTTOM w0.076: v3(133.15,63.09) 132.76,62.69 U80.AN52
  BOTTOM w0.13: v3(125.55,91.82) 125.55,91.81 USM2002.C2
M_B_CA_B<0>: length 51.9
  IN1 w0.097: v3(115.26,91.82) 115.27,91.82 115.66,92.2 117.48,92.2 118.95,90.74 118.95,86.87 119.33,86.5 119.33,84.43 119,84.1 119,75.92 124.14,70.78 124.14,70.77 124.29,70.62 124.29,70.47 123.8,69.99 123.8,69.85 123.99,69.67 124.17,69.67 124.89,70.39 124.89,70.62 122.15,73.36 121.02,74.48 121.02,74.62 121.19,74.78 121.32,74.78 125.52,70.58 126.6,70.58 126.77,70.75 126.77,71.14 126.67,71.24 126.54,71.24 126.45,71.34 126.45,71.53 126.54,71.63 126.67,71.63 126.77,71.72 126.77,72.27 126.86,72.37 v3(127.74,72.37)
  BOTTOM w0.076: U80.BA43 127.37,67.67 127.37,67.91 127.36,67.93 127.32,68.03 127.32,68.14 127.37,68.27 127.37,68.53 127.37,68.53 127.37,68.66 127.23,68.8 127.23,69.29 127.5,69.55 127.5,69.71 127.97,70.18 127.97,71.28 127.74,71.51 v3(127.74,72.37)
  BOTTOM w0.132: v3(115.26,91.82) 115.26,91.81 USM2003.R2
M_B_CA_B<1>: length 53
  IN1 w0.097: v3(127.87,73.08) 128.22,73.08 128.3,73.16 128.3,73.28 128.01,73.57 127.71,73.57 127.27,73.12 127.27,72.81 127.16,72.7 126.58,72.7 126.41,72.53 126.41,72.06 126.28,71.93 126.07,71.93 123.55,74.45 123.4,74.45 123.22,74.27 123.22,74.11 125.91,71.42 125.91,71.22 125.8,71.1 125.6,71.1 119.97,76.73 119.82,76.73 119.71,76.62 119.71,76.38 120.87,75.21 120.87,75.1 120.67,74.9 120.47,74.9 119.3,76.06 119.3,83.96 119.7,84.36 119.7,86.65 119.26,87.09 119.26,90.93 117.61,92.58 115.38,92.58 114.62,91.82 v3(114.61,91.82)
  BOTTOM w0.076: U80.AY43 127.8,67.08 127.8,67.18 127.87,67.33 127.87,67.52 127.82,67.68 127.82,67.82 127.88,68.04 127.88,68.15 127.85,68.24 127.84,68.26 127.84,68.64 128.02,68.83 128.02,69.91 128.13,70.02 128.13,71.95 128.09,71.99 128.09,72.22 128.09,72.22 128.09,72.52 128.09,72.53 128.09,72.6 127.87,72.82 v3(127.87,73.08)
  BOTTOM w0.132: USM2003.P2 114.61,91.81 v3(114.61,91.82)
M_B_CA_B<2>: length 53.2
  IN1 w0.097: v3(128.6,76.29) 127.55,76.29 127.41,76.14 127.41,73.79 126.72,73.11 125.52,73.11 123.71,74.92 120.55,78.07 120.4,78.07 120.21,77.88 120.21,77.72 122.98,74.96 122.98,74.78 122.81,74.62 122.64,74.62 119.61,77.65 119.61,83.84 120,84.23 120,86.78 119.56,87.21 119.56,91.26 117.88,92.95 115.1,92.95 113.97,91.82 v3(113.96,91.82)
  BOTTOM w0.076: U80.AY44 128.17,67.36 128.07,67.46 128.07,67.47 127.99,67.68 127.99,67.81 128.06,68.04 128.06,68.18 128,68.3 128,68.57 128.2,68.78 128.2,69.54 128.2,69.83 128.3,69.92 128.3,72.02 128.27,72.04 128.27,72.96 128.79,73.48 128.79,74.39 129.01,74.6 129.01,75.36
  BOTTOM w0.132: v3(113.96,91.82) 113.96,91.81 USM2003.N2 ; 129.01,75.36 129.01,75.88 v3(128.6,76.29)
M_B_CA_B<3>: length 51.5
  IN1 w0.097: v3(113.96,91.02) 114.35,91.41 116.3,91.41 116.41,91.29 116.41,91.01 116.51,90.91 116.77,90.91 116.87,91.01 116.87,91.81 116.96,91.91 117.22,91.91 117.31,91.81 117.31,90.5 117.39,90.42 117.58,90.42 117.7,90.53 117.7,91.1 117.78,91.18 117.98,91.18 118.65,90.51 118.65,86.64 119,86.29 119,84.55 118.69,84.24 118.69,75.8 121.83,72.66 121.83,72.37 122.2,72 122.2,71.84 121.52,71.16 121.52,71.01 121.7,70.83 121.85,70.83 122.53,71.52 122.69,71.52 122.85,71.35 122.85,71.19 122.4,70.74 122.4,70.74 121.84,70.18 121.84,70.03 122.03,69.84 122.14,69.84 122.65,70.34 123.17,70.87 123.33,70.87 123.48,70.72 123.48,70.48 123.12,70.12 123.12,69.97 123.89,69.2 124.15,69.2 125.24,70.28 126.91,70.28 127.06,70.43 127.06,71.73 127.29,71.96 128.55,71.96 v3(128.99,72.39)
  BOTTOM w0.076: U80.AW44 128.17,66.62 128.33,66.78 128.44,67 128.46,67.06 128.46,67.53 128.7,67.77 128.7,69.59 128.8,69.69 128.8,70.18 128.8,71.95 128.99,72.15 v3(128.99,72.39)
  BOTTOM w0.132: USM2003.N3 113.96,91.01 v3(113.96,91.02)
M_B_CA_B<4>: length 51.4
  IN1 w0.097: v3(129.39,74.52) 129.02,74.9 129.02,76.63 128.9,76.75 127.23,76.75 127.03,76.55 127.03,75.76 126.92,75.65 126.01,75.65 125.9,75.53 125.9,75.31 126.01,75.19 126.92,75.19 127.03,75.08 127.03,74.86 126.92,74.75 125.4,74.75 125.28,74.63 125.28,74.4 125.4,74.29 126.92,74.29 127.03,74.17 127.03,73.92 126.64,73.53 125.63,73.53 119.91,79.24 119.91,83.71 120.31,84.11 120.31,86.9 119.87,87.34 119.87,91.43 118,93.3 113.35,93.3 112.89,92.84 112.89,91.41 113.29,91.02 v3(113.31,91.02)
  BOTTOM w0.076: U80.BB44 128.37,68.51 128.37,69.61 128.37,69.75 128.46,69.85 128.46,72.17 128.46,72.17 128.46,72.91 128.99,73.44 128.99,74.03 v3(129.39,74.52)
  BOTTOM w0.132: USM2003.M3 113.31,91.01 v3(113.31,91.02)
M_B_CA_B<5>: length 53.3
  IN1 w0.097: v3(108.77,91.02) 108.77,91.01 108.37,90.61 107.94,90.61 107.63,90.91 107.63,92.62 109.38,94.37 118.76,94.37 122.27,90.86 122.27,90.8 122.29,90.78 122.29,90.46 122.27,90.43 122.27,88.27 122.13,88.14 122.13,83.35 121.79,83 121.79,81.48 123.66,79.61 128.72,79.61 130.97,77.36 130.97,75.27 v3(131.14,75.1)
  BOTTOM w0.076: U80.AY47 129.69,67.09 129.69,67.52 129.74,67.68 129.74,67.82 129.68,68.04 129.68,68.15 129.71,68.24 129.73,68.26 129.73,68.63 129.52,68.84 129.52,69.25 129.62,69.34 129.62,69.51 129.62,69.51 129.62,69.84 129.62,69.84 129.62,71.44 129.74,71.56 129.74,71.56 129.82,71.63 129.82,71.63 130.58,72.39
  BOTTOM w0.132: USM2003.F3 108.77,91.01 v3(108.77,91.02) ; v3(131.14,75.1) 131.7,74.54 131.7,72.87 131.22,72.39 130.58,72.39
M_B_CA_B<6>: length 51.1
  IN1 w0.097: v3(108.12,91.02) 108.1,91.02 107.89,91.23 107.89,92.41 109.54,94.06 118.3,94.06 120.53,91.83 120.53,87.54 120.91,87.16 120.91,83.85 120.52,83.46 120.52,79.65 122.72,77.46 122.72,77.45 124.39,75.78 124.49,75.68 124.98,75.68 125.14,75.83 125.14,76.32 125.27,76.45 126.13,76.45 126.28,76.6 126.28,77.36 126.37,77.46 129.15,77.46 129.8,76.8 129.8,74.19 129.55,73.94 v3(129.52,73.94)
  BOTTOM w0.076: v3(129.52,73.94) 129.16,73.58 129.16,73.34 128.62,72.8 128.62,72.24 128.63,72.23 128.63,69.78 128.53,69.68 128.53,68.03 U80.BA44
  BOTTOM w0.132: v3(108.12,91.02) 108.12,91.01 USM2003.E3
M_B_CA_B<7>: length 51.9
  IN1 w0.097: v3(108.31,92.25) 109.29,92.25 109.4,92.37 109.4,93.47 109.61,93.68 118.22,93.68 120.17,91.73 120.17,87.47 120.61,87.03 120.61,83.98 120.22,83.58 120.22,79.39 124.11,75.49 124.69,74.91 124.97,74.91 125.22,75.17 125.44,75.17 125.54,75.26 125.54,75.92 125.66,76.04 126.49,76.04 126.65,76.21 126.65,76.96 126.81,77.11 129.06,77.11 129.42,76.76 v3(129.42,75.87)
  BOTTOM w0.076: v3(129.42,75.87) v1(130.31,75.21) 130.31,74.17 129.88,73.75 129.88,73.45 129.88,72.79 128.96,71.87 128.96,70.11 128.96,69.62 128.86,69.52 128.86,67.77 129.1,67.53 129.1,67.04 129.21,66.83 129.39,66.65 U80.AW46
  BOTTOM w0.132: USM2003.E2 108.31,91.62 v3(108.31,92.25)
M_B_CA_B<8>: length 51.9
  IN1 w0.097: v3(107.35,92.91) 109.25,94.82 119.11,94.82 122.63,91.3 122.63,87.94 122.47,87.77 122.47,83.2 122.18,82.91 122.18,81.57 123.8,79.95 128.81,79.95 131.26,77.5 131.26,75.54 131.54,75.25 131.54,74.83 v3(131.19,74.47)
  BOTTOM w0.076: U80.AY46 129.39,67.37 129.5,67.47 129.57,67.68 129.57,67.81 129.51,68.04 129.51,68.18 129.56,68.3 129.56,68.56 129.36,68.77 129.36,69.31 129.46,69.41 129.46,69.44 129.46,71.6 130.57,72.71 131.05,72.71 131.45,73.11 131.45,73.58 131.45,74.21 v3(131.19,74.47)
  BOTTOM w0.132: v3(107.35,92.91) 107.35,91.93 USM2003.D2
M_B_CA_B<9>: length 52.8
  IN1 w0.097: v3(106.82,91.82) 106.82,93.18 108.87,95.24 119.23,95.24 123.05,91.42 123.05,83.51 122.76,83.23 122.76,83.08 122.75,83.07 122.75,82.99 122.56,82.8 122.56,81.7 123.92,80.33 128.9,80.33 131.33,77.9 131.33,77.85 131.55,77.64 131.55,75.71 131.83,75.44 131.83,74.57 131.35,74.1 131.29,74.1 v3(131.07,73.88)
  BOTTOM w0.076: 130.09,73.53 130.09,72.71 129.13,71.76 129.13,70.04 129.13,70.04 129.13,69.55 129.03,69.45 129.03,68.03 U80.BA46
  BOTTOM w0.13: v3(106.82,91.82) 106.82,91.81 USM2003.C2
  BOTTOM w0.132: 130.09,73.53 130.43,73.88 v3(131.07,73.88)
M_B_CKE<0>: length 54.4
  IN1 w0.097: v3(135.93,63.02) 135.83,63.02 135.51,62.69 135.51,61.48 135.37,61.34 135.37,60.8 134.7,60.12 128.73,60.12 127.82,61.03 127.34,61.03 126.34,62.03 126.34,65.84 126.83,66.33 126.83,67.45 126.93,67.54 127.86,67.54 127.99,67.68 127.99,67.87 127.86,68.01 127.15,68.01 127.05,68.1 127.05,68.37 127.15,68.46 127.71,68.46 132.69,73.44 132.69,75.03 132.96,75.31 132.96,79.12 135.94,82.09 135.94,91.18 135.63,91.49 131.22,91.49 130.79,91.06 v3(130.78,91.06)
  BOTTOM w0.076: v3(135.93,63.02) 135.82,63.02 135.7,62.92
  BOTTOM w0.132: v3(130.78,91.06) 130.72,91.01 130.72,90.99 USM2002.K3
  BOTTOM w0.147: U80.AN56 135.7,62.92
M_B_CKE<1>: length 54.6
  IN1 w0.076: v3(134.98,63.72) 134.61,63.35 134.61,61.52 134.36,61.27 128.92,61.27
  IN1 w0.097: 128.92,61.27 128.72,61.47 127.63,61.47 127.16,61.94 127.16,66.15 127.24,66.23 128.15,66.23 128.29,66.37 128.29,66.56 128.15,66.7 127.38,66.7 127.25,66.82 127.25,66.98 127.35,67.08 128.18,67.08 128.36,67.26 128.36,68.71 132.96,73.3 132.96,74.78 133.25,75.07 133.25,78.99 136.36,82.1 136.36,91.34 135.8,91.89 130.75,91.89 130.39,91.53 130.39,90.56 130.73,90.22 v3(130.74,90.22)
  BOTTOM w0.076: U80.AP55 v3(134.98,63.72)
  BOTTOM w0.132: v3(130.74,90.22) 130.74,90.21 USM2002.K4
M_B_CKE<2>: length 55.3
  IN1 w0.076: 135.3,63.41 134.98,63.09
  IN1 w0.097: v3(112.01,91.02) 112.01,91.01 112.4,90.62 116.73,90.62 118.34,89 118.34,86.02 118.13,85.81 118.13,84.21 118.4,83.94 118.4,75.66 121.18,72.88 121.18,70 124.45,66.73 124.45,62.32 125.47,61.3 126.06,61.3 126.47,60.89 126.47,60.43 127.18,59.72 135.27,59.72 136.07,60.53 136.1,60.53 136.34,60.77 136.34,63.16 136.09,63.41 135.3,63.41 ; 134.98,63.09 v3(134.98,63.09)
  BOTTOM w0.076: v3(134.98,63.09) 134.59,62.69 U80.AN55
  BOTTOM w0.132: USM2003.K3 112.01,91.01 v3(112.01,91.02)
M_B_CKE<3>: length 55.1
  IN1 w0.097: v3(112.01,90.22) 112.01,90.21 112.4,89.82 116.72,89.82 117.96,88.57 v3(117.96,87.97)
  IN2 w0.097: v3(117.96,87.97) 119.22,87.97 120.9,86.29 120.9,83.19 118.81,81.09 118.81,67.31 118.46,66.96 118.46,66.39 118.96,65.89 118.96,62.17 119.68,61.45 133.73,61.45 134.45,62.17 134.45,63.33 134.07,63.72 v3(134.07,63.72)
  BOTTOM w0.076: U80.AP53 v3(134.07,63.72)
  BOTTOM w0.132: v3(112.01,90.22) 112.01,90.21 USM2003.K4
M_B_CLK_DDR_DN*<0>: length 54.1
  IN2 w0.076: v3(129.5,63.09) 129.82,63.41 129.82,63.41 130.04,63.63 130.04,66.22 129.94,66.32 129.94,66.58 129.96,66.61
  IN2 w0.102: 129.96,66.61 130.82,67.47 131.74,68.39 131.74,69.45 132.12,69.83 132.12,70.08 132.12,70.16 132.13,70.17 132.13,71.01 132.71,71.59 133.14,71.59 133.36,71.81 133.36,72.2 133.14,72.42 132.77,72.42 132.67,72.52 132.67,72.74 132.77,72.84 133.41,72.84 133.63,73.06 133.63,73.45 133.41,73.67 132.74,73.67 132.66,73.75 132.66,73.9 132.87,74.11 132.89,74.11 133.07,74.3 133.07,74.6 132.91,74.77 132.71,74.77 132.67,74.81 132.67,74.91 133.15,75.39 133.29,75.39 134.16,74.53 134.56,74.53 135.17,75.14 135.17,75.99 135.27,76.09 135.45,76.09 135.75,76.09 135.98,76.32 135.98,76.68 135.37,77.29 135.37,77.61 135.48,77.71 135.48,77.72 135.48,77.73 138.5,80.75 138.5,89.95 138.28,90.18 137.78,90.18 137.56,89.95 137.56,89.01 137.45,88.9 137.2,88.9 137.1,89.01 137.1,91.21 136.86,91.45 136.51,91.45 136.27,91.2 136.27,89.67 136.27,89.22 136.21,89.16 135.98,89.16 135.88,89.26 135.88,91.43 135.66,91.65 131.73,91.65 131.61,91.77 130.14,91.77 v3(130.09,91.82)
  BOTTOM w0.076: U80.AN45 v3(129.5,63.09)
  BOTTOM w0.147: USM2002.J2 130.09,91.81 v3(130.09,91.82)
M_B_CLK_DDR_DN*<1>: length 54.2
  IN2 w0.076: v3(130.41,63.09) 130.27,63.09 130.05,62.86 130.05,62.03 129.78,61.76 120.13,61.76 119.79,62.1 119.79,65.97
  IN2 w0.102: 119.79,65.97 119.3,66.46 119.3,68.18 119.26,68.22 119.26,69.63 119.63,70 119.63,80.55 121.5,82.42 121.5,86.5 119.54,88.47 117.25,88.47 116.79,88.01 110.97,88.01 110.67,88.32 110.67,91.17 111.09,91.59 111.13,91.59 v3(111.36,91.82)
  BOTTOM w0.076: U80.AN46 v3(130.41,63.09)
  BOTTOM w0.147: v3(111.36,91.82) 111.36,91.81 USM2003.J2
M_B_CLK_DDR_DP<0>: length 54.1
  IN2 w0.076: 129.77,66.67 129.77,66.26 129.88,66.15 129.88,66.08 129.86,66.07 129.86,63.71 129.73,63.57 129.64,63.57 v3(129.5,63.72)
  IN2 w0.102: v3(130,91.09) 130.48,91.56 131.53,91.56 131.61,91.48 131.65,91.44 132.13,91.44 132.29,91.28 132.57,91.28 132.73,91.44 132.94,91.44 133.04,91.34 133.04,91.34 133.14,91.23 133.34,91.23 133.45,91.34 133.45,91.34 133.55,91.44 135.58,91.44 135.69,91.33 135.69,89.18 135.91,88.96 136.3,88.96 136.47,89.13 136.47,89.59 136.47,89.59 136.47,91.12 136.6,91.25 136.78,91.25 136.9,91.13 136.9,88.92 137.12,88.7 137.54,88.7 137.76,88.92 137.76,89.87 137.86,89.97 138.19,89.97 138.29,89.87 138.29,80.83 135.28,77.82 135.28,77.8 135.17,77.69 135.17,77.21 135.78,76.6 135.78,76.4 135.67,76.29 135.45,76.29 135.36,76.38 135.22,76.38 134.97,76.13 134.97,75.22 134.47,74.73 134.24,74.73 133.38,75.59 133.07,75.59 132.46,74.99 132.46,74.73 132.63,74.56 132.82,74.56 132.87,74.52 132.87,74.38 132.8,74.31 132.79,74.31 132.45,73.98 132.45,73.67 132.65,73.47 133.33,73.47 133.43,73.37 133.43,73.15 133.33,73.04 132.68,73.04 132.46,72.82 132.46,72.44 132.69,72.21 133.06,72.21 133.16,72.11 133.16,71.9 133.06,71.8 132.63,71.8 131.93,71.1 131.93,70.26 131.92,70.24 131.92,69.99 131.92,69.91 131.54,69.53 131.54,68.47 130.62,67.55 129.77,66.71 129.77,66.67
  BOTTOM w0.076: U80.AP45 v3(129.5,63.72)
  BOTTOM w0.147: USM2002.J3 130,90.92 v3(130,91.09)
M_B_CLK_DDR_DP<1>: length 54.2
  IN2 w0.076: v3(130.41,63.72) 130,63.31 130,63.11 129.87,62.98 129.87,62.11 129.7,61.94 120.21,61.94 119.97,62.18 119.97,65.88 119.98,65.89 119.98,66.05 119.94,66.09 119.94,66.11 119.94,66.11
  IN2 w0.102: 119.94,66.11 119.51,66.54 119.51,68.26 119.46,68.31 119.46,69.54 119.83,69.91 119.83,80.46 121.71,82.34 121.71,86.59 119.62,88.67 117.16,88.67 116.71,88.22 111.06,88.22 110.87,88.4 110.87,91.09 111.18,91.39 111.32,91.39 111.42,91.29 111.42,91.08 v3(111.36,91.02)
  BOTTOM w0.076: U80.AP46 v3(130.41,63.72)
  BOTTOM w0.147: v3(111.36,91.02) 111.36,91.01 USM2003.J3
M_B_CS*<0>: length 60
  IN1 w0.097: v3(127.61,70.92) 128.24,71.55 128.89,71.55 130.67,73.33 130.67,77.23 128.77,79.12 124.28,79.12 124.16,79.01 124.16,78.89 124.05,78.78 123.82,78.78 123.7,78.89 123.7,79.01 123.59,79.12 123.16,79.12 121.43,80.85 121.43,83.08 121.83,83.47 121.83,88.26 121.91,88.34 v3(121.91,90.62)
  IN2 w0.097: v3(112.66,91.02) 112.66,91.01 113.05,90.62 117.46,90.62 117.56,90.52 117.56,89.88 117.77,89.66 119.3,89.66 119.39,89.76 119.39,90.33 119.49,90.42 119.68,90.42 119.78,90.33 119.78,89.76 119.88,89.66 120.07,89.66 120.17,89.76 120.17,90.33 120.26,90.42 120.45,90.42 120.55,90.33 120.55,89.76 120.65,89.66 120.85,89.66 120.94,89.76 120.94,90.52 121.04,90.62 v3(121.91,90.62) 121.91,91.92 122.04,92.05 122.45,92.05 122.54,91.95 122.54,91.38 122.64,91.29 123.08,91.29 123.18,91.38 123.18,91.87 123.36,92.05 123.66,92.05 123.76,91.95 123.76,90.71 123.86,90.62 131.03,90.62 131.39,90.98 v3(131.39,91.02)
  BOTTOM w0.076: U80.BB42 126.94,68.68 126.9,68.72 126.9,69.43 127.17,69.69 127.17,70.48 v3(127.61,70.92)
  BOTTOM w0.132: USM2003.L3 112.66,91.01 v3(112.66,91.02) ; v3(131.39,91.02) 131.39,91.01 USM2002.L3
M_B_CS*<1>: length 56.6
  IN1 w0.097: v3(121.45,89.37) 121.03,89.37 120.92,89.26 120.92,87.58 121.22,87.27 121.22,83.73 120.83,83.33 120.83,80.59 123.51,77.91 129.13,77.91 130.09,76.94 130.09,73.89 129.76,73.56 129.32,73.56 129.07,73.81 129.07,74.31 128.63,74.75 v3(128.63,75.03)
  IN2 w0.097: v3(112.66,90.22) 112.66,90.21 113.05,89.82 116.99,89.82 117.14,89.67 117.14,89.27 117.24,89.17 120.31,89.17 120.4,89.08 120.4,88.78 120.5,88.68 120.69,88.68 120.79,88.78 120.79,89.08 120.88,89.17 121.25,89.17 v3(121.45,89.37) 121.89,89.81 130.99,89.81 131.39,90.21 v3(131.39,90.22)
  BOTTOM w0.076: v3(128.63,75.03) 128.37,74.77 128.27,74.77 127.21,73.71 127.21,71.37 126.83,71 126.83,70.62 126.71,70.5 126.71,69.7 126.57,69.56 126.57,68.82 126.51,68.75 126.51,68.27 126.52,68.24 126.61,68.03 126.67,67.86 126.67,67.38 U80.AY42
  BOTTOM w0.132: v3(112.66,90.22) 112.66,90.21 USM2003.L4 ; v3(131.39,90.22) 131.39,90.21 USM2002.L4
M_B_DQ<0>: length 32
  BOTTOM w0.076: U80.AY39 125.78,67.22 125.78,67.42 125.99,67.64 125.99,68 126.04,68.12 126.04,68.14 126.1,68.27 126.1,68.67 126.04,68.72 126.04,69.57 125.92,69.69 125.92,70.03 126.65,70.75 126.65,71.07 127.03,71.45 127.03,73.95
  BOTTOM w0.152: USM2002.R8 133.67,87.23 134.4,87.96 136.19,87.96 137.05,87.09 137.05,80.85 134.38,78.17 133.82,78.17 132.38,76.73 128.44,76.73 128.14,76.43 128.14,75.06 127.03,73.95
M_B_DQ<1>: length 30.5
  BOTTOM w0.076: U80.AW39 125.01,66.46 124.75,66.72 124.75,67.3 124.73,67.33 124.73,67.52 124.79,67.68 124.79,67.82 124.73,68.04 124.73,68.15 124.77,68.27 124.77,68.64 124.57,68.84 124.57,69.24 125.06,69.72 125.06,70.42 125.63,71 125.63,71.73 125.76,71.85
  BOTTOM w0.152: USM2002.T9 134.79,86.35 135.65,86.35 136.02,85.98 136.02,81.43 134.15,79.56 130.93,79.56 130.34,78.96 127.98,78.96 126.34,77.32 126.34,75.87 125.76,75.29 125.76,71.85
M_B_DQ<2>: length 28.6
  BOTTOM w0.076: U80.AY37 124.54,67.21 124.54,67.47 124.62,67.68 124.62,67.81 124.55,68.04 124.55,68.18 124.61,68.3 124.61,68.57 124.4,68.78 124.4,69.45 124.79,69.83 124.79,70.59 125.43,71.23
  BOTTOM w0.152: USM2002.R10 133.67,85.31 133.84,85.49 135.52,85.49 135.67,85.33 135.67,81.65 133.93,79.91 130.73,79.91 130.21,79.38 127.9,79.38 125.97,77.46 125.97,76.04 125.43,75.49 125.43,71.23
M_B_DQ<3>: length 31.9
  BOTTOM w0.076: USM2002.R11 133.89,84.06 133.89,83.62 133.91,83.6 133.91,83.37 133.91,83.37 133.91,83.33 133.9,83.32 133.9,83.11 132.83,82.05 ; 123.98,71.2 123.98,70.16 123.91,70.08 123.91,67.75 124.13,67.53 124.13,66.99 124.44,66.68 U80.AW37
  BOTTOM w0.152: 123.98,71.2 124.44,71.65 124.44,76.13 124.86,76.55 124.86,77.87 126.69,79.7 v1(126.69,79.87) 126.69,82.33 126.87,82.51 127.36,82.51 127.5,82.36 127.5,81.79 127.6,81.69 128.73,81.69 128.87,81.82 128.87,82.59 129,82.73 129.19,82.73 129.33,82.59 129.33,81.82 129.46,81.69 129.65,81.69 129.78,81.82 129.78,82.59 129.92,82.73 130.11,82.73 130.24,82.59 130.24,81.82 130.38,81.69 130.57,81.69 130.7,81.82 130.7,82.59 130.83,82.73 131.02,82.73 131.16,82.59 131.16,82.18 131.29,82.05 132.83,82.05
M_B_DQ<4>: length 28
  BOTTOM w0.076: 126.68,74.54 126.6,74.45 126.6,71.51 126.3,71.21 126.3,70.87 125.59,70.16 125.59,69.55 125.7,69.44 125.7,68.66 125.67,68.62 U80.BB39
  BOTTOM w0.152: 126.68,74.54 127.46,75.31 127.46,76.72 128.3,77.56 132.13,77.56 133.58,79.02 134.18,79.02 136.37,81.2 136.37,86.75 135.86,87.26 134.89,87.26 USM2002.T8
M_B_DQ<5>: length 31
  BOTTOM w0.076: U80.BA39 125.75,67.84 125.75,67.99 125.81,68.05 125.81,68.05 125.81,68.05 125.9,68.23 125.92,68.28 125.92,68.56 125.91,68.57 125.91,68.62 125.88,68.66 125.88,69.5 125.76,69.62 125.76,70.1 126.47,70.81 126.47,71.15 126.82,71.5 126.82,74.21 126.93,74.32
  BOTTOM w0.152: USM2002.R9 134,86.22 134,87.07 134.54,87.61 136.03,87.61 136.71,86.93 136.71,81.03 134.25,78.57 133.67,78.57 132.22,77.13 128.35,77.13 127.8,76.57 127.8,75.19 126.93,74.32
M_B_DQ<6>: length 27.5
  BOTTOM w0.076: USM2002.T11 134.32,84.24 134.08,84 134.08,83.6 134.08,83.59 134.08,83.39 134.08,83.38 134.08,82.89 ; U80.BA37 124.34,67.97 124.07,68.24 124.07,68.7 124.07,69.87 124.27,70.07 124.27,71 124.77,71.49
  BOTTOM w0.152: 124.77,71.49 124.77,75.97 125.2,76.41 125.2,77.71 127.38,79.88 127.38,81.11 v1(127.41,81.14) 127.53,81.26 127.75,81.26 127.88,81.13 127.88,80.87 128.01,80.74 128.2,80.74 128.34,80.87 128.34,81.13 128.47,81.26 128.66,81.26 128.8,81.13 128.8,80.87 128.93,80.74 129.12,80.74 129.25,80.87 129.25,81.13 129.39,81.26 129.58,81.26 129.71,81.13 129.71,80.87 129.85,80.74 130.04,80.74 130.17,80.87 130.17,81.13 130.3,81.26 130.49,81.26 130.63,81.13 130.63,80.87 130.76,80.74 130.95,80.74 131.09,80.87 131.09,81.13 131.22,81.26 131.41,81.26 131.54,81.13 131.54,80.87 131.68,80.74 131.87,80.74 132,80.87 132,81.13 132.14,81.26 132.46,81.26 134.08,82.89
M_B_DQ<7>: length 26.1
  BOTTOM w0.076: 125.1,71.28 124.54,70.72 124.54,69.97 124.24,69.67 124.24,68.7 124.34,68.6 U80.BB37
  BOTTOM w0.152: 125.1,71.28 125.1,75.7 125.59,76.19 125.59,77.59 127.74,79.73 127.74,80.13 127.97,80.37 v1(128.6,80.37) 129.19,80.37 129.34,80.22 129.34,79.92 129.49,79.77 129.8,79.77 129.95,79.92 129.95,80.22 130.1,80.37 133.76,80.37 135.32,81.93 135.32,82.87 135.07,83.13 134.89,83.13 134.64,83.38 134.64,84.76 USM2002.T10
M_B_DQ<8>: length 20.7
  BOTTOM w0.076: 122.86,72.21 122.86,70.39 123.23,70.02 123.23,69.06 123.04,68.88 123.04,68.31 123.08,68.22 123.08,68.2 123.08,67.95 123.04,67.87 123.04,67.66 123.11,67.47 123.11,67.21 U80.AY35
  BOTTOM w0.152: USM2002.B10 125.08,85.09 124.64,84.64 123.57,84.64 123.37,84.44 123.37,84.02 123.89,83.49 123.89,82.48 124.08,82.29 124.08,80.9 124.28,80.7 124.28,79.7 123.1,78.52 123.1,72.46 122.86,72.21
M_B_DQ<9>: length 20
  BOTTOM w0.076: 123.73,71.43 123.73,68.63 123.74,68.62 123.74,68.09 123.62,67.97 123.62,67.62 123.53,67.53 123.53,67.01 123.21,66.69 U80.AW35
  BOTTOM w0.152: USM2002.C10 126.19,84.76 126.19,79.91 124.35,78.07 v1(124.35,76.98) 124.35,76.51 124.11,76.27 124.11,71.81 123.73,71.43
M_B_DQ<10>: length 24.7
  BOTTOM w0.076: 121.05,70.71 121.34,70.43 121.34,69.51 121.71,69.14 121.71,68.79 121.68,68.76 121.55,68.63 121.55,68.27 121.71,67.93 121.71,67.38 U80.AY33
  BOTTOM w0.152: USM2002.C8 125,87.55 123.56,87.55 121.79,85.77 121.79,82.62 120.98,81.81 v1(120.98,80.16) 120.98,77.37 121.12,77.23 121.12,72.43 121.05,72.37 121.05,70.71
M_B_DQ<11>: length 23.5
  BOTTOM w0.076: U80.AW33 122.64,66.46 122.84,66.66 122.84,67.18 122.92,67.28 122.92,67.53 122.87,67.65 122.87,67.88 122.88,67.89 122.88,67.89 122.88,67.9 122.92,67.99 122.92,68.19 122.88,68.27 122.88,68.28 122.88,68.95 123.07,69.13 123.07,69.83 122.57,70.33 122.57,72.47
  BOTTOM w0.152: 122.57,72.47 122.76,72.66 122.76,78.72 123.62,79.58 v1(123.62,79.78) 123.62,81.07 123.75,81.2 123.75,82.16 123.58,82.33 123.58,83.31 122.97,83.92 122.97,84.62 123.87,85.52 125.5,85.52 USM2002.C9
M_B_DQ<12>: length 18.9
  BOTTOM w0.076: U80.BB35 123.31,68.8 123.4,68.89 123.4,70.21 123.13,70.48 123.13,71.88
  BOTTOM w0.079: 124.92,84.02 124.92,84.43 125.17,84.68 125.45,84.68 125.56,84.57 125.56,84.36 125.49,84.29 USM2002.B11
  BOTTOM w0.152: 124.92,84.02 124.77,83.87 124.43,83.87 124.18,83.62 124.18,82.58 124.41,82.35 124.41,81.13 124.57,80.97 124.57,80.9 124.63,80.84 124.63,79.55 123.45,78.36 123.45,72.2 123.13,71.88
M_B_DQ<13>: length 18.8
  BOTTOM w0.076: 123.44,71.6 123.44,70.47 123.57,70.34 123.57,68.56 123.58,68.55 123.58,68.25 123.31,67.98 U80.BA35
  BOTTOM w0.079: USM2002.C11 125.55,83.97 125.55,82.53 125.28,82.25
  BOTTOM w0.152: 125.28,82.25 125.28,81.75 125.77,81.25 125.77,80.92 125.62,80.76 125.12,80.76 125.01,80.66 125.01,80.22 125.12,80.12 125.22,80.12 125.37,79.96 125.37,79.75 123.78,78.15 123.78,71.94 123.44,71.6
M_B_DQ<14>: length 22.4
  BOTTOM w0.076: U80.BA33 121.99,67.91 121.84,68.05 121.84,68.05 121.84,68.05 121.72,68.3 121.72,68.56 121.9,68.74 121.9,69.21 121.58,69.53 121.58,70.78 121.46,70.89 121.46,71
  BOTTOM w0.152: 121.46,71 121.46,71 121.46,81.59 122.18,82.3 122.18,85.65 123.73,87.2 124.7,87.2 USM2002.B8
M_B_DQ<15>: length 20.7
  BOTTOM w0.076: 121.79,71.73 121.79,69.56 122.07,69.28 122.07,68.5 U80.BB33
  BOTTOM w0.152: 121.79,71.73 121.79,81.03 v1(122.16,81.39) 122.55,81.79 122.55,85.51 123.3,86.26 124.84,86.26 USM2002.B9
M_B_DQ<16>: length 32.8
  IN2 w0.114: v3(126.75,65.63) 126.75,67.52 126.91,67.68 127.05,67.68 127.44,67.29 127.58,67.29 127.68,67.39 127.68,67.53 127.29,67.92 127.29,68.06 127.39,68.16 127.53,68.16 127.92,67.77 128.06,67.77 128.16,67.88 128.16,68.02 127.78,68.41 127.78,68.55 127.88,68.65 128.02,68.65 128.41,68.26 128.55,68.26 128.65,68.36 128.65,68.5 128.26,68.89 128.26,69.03 129.76,70.53 129.76,72.16 130.38,72.78 130.38,75.67 131.05,76.34 131.82,76.34 136.81,81.33 136.81,84.68 135.99,85.5 134.86,85.5 133.99,86.37 133.35,86.37 v3(133.34,86.36)
  BOTTOM w0.076: U80.AU40 v3(126.75,65.63)
  BOTTOM w0.152: v3(133.34,86.36) 133.02,86.04 USM2002.P9
M_B_DQ<17>: length 31.7
  IN2 w0.076: 127.12,65.95 127.12,65.47 126.94,65.29 126.94,65.18 v3(126.75,64.99)
  IN2 w0.114: v3(132.69,86.36) 132.69,86.37 133.11,86.79 134.3,86.79 134.68,86.41 136.51,86.41 137.15,85.78 137.15,81.21 131.89,75.96 131.2,75.96 130.69,75.45 130.69,72.57 130.08,71.96 130.08,70.29 129.29,69.51 129.29,68.24 127.12,66.07 127.12,65.95
  BOTTOM w0.076: U80.AT40 v3(126.75,64.99)
  BOTTOM w0.152: USM2002.N9 132.37,86.04 v3(132.69,86.36)
M_B_DQ<18>: length 32.6
  IN2 w0.114: v3(132.04,84.76) 132.91,85.63 134.13,85.63 134.8,84.95 134.8,82.29 135.16,81.94 135.16,80.11 131.77,76.72 130.93,76.72 130.04,75.83 130.04,72.89 129.2,72.05 129.2,71.78 129.35,71.62 129.35,71.48 129.25,71.38 128.71,71.38 128.61,71.28 128.61,71.14 128.71,71.04 129.25,71.04 129.35,70.94 129.35,70.79 129.25,70.69 128.71,70.69 128.61,70.59 128.61,69.98 128.08,69.46 127.21,69.46 126.72,68.96 126.72,68.52 126.03,67.83 126.03,67.67 126.29,67.41 126.29,67.25 126.12,67.09 125.96,67.09 125.71,67.34 125.55,67.34 125.33,67.13 125.33,65.15 125.17,64.99 v3(124.91,64.99)
  BOTTOM w0.076: U80.AT37 124.91,64.98 v3(124.91,64.99)
  BOTTOM w0.152: v3(132.04,84.76) 131.72,85.08 USM2002.M10
M_B_DQ<19>: length 33.4
  IN2 w0.114: v3(132.69,84.76) 133.21,85.28 133.9,85.28 134.49,84.69 134.49,82.11 134.75,81.85 134.75,80.14 131.72,77.1 128.21,77.1 128.09,76.99 128.09,75.87 127.98,75.76 125.92,75.76 125.82,75.66 125.82,75.51 125.92,75.41 126.87,75.41 126.97,75.31 126.97,75.17 126.87,75.07 125.92,75.07 125.82,74.97 125.82,74.83 125.92,74.73 126.87,74.73 126.97,74.63 126.97,69.79 126.15,68.97 126.15,68.67 124.92,67.45 124.92,65.65 v3(124.91,65.64)
  BOTTOM w0.076: U80.AU37 124.91,65.63 v3(124.91,65.64)
  BOTTOM w0.152: USM2002.N10 132.37,85.08 v3(132.69,84.76)
M_B_DQ<20>: length 34
  IN2 w0.076: 127.35,65.82 127.35,65.44 127.12,65.21 127.12,64.73 v3(126.75,64.36)
  IN2 w0.114: v3(131.72,87.23) 132.11,87.63 133.21,87.63 133.6,87.24 136.22,87.24 137.45,86 137.45,81.05 131.59,75.19 131.59,72.15 131,71.56 131,70.55 130.43,69.98 130.43,68.48 129.02,67.06 128.6,67.06 127.35,65.82
  BOTTOM w0.076: v3(126.75,64.36) 126.42,64.09 U80.AR40
  BOTTOM w0.152: USM2002.M8 v3(131.72,87.23)
M_B_DQ<21>: length 37.5
  IN2 w0.076: v3(126.75,63.72) 127.29,64.26 127.29,65.14 128.25,66.1
  IN2 w0.114: 128.25,66.1 128.81,66.1 129.34,66.64 129.34,66.88 130.79,68.33 130.79,69.73 131.35,70.29 131.35,71.41 131.94,72 131.94,75.05 137.76,80.88 137.76,86.22 136.41,87.57 133.78,87.57 133.41,87.94 131.65,87.94 131.32,87.6 131.32,86.93 131.43,86.81 131.59,86.81 132.04,86.37 v3(132.04,86.36)
  BOTTOM w0.076: U80.AP40 v3(126.75,63.72)
  BOTTOM w0.152: v3(132.04,86.36) 131.72,86.04 USM2002.M9
M_B_DQ<22>: length 33.4
  IN2 w0.076: v3(124.92,63.72) 124.39,64.25 124.39,65.15 124.23,65.31 124.23,65.89 124.02,66.09 124.02,66.2 124.23,66.41 124.23,66.82 124.04,67.01
  IN2 w0.114: 124.04,67.01 124.04,67.41 124.31,67.68 124.31,69.05 125.05,69.8 125.05,72.13 125.15,72.23 126.13,72.23 126.23,72.33 126.23,72.48 126.18,72.53 126.13,72.58 125.15,72.58 125.05,72.68 125.05,72.82 125.15,72.92 126.13,72.92 126.23,73.02 126.23,73.16 126.13,73.26 125.15,73.26 125.05,73.36 125.05,73.51 125.15,73.61 126.13,73.61 126.23,73.71 126.23,73.85 126.13,73.95 125.15,73.95 125.05,74.05 125.05,76.36 126.67,77.97 129.52,77.97 131.22,79.67 131.22,83.5 131.62,83.89 v3(132.01,83.89)
  BOTTOM w0.076: U80.AP37 v3(124.92,63.72)
  BOTTOM w0.152: v3(132.01,83.89) 131.92,83.89 131.72,84.1 USM2002.M11
M_B_DQ<23>: length 33.5
  IN2 w0.076: 124.57,67.5 124.57,66.29 124.52,66.24 124.52,65.28 124.56,65.24 124.56,64.72 v3(124.92,64.36)
  IN2 w0.114: v3(132.69,83.96) 132.24,83.51 131.83,83.51 131.56,83.25 131.56,79.48 129.67,77.58 126.74,77.58 125.48,76.32 125.48,74.46 125.65,74.29 126.45,74.29 126.58,74.16 126.58,71.81 126.48,71.71 125.51,71.71 125.41,71.61 125.41,71.46 125.51,71.36 126.48,71.36 126.58,71.26 126.58,71.12 126.48,71.02 125.51,71.02 125.41,70.92 125.41,70.78 125.51,70.68 126.48,70.68 126.58,70.58 126.58,70.44 126.48,70.34 125.51,70.34 125.41,70.24 125.41,69.91 125.51,69.81 125.59,69.81 125.69,69.71 125.69,69.57 125.59,69.47 125.51,69.47 125.41,69.36 125.41,69.22 125.51,69.12 125.59,69.12 125.69,69.02 125.69,68.88 125.59,68.78 125.51,68.78 125.41,68.68 125.41,68.42 125.3,68.3 125.13,68.3 125.01,68.43 124.81,68.43 124.61,68.23 124.61,68.03 124.76,67.89 124.76,67.69 124.57,67.5
  BOTTOM w0.076: U80.AR37 124.59,64.09 v3(124.92,64.36)
  BOTTOM w0.152: USM2002.N11 132.37,84.28 v3(132.69,83.96)
M_B_DQ<24>: length 27.1
  IN2 w0.076: 123.39,67.92 123.04,67.57 123.04,66.23 123.48,65.8 123.48,65.47 123.1,65.09 v3(123.1,64.99)
  IN2 w0.114: 123.39,67.92 123.39,69.98 123.84,70.43 123.84,76.87 126.33,79.35 128.99,79.35 129.65,80.02 129.65,80.98 129.54,81.09 127.54,81.09 127.04,81.6 127.04,83.51 127.49,83.96 v3(127.5,83.96)
  BOTTOM w0.076: v3(123.1,64.99) 122.92,64.85 U80.AT33
  BOTTOM w0.152: USM2002.E11 v3(127.5,83.96)
M_B_DQ<25>: length 22.5
  IN2 w0.076: 122.82,67.75 122.82,66.22 123.1,65.95 v3(123.1,65.63)
  IN2 w0.114: 122.82,67.75 123.08,68.01 123.08,70.43 123.52,70.88 123.52,78.16 126.2,80.84 126.2,83.96 126.59,84.36 127.09,84.36 127.49,84.76 v3(127.5,84.76)
  BOTTOM w0.076: U80.AU33 122.92,65.5 v3(123.1,65.63)
  BOTTOM w0.152: USM2002.E10 v3(127.5,84.76)
M_B_DQ<26>: length 23.8
  IN2 w0.114: v3(126.85,85.56) 126.84,85.57 126.47,85.57 125.29,84.39 125.29,84.25 124.46,83.41 124.46,82.99 123.93,82.46 123.93,81.04 120.97,78.09 120.97,69.23 120.92,69.17 120.92,65.97 v3(121.27,65.63)
  BOTTOM w0.076: v3(121.27,65.63) U80.AU30
  BOTTOM w0.152: USM2002.D9 v3(126.85,85.56)
M_B_DQ<27>: length 26
  IN2 w0.114: v3(121.27,64.99) 120.6,65.66 120.6,69.33 120.64,69.37 120.64,78.23 123.55,81.14 123.55,82.52 124.13,83.1 124.13,83.52 124.75,84.14 124.75,84.32 126.4,85.97 127.1,85.97 127.5,85.57 v3(127.5,85.56)
  BOTTOM w0.076: v3(121.27,64.99) U80.AT30
  BOTTOM w0.152: USM2002.E9 v3(127.5,85.56)
M_B_DQ<28>: length 27.7
  IN2 w0.076: 123.71,67.89 123.25,67.43 123.25,66.31 123.67,65.9 123.67,65.41 123.47,65.21 123.47,64.73 v3(123.1,64.36)
  IN2 w0.114: v3(128.08,83.9) 128.05,83.9 127.82,83.67 127.82,81.83 128.15,81.5 130.03,81.5 130.14,81.38 130.14,79.98 129.07,78.9 126.39,78.9 124.18,76.7 124.18,70.22 123.71,69.75 123.71,67.89
  BOTTOM w0.076: v3(123.1,64.36) 122.76,64.09 U80.AR33
  BOTTOM w0.152: v3(128.08,83.9) 127.9,84.08 127.9,84.2 USM2002.F11
M_B_DQ<29>: length 28.8
  IN2 w0.076: v3(123.1,63.72) 123.64,64.27 123.64,65.15 123.87,65.38 123.87,65.98 123.46,66.39 123.46,67.27 124.01,67.82
  IN2 w0.114: 124.01,67.82 124.01,69.36 124.63,69.98 124.63,76.54 126.52,78.43 129.28,78.43 130.57,79.72 130.57,81.59 129.88,82.28 128.96,82.28 128.34,82.91 128.34,83.51 128.47,83.64 128.47,84.44 128.15,84.76 v3(128.15,84.76)
  BOTTOM w0.076: U80.AP33 122.92,63.57 v3(123.1,63.72)
  BOTTOM w0.152: USM2002.F10 v3(128.15,84.76)
M_B_DQ<30>: length 28.5
  IN2 w0.076: v3(121.27,64.36) 120.76,64.86 120.76,65.11 120.28,65.59
  IN2 w0.114: v3(128.15,86.36) 128.15,86.37 127.74,86.77 126.62,86.77 124.42,84.57 123.9,84.57 122.7,83.37 122.7,82.55 122.6,82.44 122.6,80.69 120.33,78.42 120.33,69.56 120.28,69.51 120.28,65.59
  BOTTOM w0.076: v3(121.27,64.36) 120.94,64.09 U80.AR30
  BOTTOM w0.152: USM2002.F8 v3(128.15,86.36)
M_B_DQ<31>: length 27.1
  IN2 w0.079: v3(121.27,63.72) 121.74,64.19 121.74,66.85
  IN2 w0.114: 121.74,66.85 121.74,69.17 121.38,69.53 121.38,78.04 124.27,80.94 124.27,82.33 124.52,82.58 125.18,82.58 125.79,83.2 125.79,84.32 126.62,85.16 127.74,85.16 128.14,85.56 v3(128.15,85.56)
  BOTTOM w0.076: v3(121.27,63.72) U80.AP30
  BOTTOM w0.152: USM2002.F9 v3(128.15,85.56)
M_B_DQ<32>: length 26.8
  BOTTOM w0.076: 120.74,72.15 120.74,70.65 121.04,70.35 121.04,69.2 120.94,69.1 120.94,68.81 121.12,68.63 121.12,68.27 121.1,68.24 120.95,67.86 120.95,67.58 120.69,67.31 U80.AY31
  BOTTOM w0.152: 120.74,72.15 120.74,72.6 120.79,72.64 120.79,76.96 120.47,77.27 120.47,81.99 121.16,82.68 121.16,85.89 v1(121.11,85.94) 120.03,87.02 118.89,87.02 118.38,87.53 115.78,87.53 USM2003.R8
M_B_DQ<33>: length 23.2
  BOTTOM w0.076: U80.AW31 119.89,66.46 119.81,66.54 119.81,67.03 119.77,67.07 119.77,67.53 119.77,67.53 119.77,67.58 119.81,67.62 119.81,67.89 119.77,67.94 119.77,68.21 119.79,68.23 119.79,68.85 119.52,69.12 119.52,69.4 119.53,69.41 119.53,71.15 119.15,71.53 119.15,75.75 119.05,75.85 ; 117.21,85.65 116.95,85.65 116.87,85.57 115.9,85.57 USM2003.T9
  BOTTOM w0.152: 119.05,75.85 118.34,76.56 118.34,77.24 117.99,77.59 117.99,85.32 117.66,85.65 v1(117.5,85.65) 117.21,85.65
M_B_DQ<34>: length 21.6
  BOTTOM w0.076: 117.09,85.28 116.99,85.39 115.24,85.39 USM2003.R10 ; U80.AY29 119.46,67.45 119.6,67.6 119.6,67.65 119.61,67.66 119.61,67.88 119.6,67.89 119.6,68.25 119.61,68.26 119.61,68.31 119.61,68.31 119.61,68.75 119.35,69.01 119.35,71 118.85,71.5 118.85,75.55
  BOTTOM w0.152: 117.09,85.28 117.62,84.76 117.62,77.46 118,77.08 118,76.44 118.85,75.58 118.85,75.55
M_B_DQ<35>: length 21.3
  BOTTOM w0.076: U80.AW29 119.46,66.68 119.15,66.99 119.15,67.53 118.93,67.75 118.93,68.68 118.83,68.79 118.83,69.59 118.67,69.75 118.67,70.49 118.01,71.15 118.01,75.02 117.86,75.17
  BOTTOM w0.152: USM2003.R11 114.91,84.32 114.91,84.45 115,84.54 115.15,84.54 115.27,84.43 115.27,83.29 115.38,83.18 115.38,82.89 115.13,82.64 115.13,82.32 115.29,82.16 115.38,82.16 115.51,82.03 115.51,81.82 v1(114.65,80.96) 114.65,80.33 116.32,78.66 116.32,77.23 116.97,76.58 116.97,76.06 117.86,75.17
M_B_DQ<36>: length 23.8
  BOTTOM w0.076: 120.09,72.11 120.22,71.99 120.22,70.28 120.64,69.86 120.64,69.34 120.61,69.32 120.61,68.48 U80.BB31
  BOTTOM w0.152: USM2003.R9 114.94,85.89 115.43,86.38 117.12,86.38 117.34,86.16 119.38,86.16 v1(119.82,85.72) 120.45,85.1 120.45,83.28 119.56,82.39 119.56,76.96 120.09,76.43 120.09,72.11
M_B_DQ<37>: length 24.8
  BOTTOM w0.076: 120.44,72.13 120.44,70.52 120.85,70.11 120.85,69.28 120.78,69.21 120.78,68.74 120.95,68.56 120.95,68.3 120.83,68.05 120.83,68.05 120.83,68.05 120.69,67.91 U80.BA31
  BOTTOM w0.152: 120.44,72.13 120.44,76.72 119.97,77.19 119.97,82.2 120.8,83.03 120.8,85.54 119.73,86.61 v1(118.65,86.61) 118.11,87.15 116.01,87.15 115.59,86.73 USM2003.T8
M_B_DQ<38>: length 20.9
  BOTTOM w0.076: 118.24,75.26 118.31,75.18 118.31,71.33 118.89,70.76 118.89,69.77 119,69.65 119,68.88 119.09,68.79 119.09,68.25 119.36,67.99 U80.BA29
  BOTTOM w0.152: 118.24,75.26 117.3,76.2 117.3,76.76 116.68,77.38 116.68,79.49 116.53,79.64 115.89,79.64 115.1,80.44 115.1,80.65 115.45,81.01 116.53,81.01 116.62,81.1 v1(116.68,81.16) 116.68,83.68 116.53,83.83 115.74,83.83 115.59,83.99 USM2003.T11
M_B_DQ<39>: length 21.4
  BOTTOM w0.076: 118.47,75.49 118.59,75.37 118.59,71.4 119.1,70.9 119.1,69.87 119.17,69.8 119.17,68.95 119.36,68.76 U80.BB29 ; USM2003.T10 115.59,84.92 115.86,84.65 116.42,84.65 116.46,84.61 117.04,84.61
  BOTTOM w0.152: 117.04,84.61 117.27,84.38 117.27,83.48 117.02,83.24 117.02,82.84 117.27,82.6 117.27,82.26 117.02,82.02 117.02,81.62 117.27,81.38 117.27,80.76 117.11,80.61 116.35,80.61 116.19,80.45 116.19,80.24 116.34,80.09 117.09,80.09 117.25,79.94 117.25,79.68 117.03,79.46 117.03,79.05 117.27,78.81 117.27,78.48 v1(117.17,78.38) 117.05,78.26 117.05,77.52 117.65,76.91 117.65,76.31 118.47,75.49
