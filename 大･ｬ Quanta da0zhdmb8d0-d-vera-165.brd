# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 124.06,51.66 124.06,51.25 124.24,51.08 124.24,50.85 124.19,50.8 124.19,50.36 124.23,50.32 124.23,48.85 124.12,48.74 123.86,48.74 123.78,48.82 123.78,49.46 123.35,49.88 123.35,50.57 123.4,50.62 123.68,50.62 123.76,50.69 123.76,51.66 123.81,51.71 124.01,51.71
GND on TOP (solid shape): 205.43,30.77 205.43,29.88 205.99,29.32 205.99,27.57 206.29,27.26 209.19,27.26 209.62,27.69 211.88,27.69 211.96,27.62 211.96,26.32 211.7,26.07 209.67,26.07 209.36,26.37 206.27,26.37 205.83,25.94 204.61,25.94 204.44,26.12 204.44,30.56 204.69,30.82 205.38,30.82
GND on TOP (solid shape): 97.54,53.21 99.65,53.21 99.74,53.12 99.74,52.71 99.59,52.56 98.04,52.56 97.92,52.45 97.9,52.45 97.77,52.42 97.65,52.34 97.63,52.33 96.97,52.33 96.89,52.41 96.89,53.12 97.02,53.25 97.51,53.25
GND on TOP (solid shape): 160.58,32.72 165,32.72 165.5,32.22 165.5,32.03 164.45,30.99 163.79,30.99 163.55,30.74 163.55,29.6 163.52,29.57 162.69,29.57 162.66,29.61 162.66,31.36 162.05,31.97 160.67,31.97 160.1,31.39 157.85,31.39 157.72,31.52 157.72,31.77 157.51,31.98 157.51,32.53 158.17,33.19 160.11,33.19
GND on TOP (solid shape): 168.66,41.06 168.66,40.89 168.15,40.38 168.15,39.73 168.44,39.44 168.44,38.94 168.74,38.64 169.99,38.64 170.17,38.46 170.17,36.75 167.32,33.89 165.52,33.89 165.4,34 165.4,35.72 166.29,36.6 166.97,36.6 167.12,36.76 167.12,38.47 165.46,40.13 165.46,41.85 165.83,42.22 167.5,42.22
GND on TOP (solid shape): 169.8,78.54 169.8,78.31 169.67,78.18 169.5,78.18 169.14,77.83 169.14,76.74 168.89,76.48 168.19,76.48 168.12,76.55 168.12,76.76 168.28,76.91 168.58,76.91 168.71,77.04 168.71,77.75 168.61,77.85 168.05,77.85 168,77.9 168,78.34 168.07,78.41 169.19,78.41 169.47,78.69 169.65,78.69
GND on TOP (solid shape): 33.47,21.22 33.47,20.94 33.52,20.89 34.66,20.89 34.71,20.84 34.71,20.68 34.66,20.63 33.65,20.63 33.47,20.45 33.47,19.9 33.04,19.46 33.04,18.45 33.01,18.42 32.74,18.42 32.74,19.39 32.73,19.39 32.73,19.51 32.53,19.72 32.12,19.72 31.82,20.02 31.82,21.09 32.12,21.39 33.29,21.39
GND on TOP (solid shape): 150.95,88.98 150.95,87.96 150.83,87.84 150.47,87.84 150.32,87.68 150.32,86.85 150.45,86.72 150.8,86.72 150.98,86.54 150.98,85.78 150.95,85.75 150.7,85.75 150.7,85.76 150.11,85.17 149.3,85.17 149.18,85.29 149.18,88.17 149.33,88.32 150.32,88.32 150.5,88.5 150.5,89 150.6,89.11 150.83,89.11
GND on TOP (solid shape): 32.86,33.94 33.62,33.94 34.13,33.43 34.13,32.04 33.49,31.4 32.89,31.4 32.71,31.22 32.71,30.87 32.22,30.39 31.72,30.39 31.54,30.56 31.54,30.82 31.67,30.94 32.05,30.94 32.2,31.1 32.2,32.27 31.84,32.62 31.84,34.32 31.97,34.45 32.35,34.45
GND on TOP (solid shape): 47.67,59.7 47.67,57.06 47.41,56.8 46.98,56.8 46.88,56.9 46.88,57.31 46.93,57.36 46.93,58.91 46.8,59.04 43.78,59.04 43.65,58.91 43.65,58.28 43.78,58.15 43.78,56.37 43.71,56.29 43.17,56.29 43.12,56.34 43.12,58.88 42.92,59.09 42.33,59.09 42.26,59.16 42.26,59.8 42.38,59.93 47.44,59.93
GND on TOP (solid shape): 144.68,55.72 144.68,54.65 144.57,54.54 144.04,54.54 143.98,54.59 143.98,54.82 144.1,54.94 144.1,55.44 144.07,55.47 143.65,55.47 143.44,55.26 143.44,54.99 142.9,54.46 142.24,54.46 142.19,54.51 142.19,54.92 142.32,55.05 142.68,55.05 142.98,55.35 143.14,55.35 143.59,55.8 144.59,55.8
GND on TOP (solid shape): 31.59,66.76 31.59,65.95 31.61,65.92 31.61,65.9 32.1,65.42 32.1,62.39 32.03,62.32 32,62.3 31.97,62.28 31.89,62.19 31.31,62.19 31.21,62.29 31.21,64.28 31.31,64.38 31.31,64.4 31.34,64.42 31.34,66.78 31.35,66.82 31.39,66.84 31.51,66.84
GND on TOP (solid shape): 39.21,71.03 39.21,67.47 38.96,67.22 32.48,67.22 32.1,67.6 32.1,67.74 32.15,67.93 32.1,68.11 32.1,68.23 32.22,68.36 35.15,68.36 35.78,68.99 35.78,70.52 35.53,70.77 33.11,70.77 32.99,70.9 32.99,71.79 33.11,71.92 38.32,71.92
GND on TOP (solid shape): 105.48,35.39 105.48,34.35 105.25,34.12 104.28,34.12 104.15,34.25 104.15,34.28 104.15,34.3 104.17,34.52 104.05,34.71 104.03,34.72 104.03,34.75 104.03,34.92 103.85,35.09 103.85,35.36 104.21,35.72 105.15,35.72
GND on TOP (solid shape): 63.72,95.13 63.72,89.87 63.59,89.75 53.99,89.75 53.92,89.67 53.92,82.56 53.87,82.51 53.05,82.51 52.87,82.69 52.87,92.32 53.18,92.98 53.28,93.7 53.28,94.78 53.71,95.21 63.64,95.21
GND on TOP (solid shape): 129.03,86.44 129.03,85.45 129.26,85.22 129.59,85.22 129.8,85.43 129.8,85.67 129.83,85.7 130.87,85.7 131,85.57 131,85.34 130.88,85.22 130.43,85.22 130.23,85.02 129.87,85.02 129.69,84.84 129.69,84.61 129.59,84.51 129.36,84.51 129.21,84.66 129.21,84.81 128.73,85.3 128.7,85.3 128.55,85.45 128.55,86.44 128.7,86.59 128.88,86.59
GND on TOP (solid shape): 132.92,90.3 132.92,88.52 132.92,88.52 132.99,88.45 132.99,87.92 132.91,87.84 132.3,87.84 132.02,87.56 131.51,87.56 131.23,87.28 131.23,87.21 131.01,86.98 130.75,86.98 130.65,87.08 130.65,87.31 131.15,87.81 131.15,88.85 131.26,88.96 131.59,88.96 131.8,89.17 131.8,90.33 131.93,90.45 132.77,90.45
GND on TOP (solid shape): 21.15,48.34 21.18,48.33 21.2,48.29 21.2,47.72 21.2,47.72 21.2,47.53 21.35,47.38 21.86,47.38 21.99,47.25 21.99,42.68 21.86,42.55 20.34,42.55 20.21,42.68 20.21,47.25 20.34,47.38 20.72,47.38 21,47.66 21,47.72 21,47.72 21,48.29 21.02,48.33 21.05,48.34
GND on TOP (solid shape): 64.9,70.72 65.12,70.64 65.34,70.72 66.16,70.72 66.24,70.65 66.24,68.94 66.11,68.81 65.91,68.71 65.81,68.51 64.84,67.55 63.37,67.55 63.09,67.83 63.09,69.02 64.79,70.72
GND on TOP (solid shape): 109.65,91.11 109.65,90.1 109.55,89.99 109.15,89.99 108.99,89.84 108.99,88.98 109.1,88.88 109.5,88.88 109.65,88.72 109.65,88.49 109.92,88.22 109.92,87.51 109.82,87.41 108.86,87.41 108.73,87.54 107.97,87.54 107.71,87.28 107.49,87.28 107.36,87.41 107.36,87.71 107.88,88.23 107.88,90.3 108.03,90.45 109.1,90.45 109.2,90.55 109.2,91.18 109.29,91.27 109.5,91.27
GND on TOP (solid shape): 112.85,86.39 112.85,85.93 112.91,85.88 112.91,85.37 112.8,85.27 112.55,85.27 112.24,84.97 112.24,84.61 112.14,84.51 111.94,84.51 111.79,84.66 111.79,84.81 111.61,84.99 111.13,84.99 110.97,84.84 110.97,84.64 110.85,84.51 110.62,84.51 110.49,84.64 110.49,85.02 110.62,85.14 110.8,85.14 111.08,85.42 111.08,85.6 111.15,85.68 111.84,85.68 112.35,86.18 112.35,86.34 112.5,86.49 112.75,86.49
GND on TOP (solid shape): 18.36,59.01 18.36,57.97 18.43,57.89 18.92,57.89 18.94,57.87 18.94,56.62 18.89,56.57 18.43,56.57 18.36,56.5 18.36,55.46 18.41,55.41 18.89,55.41 18.92,55.38 18.92,54.41 18.76,54.26 18.38,54.26 18.25,54.14 18.25,53.5 18.13,53.37 17.62,53.37 17.49,53.5 17.49,54.01 17.11,54.39 17.11,54.94 17.21,55.05 17.21,55.99 17.14,56.07 17.14,57.36 17.21,57.43 17.21,58.48 17.14,58.56 17.14,59.04 17.19,59.09 18.28,59.09
GND on TOP (solid shape): 120.88,64.39 120.88,63.58 121.08,63.38 121.49,63.38 121.64,63.53 121.64,63.88 121.74,63.99 122.66,63.99 122.76,63.88 122.76,63.48 122.86,63.38 123.37,63.38 123.47,63.48 123.47,64.44 123.57,64.54 124.44,64.54 124.59,64.39 124.59,63.43 124.64,63.38 125,63.38 125.15,63.22 125.15,63.02 125,62.87 123.06,62.87 122.78,62.59 121.66,62.59 121.46,62.8 120.29,62.8 119.91,63.18 119.91,64.37 120.14,64.6 120.67,64.6
GND on TOP (solid shape): 14.75,22.46 14.75,21 13.69,19.95 4.17,19.95 3.86,20.26 3.86,20.99 4.01,21.14 10.82,21.14 11.78,20.57 12.73,21.14 12.86,21.14 12.86,22.82 14.39,22.82
GND on TOP (solid shape): 157.43,89.77 157.43,86.36 156.8,85.73 156.34,85.73 156.34,88.27 156.14,88.47 155.78,88.47 155.48,88.17 155.48,86.36 155.47,86.36 155.47,85.69 155.06,85.28 154.3,85.28 154.25,85.33 154.25,85.86 153.72,86.39 153.72,86.57 153.88,86.72 154.31,86.72 154.38,86.79 154.38,88.37 154.54,88.52 155.37,88.52 155.63,88.78 155.63,88.98 155.4,89.21 154.94,89.21 154.92,89.23 154.92,89.46 154.94,89.49 155.45,89.49 155.6,89.33 156.8,89.33 156.95,89.49 156.95,89.74 157.1,89.89 157.3,89.89
GND on TOP (solid shape): 116.16,91.93 116.16,88.06 116.15,88.06 116.15,87.97 116.04,87.86 115.09,87.86 115.04,87.91 115.04,90.29 115.05,90.34 115.04,90.35 114.78,90.61 114.51,90.61 114.18,90.27 114.18,88.52 114.02,88.37 113.72,88.37 113.48,88.13 113.48,87.84 113.33,87.69 112.95,87.69 112.84,87.79 112.84,88.13 112.45,88.52 112.45,88.72 112.6,88.88 112.91,88.88 113.06,89.03 113.06,90.53 113.18,90.66 114.07,90.66 114.38,90.96 114.38,91.26 114.57,91.46 115.44,91.46 115.7,91.72 115.7,91.98 115.8,92.08 116,92.08
GND on TOP (solid shape): 140.4,53.53 140.4,52.97 140.25,52.81 140.25,52.18 140.17,52.1 138.9,52.1 138.65,51.85 138.65,51.39 139.82,50.23 139.82,50.05 139.72,49.95 139.65,49.95 139.41,49.71 139.01,49.71 138.78,49.93 138.36,49.93 137.95,49.52 137.95,48.85 137.8,48.69 137.64,48.69 137.54,48.8 137.54,50.12 137.59,50.17 138.06,50.17 138.1,50.21 138.1,50.55 138.13,50.59 138.13,51.12 137.94,51.32 137.84,51.32 137.74,51.42 137.74,51.75 137.84,51.85 138.12,51.85 138.73,52.46 138.73,53.12 138.88,53.27 139.46,53.27 139.74,53.55 140.38,53.55
GND on TOP (solid shape): 24.4,10.47 24.43,10.47 24.83,10.07 24.96,10.06 25.26,10.06 25.3,10.07 25.54,10.07 25.6,10.12 26.01,10.12 26.06,10.07 27.8,10.07 27.85,10.12 28.03,10.12 28.16,9.99 28.16,9.35 28.01,9.2 23.79,9.2 23.77,9.18 21.86,9.18 21.25,8.57 20.97,8.57 20.67,8.26 20.52,8.26 20.13,7.88 19.65,7.88 19.32,8.21 19.32,9.05 19.5,9.23 19.98,9.23 20.72,9.96 20.9,9.96 20.9,9.99 20.92,10.02 21.68,10.02 21.81,9.89 23.59,9.89 24.2,10.5 24.38,10.5
GND on TOP (solid shape): 52.61,28.29 52.61,27.85 52.22,27.46 52.22,24.57 52.03,24.32 52.11,24.03 52.11,24.02 52.13,23.98 52.01,23.86 50.16,23.86 49.35,24.67 48.09,24.67 47.73,25.02 47.73,25.92 47.76,25.93 47.95,26.25 47.76,26.56 47.73,26.57 47.73,27.76 48.34,28.37 52.53,28.37
GND on TOP (solid shape): 87.77,90 87.77,84.11 87.62,83.95 86.71,83.95 86.53,84.13 86.53,89.06 86.25,89.34 83.7,89.34 83.61,89.25 78.74,89.25 78.73,89.25 78.35,89.25 77.83,88.73 77.83,87.65 77.73,87.54 77.3,87.54 77.28,87.56 77.03,87.56 76.84,87.75 76.84,88.16 76.66,88.34 76.66,88.9 76.52,89.04 75.89,89.04 75.7,88.85 75.7,88.43 75.16,87.89 75.16,87.27 74.96,87.07 73.91,87.07 73.9,87.08 73.88,87.09 73.71,87.26 73.71,87.79 72.66,88.84 72.66,89.84 73.06,90.25 83.25,90.25 83.54,90.53 87.24,90.53
GND on TOP (solid shape): 164.01,78.56 164.01,78.31 164.42,77.9 165.13,77.9 165.28,77.75 165.28,77.55 165.56,77.27 166.14,77.27 166.27,77.14 166.52,77.14 166.75,77.37 166.75,77.78 166.85,77.88 167.06,77.88 167.26,77.68 167.26,76.79 167.06,76.58 166.83,76.58 166.55,76.3 166.55,75.59 166.68,75.47 167.08,75.47 167.21,75.34 167.21,75.11 167.08,74.98 166.22,74.98 166.09,75.11 166.09,75.64 165.94,75.8 165.58,75.8 165.46,75.92 165.46,76.15 165.56,76.25 165.99,76.25 166.12,76.38 166.12,76.81 165.97,76.96 165.46,76.96 165.03,77.4 164.26,77.4 164.11,77.55 164.11,77.75 163.76,78.11 162.84,78.11 162.74,78.21 162.74,78.65 162.8,78.72 163.86,78.72
GND on TOP (solid shape): 23.28,69.25 23.28,67.57 23.23,67.52 21.13,67.52 20.86,67.25 20.81,67.25 20.81,66.3 20.8,66.27 20.76,66.25 20.59,66.25 20.55,66.29 20.55,66.37 20.55,66.57 20.34,66.77 20.29,66.77 20.2,66.8 20.12,66.81 19.62,66.81 19.59,66.77 19.48,66.77 19.47,66.78 19.37,66.8 19.27,66.81 19.25,66.81 19.23,66.82 19.17,66.89 19.17,67.19 19.35,67.37 20.44,67.37 20.46,67.39 20.46,69.07 20.67,69.27 23.26,69.27
GND on TOP (solid shape): 126.08,58 126.08,57.76 126.01,57.69 126.01,57.53 125.92,57.45 125.92,56.89 126,56.82 126.42,56.82 126.45,56.79 126.45,56.23 126.57,56.11 126.57,55.33 126.79,55.11 126.79,54.54 126.61,54.36 125.01,54.36 124.91,54.26 124.53,54.26 124.43,54.36 124.43,54.8 124.66,55.03 125.43,55.03 125.76,55.36 125.76,55.82 125.3,56.27 125.3,56.49 125.14,56.65 125.09,56.65 125.01,56.73 125.01,57.11 125.11,57.21 125.11,57.34 124.96,57.49 124.79,57.49 124.74,57.53 124.69,57.53 124.65,57.55 124.64,57.58 124.64,57.74 124.69,57.79 124.98,57.79 125.04,57.72 125.43,57.72 125.65,57.94 125.65,58 125.67,58.02 126.05,58.02
GND on TOP (solid shape): 123.59,58.08 123.59,57.27 123.58,57.26 123.33,57.26 123.23,57.23 123.16,57.16 123.16,57.16 123.1,57.1 123.1,56.82 123.1,56.82 123.1,56.54 123.26,56.38 123.66,56.38 123.8,56.24 123.8,55.29 123.74,55.23 123.14,55.23 123.12,55.2 123.12,54.99 123.01,54.89 122.4,54.89 122.38,54.92 122.37,54.94 122.37,54.95 122.36,55.07 122.3,55.17 122.3,55.76 122.38,55.83 122.38,56.8 122.38,56.8 122.38,57.5 122.38,57.52 122.4,57.53 122.63,57.76 122.63,57.85 122.7,57.92 123.06,57.92 123.14,58 123.14,58.01 123.17,58.04 123.17,58.04 123.17,58.12 123.24,58.19 123.48,58.19
GND on TOP (solid shape): 173.56,78.57 173.56,77.4 173.47,77.31 173.47,76.56 173.69,76.35 173.69,75.79 173.56,75.66 173.27,75.66 173.19,75.58 173.19,75.06 173.09,74.96 172.75,74.96 172.57,75.14 172.57,77.02 172.39,77.19 172.04,77.19 171.73,76.89 171.73,74.82 171.09,74.18 170.4,74.18 170.25,74.33 170.25,74.87 169.98,75.14 169.98,75.48 170.1,75.6 170.42,75.6 170.64,75.82 170.64,76.94 170.82,77.12 171.27,77.12 171.45,77.29 171.76,77.39 171.86,77.7 172.24,78.08 172.93,78.08 173.23,78.39 173.23,78.54 173.36,78.67 173.46,78.67
GND on TOP (solid shape): 23.21,18.68 23.21,18.32 23.11,18.22 23.11,17.05 23.23,16.92 24.86,16.92 25.11,16.67 25.11,12.99 25.24,12.86 25.62,12.86 26,12.48 26,11.84 25.91,11.76 24.95,11.76 24.81,11.89 24.81,12.94 24.63,13.11 23.72,13.11 23.61,13.01 23.61,12.91 23.61,12.91 23.61,11.92 23.61,11.92 23.61,11.79 23.87,11.54 23.87,11.31 23.72,11.16 23.59,11.16 23.21,11.54 23.21,11.64 23.31,11.74 23.31,12.94 23.13,13.11 21.56,13.11 21.43,13.24 21.43,14.51 21.3,14.64 20.16,14.64 20.11,14.69 20.11,14.87 20.16,14.92 21.35,14.92 21.43,14.99 21.43,16.8 21.56,16.92 22.65,16.92 22.8,17.08 22.8,17.12 22.81,17.12 22.81,18.11 22.8,18.11 22.73,18.19 22.73,18.7 22.85,18.83 23.06,18.83
GND on TOP (solid shape): 117.82,59.55 117.82,56.37 117.92,56.26 117.92,55.34 117.8,55.21 117.22,55.21 117.07,55.36 117.07,56.21 116.9,56.39 115.82,56.39 115.64,56.56 115.64,56.77 115.85,56.98 115.85,58.07 115.75,58.12 115.68,58.19 115.68,59.3 115.76,59.38 116.25,59.38 116.35,59.28 116.35,57.28 116.65,56.98 117.04,56.98 117.16,57.09 117.16,57.26 117.17,57.36 117.16,57.45 117.16,57.8 117.16,57.81 117.2,57.97 117.16,58.12 117.16,58.13 117.16,58.48 117.17,58.58 117.16,58.67 117.16,59.09 117.17,59.18 117.16,59.28 117.16,59.49 117.29,59.62 117.74,59.62
GND on TOP (solid shape): 183.39,44.98 183.39,44.12 184,43.51 184.4,43.51 185.36,42.55 186.1,42.55 186.1,42.56 187.95,44.41 189.17,44.41 190.15,43.44 190.15,42.36 190.69,41.81 190.69,41.49 190.5,41.3 189.71,41.3 189.12,41.88 188.43,41.88 188.43,41.71 188.25,41.53 187.85,41.53 187.51,41.19 187.51,41.11 187.52,41.1 187.52,38.94 187.49,38.92 185.84,38.92 185.09,39.66 185.09,40.58 184.64,41.03 184.64,41.03 184.25,41.43 180.81,41.43 180.32,41.92 180.31,41.92 180.25,42.01 180.16,42.08 180.15,42.08 179.61,42.62 178.95,42.62 178.63,42.3 178.63,40.71 178.36,40.44 177.51,40.44 175.8,42.14 173.99,42.14 173.3,42.83 173.3,44.66 173.68,45.04 174.98,45.04 176.26,43.76 178.57,43.76 179.09,44.29 179.63,44.29 179.8,44.46 179.8,45.25 180.05,45.5 182.87,45.5
GND on TOP (solid shape): 78.94,72.09 79.81,72.09 79.93,72.08 80.02,72.09 80.03,72.09 80.69,72.09 81.3,71.48 81.3,70.8 81.1,70.6 79.41,70.6 79.39,70.62 79.39,70.65 78.94,70.99 78.73,70.47 78.73,70.39 78.33,69.98 75.58,69.98 75.4,70.16 75.4,70.82 75.46,70.87 77.34,70.87 77.63,71.17 77.66,71.16 77.69,71.16 77.97,71.16 78,71.16 78.04,71.17 78.16,71.17 78.25,71.25 78.25,72.3 78.33,72.37 78.66,72.37
GND on TOP (solid shape): 145.09,52.09 145.09,51.23 144.95,51.08 144.61,51.08 144.57,51.12 144.57,51.27 144.49,51.35 144.05,51.35 143.97,51.27 143.97,50.93 143.9,50.86 143.56,50.86 143.45,50.98 142.97,50.98 142.84,50.86 142.84,50.53 142.93,50.44 144.7,50.44 144.9,50.25 144.9,50 144.76,49.87 144.54,49.87 144.34,50.07 143.12,50.07 143.08,50.03 143,49.98 142.95,49.9 142.92,49.87 142.92,49.36 142.67,49.11 141.99,49.11 141.83,49.27 141.56,49.27 141.35,49.05 141.35,48.08 141.27,48 140.47,48 140.34,48.13 140.34,49.7 140.41,49.77 141.05,49.77 141.09,49.74 141.94,49.74 142.12,49.92 142.12,50.47 141.98,50.62 141.26,50.62 140.94,50.93 140.66,50.93 140.35,51.24 140.35,51.67 140.53,51.84 140.74,51.84 140.95,52.05 141.68,52.05 141.86,51.87 141.86,51.64 141.65,51.43 141.65,51.1 141.74,51.02 141.76,51.02 141.79,50.99 141.79,50.98 142.37,50.98 142.37,51.1 143.31,52.04 143.34,52.04 143.57,52.27 144.91,52.27
GND on TOP (solid shape): 14.36,17.69 14.61,16.49 14.12,15.37 14.12,11.48 14.52,10.8 14.62,10.01 14.37,9.76 13.61,9.76 13.55,9.81 13.55,10.5 13.11,11.02 13.11,15.83 13.56,16.41 13.51,17.14 13.51,17.46 13.73,17.69
GND on TOP (solid shape): 37.66,22.51 37.66,21.57 37.91,21.32 38.45,21.32 38.57,21.19 38.57,21.01 38.7,20.89 38.87,20.89 38.87,20.88 39.81,20.88 39.87,20.81 39.87,20.63 39.82,20.58 38.65,20.58 38.57,20.51 38.57,19.82 38.17,19.41 38.17,18.32 38.24,18.24 38.98,18.24 39.03,18.3 39.51,18.3 39.9,17.91 39.9,12.78 36.49,9.38 32.1,9.38 31.56,9.91 31.56,12.38 31.11,12.83 31.11,13.47 31.18,13.55 31.89,13.55 32.38,13.06 33.44,13.06 33.7,13.32 33.7,14.05 33.94,14.3 34.23,14.3 34.56,13.96 34.56,12.17 34.82,11.92 35.83,11.92 36.14,12.23 36.14,12.96 36.26,13.09 38.5,13.09 38.54,13.13 38.62,13.19 38.69,13.28 38.78,13.37 38.78,17.28 37.86,18.19 37.86,18.38 37.87,18.38 37.87,19.39 37.76,19.49 37.3,19.49 37.02,19.78 37,19.8 37,19.82 37,21.17 37.15,21.32 37.23,21.32 37.38,21.47 37.38,22.56 37.41,22.59 37.58,22.59
GND on TOP (solid shape): 13.1,39.68 13.1,37.65 14.78,35.97 14.78,34.55 14.42,34.2 12.86,34.2 12.86,35.86 12.73,35.86 11.78,36.43 10.82,35.86 8.35,35.86 6.06,35.86 3.86,35.86 3.86,36.75 3.6,37.42 2.97,37.75 2.46,37.75 2.46,39.74 7.74,39.74 8.57,39.54 9.06,40.25 9.06,42.07 10.71,42.07
GND on TOP (solid shape): 84.2,44.08 84.36,43.99 84.57,43.99 84.59,43.98 85.18,43.39 85.18,40.91 85.18,40.89 85.16,40.87 85.03,40.6 85.16,40.32 85.18,40.3 85.18,40.28 85.18,38.11 84.96,37.88 84.34,37.88 84.31,37.89 84.3,37.91 83.98,38.11 83.66,37.91 83.65,37.89 83.62,37.88 82.85,37.88 82.75,37.97 82.75,38.13 82.7,38.18 82.7,38.18 82.64,38.26 82.57,38.32 82.56,38.32 82.26,38.62 80.64,38.62 80.48,38.77 80.48,43.37 80.61,43.49 81.63,43.49 82.19,44.05 82.39,44.05 82.42,44.03 82.42,43.67 82.62,43.47 83.56,43.47 83.63,43.54 83.63,43.95 83.67,44.02 83.74,44.05 83.82,44.05 83.9,44.08
GND on TOP (solid shape): 105.28,74.28 105.84,74.28 105.89,74.23 106.24,74.23 107,73.46 107.23,73.46 107.54,73.16 107.54,72.55 107.66,72.42 108.93,72.42 109.19,72.68 109.19,73.26 109.46,73.53 109.46,73.83 109.57,73.95 109.82,73.95 109.95,73.82 109.95,73.61 109.82,73.48 109.82,72.16 109.69,72.04 109.44,72.04 109.39,71.99 109.38,71.99 109.28,71.93 109.22,71.83 109.22,71.82 108.81,71.41 108.3,71.41 108.04,71.15 108.03,71.13 107.94,70.89 108.04,70.65 108.04,70.26 107.92,70.14 107.54,70.14 107.41,70.26 107.41,70.39 107.15,70.65 107.06,70.65 106.83,70.74 106.59,70.66 106.57,70.65 106.52,70.65 106.39,70.77 106.39,71.53 106.38,71.55 106.38,72.46 106.39,72.47 106.42,72.63 106.39,72.78 106.38,72.79 106.38,73.03 106.46,73.34 106.25,73.59 106.24,73.6 106.22,73.62 105.91,73.62 105.66,73.36 105.07,73.36 104.82,73.62 104.82,74.2 104.89,74.28
GND on TOP (solid shape): outline of 97 points within 116.4,52.04 121.86,62.72
GND on TOP (solid shape): 6.34,63.41 6.34,63.14 5.87,62.12 6.9,61.68 7.38,61.68 7.92,62.21 12.26,62.21 13.96,60.51 13.96,57.97 12.64,56.65 12.64,55.79 10.69,53.83 9.06,53.83 9.06,55.75 8.57,56.46 7.74,56.26 5.94,56.26 2.46,56.26 2.46,58 2.16,58.71 1.45,59.01 0.51,59.01 0.51,61.02 3.22,61.02 4.18,60.45 5.13,61.02 5.26,61.02 5.26,62.92 5.91,63.58 6.17,63.58
GND on TOP (solid shape): outline of 158 points within 124.67,87.76 128.4,92.46
GND on TOP (solid shape): outline of 379 points within 127.09,71.37 132.89,77.3
GND on TOP (solid shape): outline of 1583 points within 126.31,48.01 171.24,70.74
GND on TOP (solid shape): outline of 362 points within 0.51,0.51 236.24,98.39
GND on BOTTOM (solid shape): 29.63,31.73 29.63,30.06 29.61,30.03 27.91,30.03 27.88,30.06 27.88,31.73 27.93,31.78 29.58,31.78
GND on BOTTOM (solid shape): 37.05,52.1 37.05,46.9 36.92,46.77 31.59,46.77 31.34,47.02 31.34,52.36 31.46,52.48 36.67,52.48
GND on BOTTOM (solid shape): 45.93,24.89 45.93,23.77 45.76,23.6 40.8,23.6 40.44,23.96 40.44,25.25 40.63,25.43 45.38,25.43
GND on BOTTOM (solid shape): 51.33,27.49 51.33,24.87 51.27,24.82 48.68,24.82 48.63,24.87 48.63,27.49 48.68,27.54 51.27,27.54
GND on BOTTOM (solid shape): 60.7,59.42 60.7,56.01 60.6,55.91 57.32,55.91 57.14,56.09 57.14,59.39 57.32,59.57 60.55,59.57
GND on BOTTOM (solid shape): 79.85,96.78 79.85,95.79 79.77,95.71 66.39,95.71 65.78,96.32 65.78,96.71 65.94,96.87 79.76,96.87
GND on BOTTOM (solid shape): 103.65,94.04 103.65,92.57 103.42,92.34 102.58,92.34 102.46,92.46 102.46,94.14 102.58,94.27 103.42,94.27
GND on BOTTOM (solid shape): 106.1,78.85 106.1,77.51 105.87,77.29 105.19,77.29 104.9,77.57 104.9,78.86 104.99,78.95 106,78.95
GND on BOTTOM (solid shape): 144.55,86.44 144.55,85.98 144.25,85.68 142.01,85.68 141.86,85.83 141.86,86.18 142.22,86.54 144.45,86.54
GND on BOTTOM (solid shape): 162.89,84.86 162.89,84.56 162.74,84.41 161.17,84.41 160.2,85.37 160.2,85.88 160.25,85.93 161.83,85.93
GND on BOTTOM (solid shape): 171.09,19.49 171.09,18.27 170.88,18.07 168.19,18.07 167.86,18.4 167.86,19.36 168,19.51 171.07,19.51
GND on BOTTOM (solid shape): 179.68,37.8 179.68,37.08 179.29,36.69 178.34,36.69 177.96,37.08 177.96,37.8 178.05,37.9 179.59,37.9
GND on BOTTOM (solid shape): 180.64,31.2 180.64,29.65 179.85,28.86 175.82,28.86 174.34,30.34 174.34,31.16 174.44,31.26 180.58,31.26
GND on BOTTOM (solid shape): 182.29,19.44 182.29,18.45 181.96,18.12 179.95,18.12 179.72,18.35 179.72,19.34 179.89,19.51 182.22,19.51
GND on BOTTOM (solid shape): 199.97,51.44 199.97,50.25 199.33,49.61 195.95,49.61 195.83,49.74 195.83,52.53 195.9,52.61 198.8,52.61
GND on BOTTOM (solid shape): 205.94,16.7 205.94,15.15 205.91,15.12 204.28,15.12 204.26,15.15 204.26,16.72 204.36,16.82 205.81,16.82
GND on BOTTOM (solid shape): 231.36,31.1 231.36,30.03 231.01,29.67 228.67,29.67 228.49,29.85 228.49,31.35 228.64,31.5 230.95,31.5
GND on BOTTOM (solid shape): 64.85,24.48 64.85,22.71 64.86,22.69 64.86,21.88 64.64,21.65 63.77,21.65 63.54,21.88 63.54,24.69 63.69,24.85 64.48,24.85
GND on BOTTOM (solid shape): 74.61,20.93 74.61,18.78 74.38,18.56 69.64,18.56 69.47,18.73 69.47,19.43 70.61,20.58 70.61,21.08 70.94,21.41 74.12,21.41
GND on BOTTOM (solid shape): 76.04,38.87 76.04,38.36 75.66,37.98 74.72,37.98 74.62,38.08 74.62,38.49 74.67,38.54 75.05,38.54 75.48,38.97 75.94,38.97
GND on BOTTOM (solid shape): 81.67,43.54 85.23,43.54 85.31,43.47 85.31,38.64 85.18,38.51 80.23,38.51 80.1,38.64 80.1,43.47 80.23,43.59 81.62,43.59
GND on BOTTOM (solid shape): 231.39,13.55 231.39,11.97 231.26,11.84 228.67,11.84 228.54,11.97 228.54,13.6 228.64,13.7 231.23,13.7
GND on BOTTOM (solid shape): 119.42,90.79 119.42,90.2 119.4,90.18 118.43,90.18 118.39,90.15 118.04,90.15 117.88,90.3 117.88,90.71 118.04,90.86 119.35,90.86
GND on BOTTOM (solid shape): 55.38,27.92 55.38,25 55.25,24.87 54.17,24.87 54.03,25.01 54.03,25.51 54.03,26.89 54.69,27.55 54.69,27.99 54.8,28.11 55.18,28.11
GND on BOTTOM (solid shape): 78.45,16.64 78.45,15.93 78.38,15.86 77.72,15.86 77.31,15.45 77.31,14.1 77.16,13.95 75.81,13.95 75.61,14.16 75.61,16.77 75.86,17.03 78.07,17.03
GND on BOTTOM (solid shape): 80.79,52.03 80.79,50.25 80.77,50.21 80.74,50.2 77.73,50.2 77.18,50.74 77.18,51.82 77.6,52.23 80.59,52.23
GND on BOTTOM (solid shape): 83.56,31.15 83.56,29.9 83.56,29.47 82.92,28.84 81.81,28.84 81.77,28.87 81.77,30.68 81.93,30.84 81.93,31.48 82.06,31.61 83.1,31.61
GND on BOTTOM (solid shape): 139.22,93.86 139.22,90.25 139.07,90.1 138.64,90.1 138.61,90.13 138.61,91.19 138.52,91.27 138.52,92.45 137.34,93.63 137.34,95.33 137.39,95.38 137.7,95.38
GND on BOTTOM (solid shape): 177.39,82.61 177.39,81.85 177.51,81.72 177.94,81.72 178.07,81.59 178.07,81.08 177.94,80.96 176.65,80.96 176.5,81.11 176.5,82.63 176.65,82.79 177.21,82.79
GND on BOTTOM (solid shape): 23.18,69.02 23.18,67.74 23.11,67.67 21.94,67.67 21.87,67.6 20.79,67.6 20.67,67.72 20.67,68.11 20.54,68.23 20.03,68.23 19.91,68.36 19.91,68.99 20.16,69.25 22.95,69.25
GND on BOTTOM (solid shape): 63.72,95.13 63.72,87.54 63.26,87.54 63.19,87.61 63.19,88.27 62.88,88.58 62.5,88.58 62.4,88.68 62.4,92.97 53.66,92.97 53.28,93.35 53.28,94.75 53.74,95.21 63.64,95.21
GND on BOTTOM (solid shape): 171.59,58.2 171.59,57.06 171.49,56.95 159.61,56.95 159.48,56.83 159.48,55.79 159.15,55.46 153.87,55.46 153.61,55.71 153.61,56.47 153.79,56.65 157.45,56.65 159.38,58.58 171.21,58.58
GND on BOTTOM (solid shape): 42.41,20.91 43.63,20.91 43.86,20.68 43.86,19.69 43.44,19.27 40.62,19.27 40.16,19.73 40.16,20.72 40.23,20.78 41.52,20.78 41.8,21.06 42.26,21.06
GND on BOTTOM (solid shape): 83.71,90.08 83.71,89.45 83.51,89.25 78.56,89.25 78.14,88.83 78.14,88.43 77.93,88.22 76.81,88.22 76.66,88.37 76.66,89.74 77.17,90.25 83.54,90.25
GND on BOTTOM (solid shape): 116.47,54.28 116.47,54.22 116.49,54.16 116.49,53.72 116.56,53.65 116.87,53.65 116.99,53.52 116.99,53.24 116.89,53.14 115.93,53.14 115.8,53.27 115.8,54.37 115.91,54.48 116.26,54.48
GND on BOTTOM (solid shape): 191.94,63.25 191.94,60.18 191.69,59.93 173.83,59.93 173.63,60.13 173.63,61.6 175.96,63.94 181.75,63.94 183.15,62.54 188.38,62.54 188.97,63.13 188.97,64.19 189.53,64.75 190.44,64.75
GND on BOTTOM (solid shape): 18.94,57.18 18.94,54.47 18.83,54.35 17.07,54.35 16.98,54.44 16.98,54.8 17.19,55 17.19,55.17 17.26,55.25 17.26,56.27 17.24,56.3 17.24,57.21 17.24,57.21 17.24,57.26 17.37,57.39 18.74,57.39
GND on BOTTOM (solid shape): 57.45,17.48 57.45,14.98 56.7,14.23 51.39,14.23 51.1,14.52 51.1,15.81 51.44,16.14 54.99,16.14 55.29,16.44 55.29,16.92 54.74,17.46 54.08,17.46 54,17.54 54,18.35 54.04,18.4 56.53,18.4
GND on BOTTOM (solid shape): 189.53,31.3 189.53,29.95 189.48,29.9 188.18,29.9 188.18,29.9 186.07,29.9 185.98,29.81 185.19,29.81 184.68,29.29 184.68,26.27 184.57,26.17 181.86,26.17 181.68,26.35 181.68,30.16 182.87,31.35 189.48,31.35
GND on BOTTOM (solid shape): 19.99,38.04 19.99,36.65 20.24,36.41 21.02,36.41 21.18,36.56 21.66,36.56 21.81,36.41 21.81,35.42 21.66,35.26 16.91,35.26 16.48,34.83 15.84,34.83 15.71,34.96 15.71,37.63 16.86,38.77 19.27,38.77
GND on BOTTOM (solid shape): 59.05,67.37 59.05,65.31 58.84,65.11 56.23,65.11 55.36,65.97 55.36,66.71 55.62,66.96 56.48,66.96 56.55,67.03 56.56,67.03 56.63,67.09 56.69,67.17 56.69,67.17 57.02,67.5 58.92,67.5
GND on BOTTOM (solid shape): 40.57,31.95 40.57,30.74 40.32,30.49 40.32,27.05 39.85,26.58 38.51,26.58 38.5,26.58 38.37,26.6 38.25,26.58 38.24,26.58 37.3,26.58 37.16,26.72 37.16,30.27 39.08,32.19 40.33,32.19
GND on BOTTOM (solid shape): 45.86,30.31 45.86,29.85 46.35,29.36 46.35,28.39 45.86,27.9 45.86,27.74 45.84,27.69 45.83,27.62 45.62,27.42 45.62,27.17 45.56,27.11 44.7,27.11 44.55,27.26 44.55,30.37 44.75,30.58 45.59,30.58
GND on BOTTOM (solid shape): 61.36,85.63 62.35,85.63 62.4,85.58 62.4,85.2 62.32,85.12 60.79,85.12 59.44,83.77 59.44,80.29 59.25,80.1 58.74,80.1 58.43,80.4 58.43,83.22 57.67,83.98 54.81,83.98 54.48,84.31 54.48,85.85 54.7,86.08 60.91,86.08
GND on BOTTOM (solid shape): 100.75,35.49 101.69,35.49 101.77,35.42 101.77,34.02 101.59,33.84 100.83,33.84 100.42,34.25 100.42,35.06 100.24,35.25 100.24,35.31 100.17,35.31 100.02,35.47 99.23,35.47 98.87,35.11 98.87,34.2 98.52,33.84 97.55,33.84 97.48,33.92 97.48,35.45 98.28,36.25 99.99,36.25
GND on BOTTOM (solid shape): 84.21,78.29 84.21,76.92 83.65,76.37 77.66,76.37 77.48,76.54 77.48,76.94 77.64,77.1 78.8,77.1 78.96,77.25 78.96,77.69 79.03,77.76 80.28,77.76 81.17,78.65 83.85,78.65
GND on BOTTOM (solid shape): 124.33,33.66 124.33,28.4 124.78,27.95 135.81,27.95 137.52,29.66 137.52,30.4 138.07,30.94 140.4,30.94 140.91,30.44 140.91,27.82 140.29,27.2 123.88,27.2 121.89,29.19 121.89,32.95 122.04,33.1 123.06,33.1 123.64,33.69 124.3,33.69
GND on BOTTOM (solid shape): 75.06,89.85 75.06,87.63 75.12,87.57 75.12,85.89 74.74,85.51 74.74,85.02 74.61,84.89 74.31,84.89 74.16,85.05 74.16,85.36 74.28,85.48 74.28,86.02 74.16,86.14 73.84,86.14 73.71,86.27 73.71,87.78 72.63,88.86 72.63,89.82 72.86,90.05 74.86,90.05
GND on BOTTOM (solid shape): 119.42,41.41 120.52,41.41 121.15,42.04 122.67,42.04 122.78,41.94 122.78,41.61 122.67,41.51 122.67,40.52 121.89,39.73 121.89,38.51 121.25,37.88 121.25,34.98 121.1,34.83 120.29,34.83 120.24,34.88 120.24,36.05 119.02,37.27 119.02,39.78 118.89,39.91 117.06,39.91 116.12,40.85 116.12,41.94 116.22,42.04 118.79,42.04
GND on BOTTOM (solid shape): 173.56,39.2 173.56,37.43 173.37,37.24 173.12,37.24 173.08,37.25 173.04,37.26 172.76,37.26 172.73,37.25 172.68,37.24 172.34,37.24 172.33,37.25 172.26,37.32 172.26,37.6 172.35,37.7 172.36,37.7 172.5,37.84 172.5,37.85 172.58,37.92 172.58,39.5 172.73,39.65 173.11,39.65
GND on BOTTOM (solid shape): 194.28,40.01 194.28,39.45 194.35,39.38 195.06,39.38 195.09,39.4 199.81,39.4 199.92,39.3 199.92,38.08 198.9,37.07 197.88,37.07 197.78,36.96 197.78,35.59 197.88,35.49 199.15,35.49 199.23,35.42 199.23,34.83 199.18,34.78 192.93,34.78 192.88,34.83 192.88,35.34 192.98,35.44 193.51,35.44 193.59,35.52 193.59,40.04 193.64,40.09 194.2,40.09
GND on BOTTOM (solid shape): 21.88,66.03 21.88,65.78 21.88,65.72 21.88,65.53 21.89,65.53 21.89,65.36 22.06,65.18 22.83,65.18 22.95,65.06 22.95,60.61 22.83,60.49 21.05,60.49 20.92,60.61 20.92,65.06 21.05,65.18 21.56,65.18 21.68,65.31 21.68,65.73 21.69,65.78 21.69,66.03 21.73,66.07 21.84,66.07
GND on BOTTOM (solid shape): 98.82,53.6 99.03,53.6 99.08,53.55 99.08,53.2 99.15,53.12 99.59,53.12 99.71,52.99 99.71,52.74 99.59,52.61 99.15,52.61 99.08,52.53 99.08,52.2 99.03,52.15 98.47,52.15 98.14,52.48 97.88,52.48 97.73,52.64 97.73,53.11 97.83,53.21 98.23,53.21 98.36,53.34 98.36,53.39 98.38,53.45 98.39,53.5 98.39,53.53 98.46,53.6 98.82,53.6
GND on BOTTOM (solid shape): 34.63,39.69 34.63,38.88 30.19,34.45 28.92,34.45 28.67,34.2 28.67,33.82 28.7,33.79 28.7,33.77 28.72,33.69 28.79,33.62 28.8,33.59 28.8,33.31 28.67,33.18 28.29,33.18 28.16,33.3 28.16,34.67 28.17,34.69 28.18,34.7 33.71,40.23 33.74,40.26 33.75,40.27 33.77,40.27 34.04,40.27
GND on BOTTOM (solid shape): 131.84,39.15 132.68,39.15 132.73,39.1 132.73,38.36 132.94,38.16 134.38,38.16 134.49,38.06 134.49,37.42 134.73,37.18 135.36,37.18 135.45,37.09 135.94,37.09 136,37.03 136,36.09 135.9,35.99 135.47,35.99 135.43,36.02 133.9,36.02 133.21,36.71 129.91,36.71 129.63,36.43 126.26,36.43 126.15,36.54 126.15,37.24 126.27,37.37 127.86,37.37 128.44,37.96 128.44,39.17 128.77,39.5 131.49,39.5
GND on BOTTOM (solid shape): 191.43,40.36 191.43,40.06 191.87,39.63 192.25,39.63 192.28,39.61 192.33,39.59 192.4,39.52 192.4,38.95 192.29,38.84 191.48,38.84 191.31,38.67 190.94,38.67 190.9,38.71 190.9,39.09 190.99,39.18 190.99,39.18 191.09,39.25 191.16,39.35 191.16,39.36 191.25,39.44 191.25,39.6 190.92,39.94 190.92,40.4 190.97,40.44 191.35,40.44
GND on BOTTOM (solid shape): 105.35,38.36 105.35,34.35 105.17,34.17 104.25,34.17 104.17,34.21 104.16,34.31 104.13,34.6 103.89,34.78 103.86,34.8 103.85,34.83 103.85,35.73 104.23,36.11 104.23,38.11 104.54,38.41 105.3,38.41
GND on BOTTOM (solid shape): 93.18,41.56 93.18,40.42 92.68,39.91 91.17,39.91 91.11,39.96 91.1,39.96 90.64,40.42 89.76,40.42 89.63,40.55 89.63,40.8 89.76,40.93 90.45,40.93 90.54,40.91 90.66,40.93 90.8,41.02 90.88,41.17 90.9,41.18 91.28,41.18 91.66,41.56 91.66,41.94 91.79,42.07 92.68,42.07
GND on BOTTOM (solid shape): 67.94,70.12 68.04,70.06 68.02,69.95 67.63,69.57 67.63,69.23 67.51,69.1 67.1,69.1 66.98,68.98 66.98,68.66 66.85,68.53 65.49,68.53 65.37,68.41 65.37,68.16 65.16,67.94 65.16,67.05 64.61,66.5 62.6,66.5 60.04,69.07 60.04,69.42 60.14,69.52 60.87,69.52 61.25,69.91 64.57,69.91 64.76,70.09 65.88,70.09 65.97,70 67.56,70 67.69,70.12
GND on BOTTOM (solid shape): 79.82,71.84 80.99,71.84 81.04,71.8 81.16,71.63 81.36,71.55 81.38,71.55 81.4,71.53 83.51,71.53 83.63,71.41 83.63,70.67 83.53,70.57 80.81,70.57 80.48,70.9 79.29,70.9 79.04,71 78.78,70.9 78.33,70.9 78.15,71.08 78.15,72.17 78.35,72.37 79.29,72.37
GND on BOTTOM (solid shape): 85.39,63.89 85.39,63.28 85.18,63.08 83.96,63.08 82.82,64.22 81.91,64.22 81.89,64.21 81.83,64.2 81.79,64.19 79.84,64.19 79.49,64.24 79.27,63.96 79.27,63.94 78.99,63.66 78.86,63.66 78.55,63.97 77.94,63.97 77.44,64.47 77.44,65.03 77.69,65.29 83.99,65.29
GND on BOTTOM (solid shape): 99.49,77.12 99.66,77.12 99.76,77.02 99.76,74.81 99.8,74.77 99.8,74.76 99.92,74.53 100.15,74.41 100.16,74.41 100.65,73.92 100.65,73.67 100.47,73.49 98.98,73.49 98.85,73.36 98.54,73.36 98.44,73.46 98.44,73.9 98.86,74.32 98.86,74.57 98.87,74.59 98.88,74.61 98.98,74.97 98.67,75.19 98.65,75.2 98.63,75.21 98.54,75.29 98.15,75.29 98.06,75.38 98.06,75.6 98.11,75.65 98.52,75.65 98.7,75.83 98.7,76.87 98.98,77.15 99.46,77.15
GND on BOTTOM (solid shape): 6.72,74.25 6.72,70.44 6.72,70.44 6.34,70.4 6.03,70.19 5.26,70.19 5.26,70.98 5.13,70.98 4.18,71.55 3.22,70.98 2.56,70.98 0.51,70.98 0.51,73.39 4.25,73.39 4.91,73.64 5.25,74.25 6.27,74.25
GND on BOTTOM (solid shape): 39.46,70.39 39.46,67.22 38.7,66.45 37.1,66.45 35.86,65.21 33.32,65.21 33.24,65.13 33.24,62.77 32.99,62.52 31.08,62.52 30.57,63.03 30.57,66.17 30.65,66.25 32.5,66.25 32.5,66.2 32.51,66.15 32.53,66.1 32.55,66.05 32.58,66 32.62,65.96 32.66,65.93 32.71,65.9 32.75,65.88 32.81,65.87 32.86,65.87 32.91,65.87 32.97,65.88 33.01,65.9 33.06,65.93 33.1,65.96 33.14,66 33.17,66.05 33.19,66.1 33.21,66.15 33.22,66.2 33.22,66.25 33.21,66.3 33.19,66.36 33.17,66.4 33.14,66.45 33.1,66.49 33.06,66.52 33.01,66.55 32.97,66.57 32.91,66.58 32.86,66.58 32.81,66.58 32.75,66.57 32.71,66.55 32.66,66.52 32.62,66.49 32.58,66.45 32.55,66.4 32.53,66.36 32.51,66.3 32.5,66.25 30.65,66.25 31.23,66.84 31.23,69.02 31.01,69.25 27.72,69.25 27.7,69.27 25.5,69.27 25.48,69.25 24.73,69.25 23.59,70.39 23.59,71.79 23.97,72.17 37.69,72.17
GND on BOTTOM (solid shape): 13.05,39.78 13.05,37.7 14.78,35.97 14.78,34.55 14.42,34.2 12.86,34.2 12.86,35.86 12.73,35.86 11.78,36.43 10.82,35.86 8.09,35.86 5.48,35.86 3.86,35.86 3.86,36.75 3.6,37.42 2.97,37.75 2.46,37.75 2.46,39.74 7.74,39.74 8.57,39.54 9.06,40.25 9.06,41.71 11.12,41.71
GND on BOTTOM (solid shape): 14.04,60.61 14.04,57.72 12.24,55.91 12.24,55.35 11.09,54.21 9.06,54.21 9.06,55.75 8.57,56.46 7.74,56.26 5.43,56.26 2.46,56.26 2.46,58 2.16,58.71 1.45,59.01 0.51,59.01 0.51,61.02 3.22,61.02 4.18,60.45 5.13,61.02 5.26,61.02 5.26,61.83 6.06,61.83 6.33,61.67 6.63,61.62 6.72,61.53 8.4,61.53 9.11,62.24 12.41,62.24
GND on BOTTOM (solid shape): outline of 198 points within 28.8,8.92 39.72,26.09
GND on BOTTOM (solid shape): outline of 163 points within 157.52,30.74 190,47.4
GND on BOTTOM (solid shape): outline of 325 points within 1.46,0.51 236.24,98.39
GND on SGND (solid shape): outline of 2004 points within 0.51,0.51 236.24,98.39
GND on IN1 (solid shape): 37.05,52.23 37.05,46.9 37.02,46.86 31.53,46.86 31.38,47.01 31.38,52.4 31.46,52.48 36.8,52.48
GND on IN1 (solid shape): 107.27,78.8 107.27,77.23 107.18,77.14 103.87,77.14 103.76,77.25 103.76,78.8 103.83,78.87 107.19,78.87
GND on IN1 (solid shape): 126.11,36.57 126.11,35.53 124.14,33.56 122.29,33.56 121.93,33.93 121.93,36.52 122.47,37.07 125.62,37.07
GND on IN1 (solid shape): 80.79,52.03 80.79,50.67 80.56,50.45 77.23,50.45 77.2,50.46 77.18,50.5 77.18,52.01 77.23,52.06 78.93,52.06 79.1,52.23 80.59,52.23
GND on IN1 (solid shape): 13.02,40.22 13.02,37.73 14.78,35.97 14.78,34.55 14.42,34.2 12.86,34.2 12.86,35.86 12.73,35.86 11.78,36.43 10.82,35.86 8.37,35.86 5.58,35.86 3.86,35.86 3.86,36.75 3.56,37.46 2.85,37.76 2.46,37.76 2.46,39.74 7.74,39.74 8.57,39.54 9.06,40.25 9.06,42.12 11.12,42.12
GND on IN1 (solid shape): 13.9,18.26 14.62,16.86 14.12,15.37 14.12,11.48 14.6,10.44 14.44,9.31 14.23,9.1 13.73,9.1 13.43,9.41 13.43,9.58 13.58,10.37 13.11,11.02 13.11,15.83 13.59,16.54 13.36,17.36 13.36,17.97 13.64,18.26
GND on IN1 (solid shape): 6.44,63.41 6.44,63.17 6.02,61.87 7.35,62.18 7.49,62.31 12.16,62.31 14.01,60.46 14.01,58 11.93,55.91 11.93,54.97 10.76,53.8 9.06,53.8 9.06,55.75 8.57,56.46 7.74,56.26 5.3,56.26 2.46,56.26 2.46,58 2.16,58.71 1.45,59.01 0.51,59.01 0.51,61.02 3.22,61.02 4.18,60.45 5.13,61.02 5.26,61.02 5.26,62.93 5.86,63.53 6.32,63.53
GND on IN1 (solid shape): outline of 364 points within 0.51,0.51 236.24,98.39
GND on SGND1 (solid shape): outline of 2004 points within 0.51,0.51 236.24,98.39
GND on SVCC (solid shape): 112.17,32.42 112.39,32.34 112.61,32.42 115.78,32.42 116.12,32.16 116.46,32.42 118.5,32.42 118.84,32.08 118.84,31.79 118.88,31.59 118.99,31.42 120.89,29.52 121.06,29.41 121.26,29.37 136.15,29.37 137.4,28.12 137.57,28.01 137.77,27.97 150.51,27.97 152.01,26.47 152.17,26.36 152.37,26.32 163.71,26.32 164.05,25.98 164.05,23.99 163.6,23.54 163.39,23.4 157.58,23.4 157.38,23.36 157.21,23.25 156.09,22.13 150.29,22.13 147.65,24.78 147.48,24.89 147.28,24.93 136.19,24.93 135.84,25.28 135.67,25.4 135.47,25.43 120.7,25.43 117.42,28.71 117.25,28.82 117.06,28.86 111.94,28.86 111.74,29.06 111.66,29.44 111.28,29.52 109.31,31.49 109.31,31.95 109.78,32.42
GND on SVCC (solid shape): 9.91,92.18 8.51,86.99 13.73,85.7 13.73,80.62 13.89,79.84 14.35,79.17 14.35,79.17 15.71,77.86 15.71,72.63 15.48,72.4 15.21,72.29 15.11,72.02 13.56,70.48 5.77,70.48 5.76,70.56 5.75,70.64 5.5,71.35 4.94,71.86 4.65,72.21 4.22,72.06 3.79,72.01 3.39,71.85 2.94,71.89 2.74,71.49 1.02,71.49 1.02,72.65 1.21,72.72 1.35,72.88 1.89,72.88 2.25,72.65 2.62,72.88 3.16,72.88 3.52,72.65 3.89,72.88 4.25,72.88 4.38,72.89 4.5,72.9 4.96,72.81 5.2,73.22 5.62,73.74 5.77,74.4 5.77,75 5.32,76.07 4.25,76.52 1.97,76.52 1.97,77.18 3.25,77.18 4.44,77.94 4.27,79.34 4.27,81.06 4.53,82.21 3.77,83.11 3.77,84.2 3.67,84.73 3.4,85.19 4.47,86.01 4.27,87.34 4.27,89.06 4.44,90.46 3.25,91.22 1.97,91.22 1.97,92.18
GND on SVCC (solid shape): outline of 236 points within 1.02,1.02 32.69,62.77
GND on SVCC (solid shape): outline of 3551 points within 44.27,26.2 235.73,97.88
GND on IN2 (solid shape): 22.83,64.8 22.83,60.74 22.7,60.61 21.3,60.61 21.05,60.87 21.05,64.64 21.35,64.94 22.69,64.94
GND on IN2 (solid shape): 37.05,52.1 37.05,47.02 36.67,46.64 31.59,46.64 31.34,46.9 31.34,52.23 31.46,52.36 36.8,52.36
GND on IN2 (solid shape): 80.71,52 80.71,50.09 80.58,49.97 77.36,49.97 77.18,50.15 77.18,52.07 77.31,52.19 79.62,52.19 79.66,52.23 80.48,52.23
GND on IN2 (solid shape): 126.1,36.46 126.1,34.94 124.72,33.56 122.37,33.56 121.85,34.08 121.85,36.74 122.27,37.16 125.4,37.16
GND on IN2 (solid shape): 107.23,78.76 107.23,78.38 107.55,78.06 107.55,76.04 107.32,75.81 106.97,75.81 105.7,77.09 105.62,77.09 105.46,77.25 103.84,77.25 103.06,78.04 103.06,78.33 103.2,78.48 103.45,78.48 103.72,78.75 103.72,78.91 103.82,79 106.99,79
GND on IN2 (solid shape): 23.21,68.99 23.21,67.72 22.83,67.34 20.79,67.34 20.19,66.73 20.17,66.73 20.08,66.73 20,66.71 19.44,66.71 19.35,66.73 19.26,66.73 19.24,66.74 19.14,66.84 19.14,67.98 20.41,69.25 22.95,69.25
GND on IN2 (solid shape): 14.75,22.46 14.75,21 13.87,20.12 6.89,20.12 6.71,19.95 4.17,19.95 3.86,20.26 3.86,20.99 4.01,21.14 10.82,21.14 11.78,20.57 12.73,21.14 12.86,21.14 12.86,22.82 14.39,22.82
GND on IN2 (solid shape): 13.1,40.98 13.1,37.65 14.78,35.97 14.78,34.55 14.42,34.2 12.86,34.2 12.86,35.86 12.73,35.86 11.78,36.43 10.82,35.86 8.91,35.86 5.78,35.86 3.86,35.86 3.86,36.75 3.56,37.46 2.85,37.76 2.46,37.76 2.46,39.74 7.74,39.74 8.57,39.54 9.06,40.25 9.06,42.25 11.83,42.25
GND on IN2 (solid shape): 14.22,17.92 14.62,16.71 14.22,15.49 14.17,15.42 14.12,15.37 14.12,11.48 14.3,11.25 14.44,11 14.62,10.14 14.43,9.28 13.76,9.28 13.5,9.54 13.5,9.69 13.57,10.43 13.11,11.02 13.11,15.83 13.6,16.56 13.33,17.4 13.33,17.81 13.43,17.92
GND on IN2 (solid shape): 6.37,63.41 6.37,63.15 6.01,61.89 7.3,62.05 8.27,63.03 8.63,63.03 9.42,62.24 12.18,62.24 13.94,60.49 13.94,56.95 10.79,53.8 9.06,53.8 9.06,55.75 8.57,56.46 7.74,56.26 4.03,56.26 2.46,56.26 2.46,58 2.16,58.71 1.45,59.01 0.51,59.01 0.51,61.02 3.22,61.02 4.18,60.45 5.13,61.02 5.26,61.02 5.26,62.88 5.91,63.53 6.24,63.53
GND on IN2 (solid shape): outline of 362 points within 0.51,0.51 236.24,98.39
GND on SGND2 (solid shape): outline of 2004 points within 0.51,0.51 236.24,98.39
+GT_VRCTL on TOP (solid shape): 178.78,39.15 178.79,39.15 178.8,39.13 179.07,39.01 179.34,39.13 179.36,39.14 179.38,39.15 185.26,39.15 185.74,38.67 187.44,38.67 187.52,38.59 187.52,38.16 187.85,37.83 187.85,37.5 187.62,37.27 179.3,37.27 179.09,37.34 178.88,37.27 178.64,37.27 178.49,37.33 178.33,37.32 178.31,37.32 178.29,37.33 177.39,38.23 177.18,38.43 177.18,39.54 177.26,39.62 178.31,39.62
+GT_VRCTL on BOTTOM (solid shape): 180.14,40.87 180.14,38.63 179.54,38.04 178.06,38.04 177.98,38.12 177.98,38.12 177.83,38.27 177.83,39.43 177.89,39.48 177.89,40.23 177.89,40.23 178.14,40.23 178.16,40.21 178.16,39.49 178.16,39.48 178.62,39.01 179.02,39.01 179.07,39.01 179.25,39.01 179.76,39.52 179.76,40.79 179.66,40.89 178.84,40.89 178.82,40.91 178.82,41.16 178.83,41.17 179.83,41.17
+GT_VRCTL on BOTTOM (solid shape): 188.99,39.95 188.99,37.98 188.15,37.13 186.91,37.13 186.69,37.35 186.69,38.51 186.74,38.56 186.74,39.31 186.74,39.31 186.99,39.31 187.01,39.29 187.01,38.57 187.01,38.56 187.55,38.02 188.12,38.02 188.62,38.52 188.62,38.56 188.62,38.58 188.64,38.6 188.79,38.9 188.64,39.19 188.62,39.21 188.62,39.23 188.62,39.87 188.52,39.97 187.69,39.97 187.67,39.99 187.67,40.24 187.68,40.25 188.69,40.25
+USB3_P4_VBUS on TOP (solid shape): 20.11,30.56 20.11,29.95 19.91,29.75 18.25,29.75 18.1,29.9 18.1,30.49 17.29,31.3 14.22,31.3 13.78,31.73 13.78,32.27 15,33.48 17.19,33.48
+USB3_P4_VBUS on BOTTOM (solid shape): 23.72,34.52 23.72,32.93 23.08,32.29 21.76,32.29 21.32,31.85 15.37,31.85 14.88,31.35 14.17,31.35 13.78,31.73 13.78,32.77 15.59,34.58 16.6,34.58 16.98,34.96 23.28,34.96
+USB3_P4_VBUS_FUSE on BOTTOM (solid shape): 27.68,32.85 27.68,31.52 27.65,31.49 25.81,31.49 24.4,32.9 24.4,34.42 24.47,34.49 26.04,34.49
+V_BOOSTIN on TOP (solid shape): 49.95,31.57 49.95,31.26 49.79,31.09 49.46,31.09 49.12,30.75 48.96,30.75 48.82,30.89 48.82,31.15 49.42,31.75 49.77,31.75
+V_BOOSTIN on TOP (solid shape): 30.08,63.8 30.08,63.65 30.27,63.45 30.37,63.45 30.45,63.38 30.45,61.73 30.4,61.69 29.59,61.69 29.48,61.79 29.48,61.83 29.29,62.03 29.23,62.11 29.14,62.17 29.1,62.21 28.24,62.21 28.14,62.31 28.14,64.12 28.19,64.17 28.72,64.17 28.9,64.35 29.53,64.35
+V_BOOSTIN on BOTTOM (solid shape): 42.02,35.57 42.04,35.56 42.06,35.54 42.25,35.36 42.5,35.36 42.58,35.36 42.63,35.3 43.05,35.07 43.32,35.45 43.35,35.53 43.42,35.57 48.4,35.57 49.17,34.81 49.17,32.67 49.41,32.42 50.3,32.42 50.39,32.33 50.39,31.61 49.52,30.74 48.91,30.74 48.55,31.11 48.55,33.01 48.29,33.27 46.65,33.27 46.58,33.28 46.5,33.27 44.8,33.27 44.25,32.72 41.04,32.72 40.8,32.49 39.28,32.49 39.27,32.48 39.15,32.48 36.67,30.01 36.67,26.7 36.42,26.45 35.4,26.45 35.27,26.58 35.27,30.18 36.01,30.92 36.01,33.13 38.45,35.57
+V_BOOSTIN on SVCC (solid shape): 23.93,65.18 24.22,65.03 24.52,65.18 31.51,65.18 42.64,54.05 42.64,53.25 42.31,53.02 42.4,52.62 42.44,52.55 42.42,52.48 42.35,52.15 42.6,51.91 42.64,51.9 42.64,51.82 42.6,51.81 42.36,51.47 42.6,51.13 42.64,51.12 42.64,35.55 42.64,35.54 42.61,35.42 42.64,35.29 42.64,35.28 42.64,34.28 42.3,33.94 32.44,33.94 30.8,35.58 30.79,35.59 30.7,35.77 30.52,35.86 30.51,35.87 22,44.38 22,44.4 21.97,44.64 21.81,44.81 21.81,45.12 22.01,45.47 21.81,45.81 21.81,46.12 22.01,46.47 21.81,46.81 21.81,53.8 21.99,54.11 21.81,54.42 21.81,57.97 21.85,57.98 22.13,58.26 21.98,58.62 21.94,58.71 21.98,58.79 22.13,59.16 21.85,59.44 21.81,59.45 21.81,63.2 23.8,65.18
+V_USB2PWR on TOP (solid shape): 228.54,27.08 228.54,24.57 228.19,24.21 227.84,24.21 227.6,24.31 227.36,24.21 219.14,24.21 214.42,19.49 207.18,19.49 206.82,19.85 206.82,21.17 207.18,21.53 211.24,21.53 211.24,21.53 211.28,21.53 215.99,26.25 218.2,26.25 218.43,26.47 218.45,26.47 218.68,26.58 218.79,26.81 218.79,26.83 219.25,27.29 228.34,27.29
+V_USB2PWR on BOTTOM (solid shape): 228.62,27.29 228.62,24.9 228.49,24.77 227.22,24.77 227.2,24.8 225.93,24.8 225.85,24.87 225.85,25.05 225.86,25.09 225.9,25.1 227.2,25.1 227.2,25.3 225.9,25.3 225.86,25.31 225.85,25.35 225.85,25.55 225.86,25.59 225.9,25.6 227.2,25.6 227.2,25.8 225.9,25.8 225.86,25.81 225.85,25.85 225.85,26.05 225.86,26.09 225.9,26.1 227.2,26.1 227.2,26.3 225.9,26.3 225.86,26.31 225.85,26.35 225.85,26.55 225.86,26.59 225.9,26.6 227.2,26.6 227.2,26.8 225.9,26.8 225.86,26.81 225.85,26.85 225.85,27.06 225.89,27.1 227.2,27.1 227.2,27.14 227.21,27.18 227.25,27.2 227.3,27.2 227.3,27.31 227.32,27.34 228.57,27.34
+V_USB2PWR_R on TOP (solid shape): 209.32,18.93 209.32,17.63 209.1,17.41 208.42,17.41 207.58,16.57 206.21,16.57 206.21,18.37 206.95,19.11 209.14,19.11
+VR1_VBATA on BOTTOM (solid shape): 61.13,71.03 63.04,71.03 63.8,71.79 66.24,71.79 66.92,71.11 66.92,70.23 66.87,70.18 66.15,70.18 66.09,70.23 64.69,70.23 64.52,70.06 60.93,70.06 60.62,69.75 60.09,69.75 59.93,69.91 59.93,70.62 59.63,70.93 59.63,71.61 59.81,71.79 60.37,71.79
+VR3_VBATA on BOTTOM (solid shape): 65.68,96.27 65.68,88.78 65.32,88.43 64.79,88.43 64.61,88.6 64.23,88.6 63.97,88.86 63.97,96.45 64.05,96.53 65.42,96.53
+VR4_VBATA on TOP (solid shape): 76.5,88.82 76.5,88.22 76.69,88.03 76.69,86.77 76.02,86.1 74.79,86.1 74.67,86.22 74.67,86.8 74.78,86.91 75.05,86.91 75.07,86.91 75.35,87.19 75.35,87.85 75.89,88.4 75.89,88.79 76.03,88.93 76.39,88.93
+VR4_VBATA on BOTTOM (solid shape): 76.4,89.88 76.4,88.34 76.67,88.07 78.07,88.07 78.12,88.02 78.12,87.08 77.18,86.13 76.89,86.13 76.52,86.29 76.15,86.13 75.41,86.13 75.3,86.24 75.3,87.68 75.22,87.76 75.22,90 75.3,90.08 76.19,90.08
+VR5_VBATA on TOP (solid shape): 80.16,79.13 80.16,78.52 79.58,77.94 79.58,76.47 79.85,76.21 80.28,76.21 80.53,75.95 80.54,75.95 80.58,75.9 81.6,75.9 81.68,75.83 81.68,75.14 81.55,75.01 79.9,75.01 79.82,74.94 79.52,74.94 78.81,75.65 78.81,78.89 79.12,79.2 80.09,79.2
+VR5_VBATA on BOTTOM (solid shape): 84.21,76.21 84.21,75.35 83.81,74.94 79.06,74.94 78.85,75.15 78.85,76.06 79.03,76.24 84.18,76.24
+VUSBC1_VBUS_CONN on TOP (solid shape): 9.18,67.72 9.18,67.33 8.94,67.09 8.35,67.09 8.02,66.76 8.02,65.44 8.65,64.8 8.65,64.55 8.45,64.35 5.91,64.35 5.73,64.52 5.73,64.85 6.02,65.14 6.66,65.14 6.78,65.26 6.78,66.52 6.63,66.67 6.63,66.93 6.52,67.04 5.91,67.04 5.73,67.22 5.73,67.44 5.91,67.62 7.56,67.62 7.79,67.85 9.05,67.85
+VUSBC1_VBUS_CONN on TOP (solid shape): 20.41,69.88 20.41,69.16 20.36,69.11 20.36,69.03 20.35,69 20.31,68.98 20.06,68.98 19.95,69.03 19.84,69.04 19.04,69.04 18.92,68.92 18.71,68.92 18.46,69.17 18.46,69.17 18.23,69.4 17.82,69.4 17.72,69.5 17.72,69.83 17.89,70 18.5,70 18.51,70.01 19.79,70.01 20.29,70.01
+VUSBC1_VBUS_CONN on TOP (solid shape): 30.95,69.25 30.95,67.31 30.95,67.28 30.93,67.26 30.74,67.26 30.73,67.26 30.27,66.79 30.93,66.79 31,66.85 31.09,66.82 31.21,66.71 31.21,64.42 31.08,64.3 31.08,62.29 30.98,62.19 30.65,62.19 30.57,62.27 30.57,63.44 30.45,63.56 30.37,63.56 30.18,63.75 30.18,63.92 29.56,64.55 29.15,64.55 28.26,65.44 28.26,65.92 27.53,66.66 27.53,67.72 27.02,68.23 27.02,69.63 27.14,69.76 30.45,69.76
+VUSBC1_VBUS_CONN on BOTTOM (solid shape): outline of 179 points within 25.42,65.29 31.06,69.17
+VUSBC1_VBUS_CONN on SVCC (solid shape): 17.09,72.57 17.74,72.27 18.45,72.17 31.21,72.17 31.21,66.2 27.1,66.2 26.76,66.43 26.43,66.2 23.59,66.2 23.4,66.16 23.23,66.05 20.97,63.79 13.51,63.79 13.15,64.14 12.79,63.79 5.77,63.79 5.77,69.47 5.85,69.47 6.6,68.82 7.35,69.47 7.56,69.47 7.77,69.4 7.98,69.47 13.77,69.47 13.97,69.5 14.13,69.62 15.84,71.32 16.22,71.4 16.3,71.78
+VUSBC1_VBUS_CONN on IN2 (solid shape): 18.99,69.91 20.13,69.91 20.29,69.75 20.29,69.51 18.18,67.39 17.37,67.39 17.32,67.35 17.31,67.34 17.19,67.26 17.11,67.15 17.11,67.14 16.78,66.81 15.74,66.81 15.28,67.27 12.24,67.27 11.55,66.58 9.88,66.58 9.87,66.58 9.75,66.61 9.62,66.58 9.61,66.58 9.28,66.58 9.1,66.66 8.91,66.63 8.83,66.63 8.77,66.69 8.17,66.86 8.34,66.26 8.42,66.19 8.39,66.09 8.27,65.97 8.27,65.16 8.65,64.78 8.65,64.55 8.22,64.12 6.01,64.12 5.73,64.4 5.73,64.85 5.94,65.06 6.6,65.06 6.95,65.41 6.95,66.92 7.01,66.99 7.01,67.03 7.89,67.9 9.75,67.9 9.97,67.97 10.12,68.14 10.59,68.61 16.6,68.61 18.03,70.04 18.87,70.04
CAP1_GND on BOTTOM (solid shape): 102.2,93.05 102.2,92.64 102.19,92.63 102.19,91.92 102.07,91.8 101.8,91.8 101.72,91.88 101.72,92.51 101.64,92.59 101.26,92.59 101.11,92.74 101.08,92.74 101.08,92.75 100.47,92.75 100.4,92.82 100.4,92.95 100.45,93 101.08,93 101.24,93.15 101.91,93.15 102.1,93.15
CAP2_GND on TOP (solid shape): 53.33,73.59 53.33,72.04 53.08,71.79 53.08,71.7 53.06,71.68 53.06,71.1 53.04,71.07 53.01,71.05 52.82,71.05 52.8,71.07 52.8,71.68 52.8,71.68 52.8,73.54 52.95,73.69 53.23,73.69
CAP3_GND on TOP (solid shape): 215.1,30.11 215.1,28.91 215.08,28.89 214.88,28.89 214.86,28.91 214.86,29.51 214.85,29.51 214.85,29.55 214.67,29.73 214.06,29.73 213.94,29.6 213.12,29.6 213.02,29.7 213.02,30.18 213.25,30.41 214.8,30.41
CCD_PWR on TOP (solid shape): 47.62,61.96 47.62,60.51 47.39,60.28 46.47,60.28 46.33,60.42 46.33,62.04 46.55,62.26 47.31,62.26
CCD_PWR on BOTTOM (solid shape): 47.57,62.09 47.57,61.35 47.55,61.35 47.55,60.27 47.52,60.23 47.3,60.23 47.26,60.25 47.25,60.28 47.25,61.35 47.05,61.35 47.05,60.28 47.04,60.25 47,60.23 46.78,60.23 46.75,60.26 46.75,61.55 46.65,61.65 46.53,61.65 46.35,61.84 46.35,62.14 46.47,62.26 47.39,62.26
CORE_SW_DRV on TOP (solid shape): 166.04,39.27 166.04,38.08 165.77,37.8 164.79,37.8 164.61,37.99 164.61,38.66 165.45,39.5 165.81,39.5
CORE_SW_DRV on BOTTOM (solid shape): 166.76,38.56 166.76,36.43 166.38,36.04 162.83,36.04 162.67,36.2 162.67,37.57 162.8,37.7 163.24,37.7 163.31,37.78 163.31,38.29 163.24,38.36 162.78,38.36 162.67,38.46 162.67,39.79 162.76,39.87 165.45,39.87
EMMC_3P3 on BOTTOM (solid shape): 63.85,56.83 63.85,55.79 63.52,55.46 61.84,55.46 60.98,56.32 60.98,56.8 61.1,56.93 63.75,56.93
EMMC_3P3 on BOTTOM (solid shape): 59.35,49.64 59.35,49.56 59.86,49.06 60.22,49.06 60.84,48.43 60.84,48.25 60.95,48.14 60.96,48.12 60.95,48.11 61.01,47.93 61.18,47.85 61.24,47.85 61.31,47.79 61.31,47.51 61.1,47.3 61.09,47.29 61.02,47.24 60.97,47.18 60.97,47.17 60.75,46.95 60.62,46.95 60.55,47.02 60.55,47.16 60.58,47.19 60.77,47.5 60.6,47.81 60.59,47.82 60.47,47.94 59.5,47.94 58.96,48.48 58.96,48.61 58.89,48.68 58.86,48.72 58.55,49.04 58.54,49.04 58.54,49.18 58.71,49.35 58.73,49.36 58.84,49.42 58.91,49.54 58.91,49.55 59.07,49.72 59.28,49.72
EMMC_3P3 on IN2 (solid shape): outline of 253 points within 59.72,47.99 63.09,56.22
GT_SW_DRV1 on TOP (solid shape): 177.29,45.21 177.29,44.3 177.17,44.18 176.12,44.18 175.53,44.76 175.53,45.15 175.73,45.36 177.15,45.36
