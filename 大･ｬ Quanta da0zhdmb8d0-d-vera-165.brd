# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_WAKEOUT_INTRUDET*: length 8.9
  TOP w0.102: v3(108.54,69.93) 108.4,70.07 108.4,70.8 TP18.1
  IN2 w0.079: v3(108.54,69.93) 109.49,69.93 112.08,67.34 112.08,66.25 111.75,65.92 111.75,65.36 v3(112.12,64.99)
  BOTTOM w0.076: U80.AT15 v3(112.12,64.99)
USBA_PO_ILIMSEL: length 2.4
  TOP w0.102: EU1B2.4 202.68,15.2 202.63,15.15 R5103.1 v1(201.08,15.15)
USBC1_DN*: length 16.6
  TOP w0.102: v1(9.06,66.3) 9.26,66.5 9.26,66.8 9.61,67.15 9.61,68.45 9.85,68.69 11.7,68.69 12.4,67.99 13.5,67.99 U4.3 14.02,67.99 14.31,67.99 14.6,68.28 14.9,68.28 15.12,68.51 LCP4022.3
  IN1 w0.079: JCP4038.B7 6.52,66.07 7.07,66.07 8.16,67.16 8.45,67.16 8.72,66.89 9.28,66.89 9.46,66.71 9.46,66.53 9.23,66.3 v1(9.06,66.3)
  BOTTOM w0.102: JCP4038.A7 7.81,66.25 7.95,66.39 8.06,66.39 8.13,66.31 8.13,66.03 8.29,65.88 9.07,65.88 9.19,66 9.19,66.17 v1(9.06,66.3)
USBC1_DP: length 16.5
  TOP w0.102: v1(9.75,66.25) 9.7,66.2 9.57,66.2 9.47,66.3 9.47,66.71 9.82,67.06 9.82,68.36 9.94,68.48 10.52,68.48 U4.4 11,68.48 11.61,68.48 12.31,67.77 14.39,67.77 14.69,68.07 14.78,68.07 15.15,67.7 LCP4022.2
  IN1 w0.079: v1(9.75,66.25) 9.64,66.35 9.64,66.78 9.35,67.08 8.79,67.08 8.53,67.34 8.09,67.34 6.99,66.25 6.2,66.25 JCP4038.B6
  BOTTOM w0.102: v1(9.75,66.25) 9.17,65.67 8.21,65.67 8.13,65.75 JCP4038.A6
USBC1_R_SSRXN*<1>: length 9.7
  TOP w0.102: L11.2 15.69,61.73 15.81,61.6 15.81,61.44 15.68,61.31 15.31,61.31 15.22,61.22 15.22,60.84 15.7,60.36 17.14,60.36 17.24,60.26 18.18,60.26 18.68,60.76 18.68,61.2 18.41,61.48 v1(18.26,61.48)
  BOTTOM w0.102: U96.24 20.08,61.38 20.07,61.4 19.8,61.4 19.13,60.73 18.73,60.73 18.45,61.01 18.45,61.28 v1(18.26,61.48)
USBC1_R_SSRXN*<2>: length 10.8
  TOP w0.102: L13.3 14.65,71 14.82,71.17 15.71,71.17 v1(15.97,70.91)
  BOTTOM w0.102: U96.33 20.1,64.98 20.01,65.08 19.71,65.08 18.68,66.11 18.68,67.84 18.09,68.42 18.09,69.79 16.73,71.15 16.21,71.15 v1(15.97,70.91)
USBC1_R_SSRXP<1>: length 9.7
  TOP w0.102: L11.3 15.14,61.43 15.01,61.31 15.01,60.75 15.62,60.15 17.05,60.15 17.15,60.05 18.27,60.05 18.89,60.67 18.89,61.37 v1(19,61.48)
  BOTTOM w0.102: U96.25 20.19,61.78 20.02,61.61 19.71,61.61 19.04,60.94 18.81,60.94 18.66,61.09 18.66,61.41 18.8,61.55 18.92,61.55 v1(19,61.48)
USBC1_R_SSRXP<2>: length 10.8
  TOP w0.102: L13.2 14.68,71.56 14.85,71.39 15.71,71.39 v1(15.97,71.65)
  BOTTOM w0.102: v1(15.97,71.65) 16.25,71.36 16.82,71.36 18.31,69.88 18.31,68.51 18.89,67.93 18.89,66.2 19.8,65.29 20.01,65.29 20.1,65.38 U96.34
USBC1_R_SSTXN*<1>: length 4.7
  TOP w0.102: v1(17.77,60.97) 17.55,60.97 17.42,61.09 17.42,61.69 17.41,61.7 L10.2
  BOTTOM w0.102: v1(17.77,60.97) 17.5,61.24 17.5,61.49 16.88,62.1 16.88,62.8 17,62.92 17.24,62.92 17.46,62.7 CCP4167.1
USBC1_R_SSTXN*<1>_C: length 2.5
  BOTTOM w0.102: CCP4167.2 18.7,62.78 19.3,62.78 19.4,62.68 20.04,62.68 20.13,62.58 U96.27
USBC1_R_SSTXN*<2>: length 7.8
  TOP w0.102: L12.3 14.7,69.48 14.87,69.65 15.72,69.65 v1(15.98,69.39)
  BOTTOM w0.102: CCP4169.1 18.01,65.52 18.08,65.59 18.08,65.73 17.98,65.82 17.98,67.49 17.36,68.12 17.36,68.75 16.42,69.68 16.17,69.68 15.98,69.49 v1(15.98,69.39)
USBC1_R_SSTXN*<2>_C: length 3.4
  BOTTOM w0.102: U96.30 20.1,63.78 20,63.89 18.2,63.89 17.82,64.28 17.82,64.52 CCP4169.2
USBC1_R_SSTXP<1>: length 4.7
  TOP w0.102: v1(17.03,60.97) 17.11,60.97 17.21,61.07 17.21,61.37 16.86,61.73 L10.3
  BOTTOM w0.102: v1(17.03,60.97) 17.29,61.22 17.29,61.4 16.67,62.01 16.67,62.89 16.92,63.13 17.14,63.13 CCP4166.1
USBC1_R_SSTXP<1>_C: length 2.5
  BOTTOM w0.102: U96.28 20.17,62.98 20.08,62.89 19.47,62.89 19.37,62.99 18.7,62.99 CCP4166.2
USBC1_R_SSTXP<2>: length 7.7
  TOP w0.102: v1(15.98,70.12) 15.72,69.86 14.87,69.86 14.7,70.03 L12.2
  BOTTOM w0.102: v1(15.98,70.12) 16.21,69.89 16.51,69.89 17.57,68.84 17.57,68.21 18.2,67.58 18.2,65.91 CCP4168.1
USBC1_R_SSTXP<2>_C: length 3.4
  BOTTOM w0.102: U96.31 20.1,64.18 20.02,64.1 18.29,64.1 18.03,64.37 18.03,64.55 18.2,64.72 CCP4168.2
USBC1_SSRXN*<1>: length 16.1
  TOP w0.102: JCP4038.B10 5.56,64.09 6.59,64.09 7.2,63.48 12.76,63.48 12.93,63.31 13.72,63.31 14.31,63.9 14.31,65.81 14.93,66.43 15.36,66.43 15.54,66.25 15.54,66 15.7,65.84 UCP4034.4 UCP4034.7 15.7,64.46 15.69,64.45 L11.1
USBC1_SSRXN<2>: length 9.8
  TOP w0.102: L13.4 12.69,71 12.53,71.16 11.31,71.16 11.17,71.02 UCP4036.9 UCP4036.2 9.59,71.02 9.45,71.16 8.95,71.16 v1(8.68,70.9)
  BOTTOM w0.102: v1(8.68,70.9) 8.48,71.1 8.3,71.1 8.17,70.98 8.17,70.57 8.7,70.04 8.7,68.44 8.21,67.94 7.96,67.94 7.77,67.75 JCP4038.A10
USBC1_SSRXP<1>: length 16.1
  TOP w0.102: JCP4038.B11 5.53,63.88 6.5,63.88 7.11,63.27 12.67,63.27 12.84,63.1 13.81,63.1 14.52,63.81 14.52,65.72 15.02,66.22 15.27,66.22 15.33,66.16 15.33,65.98 15.2,65.84 UCP4034.5 UCP4034.6 15.2,64.56 15.47,64.28 15.47,64.05 15.38,63.96 15.18,63.96 15.14,63.92 L11.4
USBC1_SSRXP<2>: length 9.8
  TOP w0.102: L13.1 12.69,71.56 12.51,71.37 11.31,71.37 11.17,71.52 UCP4036.10 UCP4036.1 9.59,71.52 9.45,71.37 8.95,71.37 v1(8.68,71.64)
  BOTTOM w0.102: v1(8.68,71.64) 8.36,71.31 8.21,71.31 7.96,71.06 7.96,70.48 8.49,69.95 8.49,68.52 8.13,68.16 7.87,68.16 7.77,68.25 JCP4038.A11
USBC1_SSTXN*<1>: length 16.9
  TOP w0.102: L10.1 17.41,63.72 17.2,63.93 UCP4034.10 UCP4034.1 17.2,65.86 17.05,66.01 17.05,66.09 17.32,66.36 v1(17.44,66.36)
  IN1 w0.079: v1(17.44,66.36) 17.22,66.58 17.22,66.67 16.43,67.47 12.53,67.47 9.74,64.68 9.74,64.36 v1(9.55,64.18)
  BOTTOM w0.102: JCP4038.A3 7.96,64.25 8.05,64.17 8.05,64.06 8.15,63.96 8.61,63.96 8.98,63.59 9.61,63.59 9.87,63.86 9.87,64.04 9.74,64.18 v1(9.55,64.18)
USBC1_SSTXN*<2>: length 8.9
  TOP w0.102: L12.4 12.69,69.48 12.51,69.66 11.31,69.66 11.17,69.52 UCP4036.6 UCP4036.5 9.59,69.52 9.45,69.66 8.55,69.66 7.8,68.91 7.8,68.75 6.94,67.89 5.54,67.89 JCP4038.B3
USBC1_SSTXP<1>: length 16.9
  TOP w0.102: v1(16.57,66.39) 16.84,66.12 16.84,66.03 16.7,65.89 UCP4034.2 UCP4034.9 16.7,64.59 16.98,64.3 16.98,63.89 16.86,63.77 L10.4
  IN1 w0.079: v1(16.57,66.39) 16.69,66.28 16.91,66.28 17.04,66.4 17.04,66.6 16.35,67.28 12.61,67.28 9.92,64.6 9.92,64.32 10.07,64.18 v1(10.26,64.18)
  BOTTOM w0.102: v1(10.26,64.18) 10.08,64 10.08,63.77 9.7,63.38 8.89,63.38 8.52,63.75 JCP4038.A2
USBC1_SSTXP<2>: length 8.9
  TOP w0.102: L12.1 12.66,70.03 12.5,69.87 11.31,69.87 11.17,70.02 UCP4036.7 UCP4036.4 9.59,70.02 9.45,69.87 8.47,69.87 7.59,68.99 7.59,68.84 6.85,68.11 5.54,68.11 JCP4038.B2
USBC1_SSUSBC1_AUX_RFU1: length 20.2
  IN1 w0.079: v1(11.62,64.7) 11.39,64.48 11.18,64.48 10.84,64.14 10.84,63.81 10.54,63.52 8.53,63.52 7.76,64.28 7.76,65.95 v1(8.43,66.61)
  BOTTOM w0.102: v1(8.43,66.61) 8.28,66.75 JCP4038.A8 ; R1C11.1 17.9,59.88 17.47,59.88 RCP4186.2 16.7,59.65 16.1,59.65 15.74,60.01 15.74,62.31 14.39,63.65 14.39,64.79 14.05,65.13 12.97,65.13 12.63,64.79 U133.4 12.35,64.73 12.14,64.73 11.94,64.52 11.79,64.52 v1(11.62,64.7)
USBC1_SSUSBC1_AUX_RFU1_C: length 2.2
  BOTTOM w0.102: R1C11.2 19.3,59.76 19.49,59.76 19.73,60 19.73,60.16 19.96,60.39 20.07,60.39 20.26,60.58 U96.22
USBC1_SSUSBC1_AUX_RFU2: length 20.2
  IN1 w0.079: JCP4038.B8 5.72,65.2 5.78,65.13 7.46,65.13 7.58,65.01 7.58,64.2 8.45,63.33 10.62,63.33 11.02,63.74 11.02,64.07 11.25,64.3 11.48,64.3 11.62,64.16 v1(11.62,63.97)
  BOTTOM w0.102: R1C12.1 18.14,59.5 17.98,59.67 17.34,59.67 17.2,59.53 RCP4184.2 16.77,59.44 16.01,59.44 15.53,59.92 15.53,62.22 14.17,63.58 13.63,63.58 13.43,63.38 12.98,63.38 12.57,63.8 12.57,64.15 U133.3 12.35,64.37 12.08,64.37 12.01,64.3 11.75,64.3 11.62,64.16 v1(11.62,63.97)
USBC1_SSUSBC1_AUX_RFU2_C: length 2.1
  BOTTOM w0.102: R1C12.2 19.36,59.55 19.58,59.55 19.94,59.91 19.94,60.08 20.05,60.18 U96.21
USBPD_BOOT0: length 94.6
  TOP w0.102: v1(93.97,20.76) 93.26,21.47 93.26,22.41 89.78,25.9 89.78,26.51 v1(88.09,28.19) 86.4,29.88 84.25,29.88 82.75,31.38 75.74,31.38 73.53,33.59 70.77,33.59 67.83,36.53 67.83,38.22 63.92,42.12 63.92,42.84 66.29,45.2 66.29,46.47 65.79,46.97 65.45,46.97 65.04,46.57 64.73,46.57 61.86,43.7 61.16,43.7 60.93,43.92 57.29,43.92 57.16,44.05 50.48,44.05 50.38,44.15 44.37,44.15 43.94,44.58 R3609.1 43.81,44.86 43.55,44.61 42.26,44.61 41.88,44.99 41.88,45.63 41.62,45.88 U130.2
  BOTTOM w0.102: CN17.43 98.73,12.01 98.47,12.28 96.92,12.28 95.19,10.55 92.48,10.55 90.98,12.06 90.98,18.27 93.46,20.76 v1(93.97,20.76)
USBPD_WAKE: length 70.4
  TOP w0.102: v1(79.71,39.1) 79.25,39.56 77.77,39.56 77.54,39.78 77.54,40.27 77.09,40.72 75.74,40.72 75.33,41.13 72.84,41.13 72.4,40.69 68.69,40.69 68.01,41.37 68.01,42.89 67.3,43.6 67.3,47.07 66.34,48.04 65.06,48.04 64.79,47.77 64.32,47.77 v1(63.31,46.76) 62.3,45.75 52.15,45.75 52.07,45.68 50.36,45.68 v1(48.66,47.38) ; v1(35.63,59.85) 35.96,59.52 35.96,57.87 35.76,57.67 35.76,54.68 36.03,54.4 36.03,53.63 36.39,53.28 U95.2
  IN1 w0.079: v1(35.63,59.85) 36.72,59.85 38.96,57.61 42.37,57.61 44.15,55.83 44.8,55.18 44.8,54.62 44.55,54.37 44.55,50.88 45.48,49.94 45.48,49.56 47.67,47.38 v1(48.66,47.38)
  BOTTOM w0.102: EUPM3247.B23 79.26,39.54 v1(79.71,39.1)
USBPDRXD_SERVOTXD: length 92
  TOP w0.102: v1(101.16,14.95) 99.89,16.21 98.85,16.21 96.74,18.32 96.11,18.32 95.59,18.83 95.59,20.28 95.17,20.71 94.5,20.71 94.14,20.35 93.19,20.35 90.57,22.97 v1(90.57,23.27) 90.57,23.57 87.46,26.68 86.12,26.68 85.16,27.64 84.28,27.64 81.46,30.46 73.8,30.46 72.47,31.8 71.61,31.8 71.24,32.16 70.86,32.16 70.35,32.67 68.44,32.67 67.11,34 67.11,37.93 63.97,41.07 61.54,41.07 60.27,42.35 56.61,42.35 56.48,42.48 49.83,42.48 49.81,42.5 38.41,42.5 37.94,42.03 33.89,42.03 33.37,42.55 33.37,44.74 34.39,45.75 U95.31
  BOTTOM w0.102: v1(101.16,14.95) 101.33,14.95 102.63,13.65 102.63,12.33 103.13,11.84 CN17.21
USBPDTXD_SERVORXD: length 91.4
  TOP w0.102: U95.30 33.89,45.69 33.06,44.86 33.06,42.43 33.77,41.72 38.07,41.72 38.54,42.2 49.68,42.2 49.7,42.17 56.35,42.17 56.48,42.04 60.14,42.04 61.42,40.77 63.84,40.77 66.81,37.8 66.81,33.88 68.34,32.34 69.31,32.34 69.79,31.86 70.43,31.86 70.43,31.86 71.11,31.86 71.48,31.49 72.34,31.49 73.68,30.16 81.34,30.16 84.15,27.34 85.03,27.34 88.48,23.89 89.22,23.89 93.06,20.05 94.27,20.05 94.62,20.4 95.04,20.4 95.29,20.16 95.29,18.63 95.9,18.02 96.61,18.02 98.72,15.91 99.46,15.91 v1(100.47,14.89)
  BOTTOM w0.102: v1(100.47,14.89) 100.88,14.49 101.36,14.49 102.33,13.52 CN17.25
V_BOOSTIN_SENSE: length 4.9
  BOTTOM w0.102: v1(73.8,39.2) 73.76,39.16 R1022.2 74.25,38.39 C968.1 75.11,39.25 R1023.1 76.33,39.79 EUPM3247.A22
VBSTVR1: length 5.1
  TOP w0.33: PC1264.1 66.51,71.47 66.51,73.09 66.84,73.41 66.85,73.41 v1(66.97,73.54) 67,73.54 68.01,74.56 68.01,74.67 v4(67.99,74.69)
  BOTTOM w0.305: PU3254.R14 v4(67.99,74.69)
VBSTVR3: length 7.1
  TOP w0.305: PC3.1 65.51,85 66.29,85 66.56,84.73 66.56,84.25 66.85,83.95 67.41,83.95 67.5,83.86 67.67,83.86 68.06,83.47 v1(68.06,83.27) 68.06,82.71 68.53,82.25 v4(68.53,81.17)
  BOTTOM w0.254: PU3254.B13 68.51,81.19 v4(68.53,81.17)
VBSTVR4: length 4.1
  TOP w0.254: PC1265.1 72.45,83.54 72.45,82.05 v1(72.26,81.85) 72.26,81.35 v4(72.43,81.17)
  BOTTOM w0.254: v4(72.43,81.17) 72.47,81.13 PU3254.C4
VBSTVR5: length 9.7
  TOP w0.305: PC1266.1 77.11,76.38 v1(77.24,76.26) 77.36,76.13 77.36,73.82 77.03,73.49 76.35,73.49 75.89,73.03 74.38,73.03 73.74,73.68 73.74,74.08 73.13,74.69 v4(73.03,74.69)
  BOTTOM w0.254: 72.96,74.69 v4(73.03,74.69)
  BOTTOM w0.305: PU3254.R4 72.96,74.69
VDCSNS: length 6
  TOP w0.127: v1(75.86,79.99) 76.08,80.21 PR135.1 PR180.1
  BOTTOM w0.203: PU3254.G1 74.11,78.54 76.12,78.54 76.52,78.95 76.52,79.51 76.04,79.99 v1(75.86,79.99)
VREF1.25V: length 4.4
  BOTTOM w0.203: PC9111.1 v1(75.84,81.63) 75.16,81.63 74.52,80.99 74.52,80.53 74.18,80.19 PU3254.D1
VREFDQ_CHA: length 49.2
  TOP w0.381: v3(168.25,70.57) 168.3,70.53 CSM2029.1 ; RAP1027.2 RAP1032.1 165.95,86.64 RAP1031.2 165.35,86.65 164.74,86.04 v1(164.74,85.15) ; v3(152.65,81.81) 152.59,81.75 CSM1017.1
  IN1 w0.381: v3(152.65,81.81) 152.65,80.93 153.97,79.61 156.77,79.61 160.35,83.2 160.35,84.03 161.85,85.52 164.36,85.52 v1(164.74,85.15) ; 174.21,77.6 173.67,77.06 173.67,76.7 173.98,76.4 173.98,72.47 172.08,70.57 v3(168.25,70.57)
  IN1 w0.508: v1(164.74,85.15) 166.59,83.29 170.32,83.29 174.21,79.41 174.21,77.6
  BOTTOM w0.203: v3(168.25,70.57) 168.58,70.9 USM2000.J11
  BOTTOM w0.381: v3(152.65,81.81) 152.33,82.13 USM2001.J11
VREFDQ_CHB: length 90.8
  TOP w0.381: v1(150.3,92.73) v1(146.62,92.73) 139.31,92.73 138.42,93.62 135.47,93.62 134.82,94.27 130.22,94.27 v1(129.75,94.74) ; RAP1028.2 RAP1034.1 168.58,85.82 168.61,85.85 RAP1033.2 168.17,86.65 167.96,86.44 v1(167.96,85.5) ; v3(130.09,83.96) 130.09,84.54 CSM2097.1 ; v3(111.38,83.92) 111.38,84.56 CSM2129.1
  IN1 w0.381: v3(110.75,93.3) 110.69,93.25 110.69,87.95 111.36,87.29 111.36,83.95 v3(111.38,83.92) ; v1(129.75,94.74) 129.75,93.8 129.44,93.5 129.44,88.08 130.09,87.42 v3(130.09,83.96)
  IN2 w0.381: v1(167.96,85.5) 167.96,85.67 167.43,86.2 162.89,86.2 160.29,88.81 158.81,88.81 154.88,92.73 v1(150.3,92.73)
  BOTTOM w0.254: v3(111.38,83.92) 111.38,84.02 111.11,84.29 USM2003.J11 ; USM2002.J11 129.77,84.28 v3(130.09,83.96)
  BOTTOM w0.381: v1(129.75,94.74) 129.75,95.09 129.17,95.66 126.33,95.66 123.5,92.83 118.83,92.83 117.62,94.04 111.49,94.04 v3(110.75,93.3)
WAKE_EVENT: length 17.2
  BOTTOM w0.102: QPM3374.3 74.67,29.5 75.68,28.48 82.95,28.48 v1(83.43,28) 83.69,27.74 83.69,25.19 85.08,23.79 R3597.2 85.45,23.79 85.82,24.16 85.82,24.67 85.7,24.79 U123.1
WAKE_L*: length 21.5
  BOTTOM w0.102: CR9.2 71.29,31.28 70.76,30.74 70.76,30.13 71.85,29.04 72.85,29.04 73.39,28.51 74.41,28.51 74.77,28.15 QPM3374.2 74.77,26.75 75.05,26.47 v1(76.13,26.47) 77.21,26.47 77.48,26.75 QPM3373.3 77.48,27.99 77.77,28.28 81.09,28.28 81.29,28.08 QPM3372.3 81.29,26.79 81.5,26.58 82.14,26.58 82.65,27.09 R3596.1
WIFI_CLK_REQ*: length 173.2
  TOP w0.102: v3(106.67,65.54) 106.62,65.48 104.1,65.48 99.67,69.92 99.48,69.92 98.65,70.75 98.65,72.27 R1113.2 ; Q113.3 190.14,19.21 v1(190.44,19.51)
  IN2 w0.079: v3(106.67,65.54) 104.91,65.54 103.19,67.26 101.52,67.26 98.84,69.94 95.66,69.94 93.72,68 93.72,67.65 93.4,67.33 93.4,64.59 91.42,62.61 89.54,62.61 87.86,60.93 87.86,59.05 86.96,58.15 86.96,57.66 86.68,57.38 86.68,49.89 90.54,46.04 90.54,43.4 92.21,41.72 92.21,41.14 92.5,40.86 93.35,40.86 96.59,37.63 97.07,37.63 97.97,36.72 99.91,36.72 101.03,35.6 101.03,34.07 102.45,32.65 102.45,31.61 104.76,29.3 104.76,28.95 106.02,27.69 108.96,27.69 109.42,27.24 116.61,27.24 120.04,23.8 124.13,23.8 124.6,23.33 146.11,23.33 147.07,22.37 147.73,22.37 150.41,19.69 154.83,19.69 155.08,19.94 166.77,19.94 167.09,20.26 169.54,20.26 169.55,20.26 172.62,20.26 173.53,21.16 182.22,21.16 183.91,19.46 190.34,19.46 v1(190.44,19.51)
  BOTTOM w0.076: v3(106.67,65.54) 106.67,65.06 U80.AT7
WIFI_PCIE_CLK_DN: length 121.6
  IN1 w0.079: v1(111.41,29.19) 111.6,29.39 111.6,29.85 112.21,30.46 115.58,30.46 116.55,31.44 116.55,33.91 115.2,35.26 115.2,37.85 119.56,42.2 122.98,42.2 125.47,44.69 126.3,44.69 v1(126.47,44.87)
  BOTTOM w0.102: v1(126.47,44.87) 126.47,44.75 126.59,44.63 127.1,44.63 127.34,44.87 127.34,46.03 127.53,46.22 127.78,46.22 U80.B42 ; CN8.49 186.49,17.45 186.33,17.6 186.33,17.68 186.27,17.74 186.14,17.74 185.19,16.79 185.19,16.09 184.38,15.28 165.67,15.28 164.38,16.57 158.77,16.57 157.17,14.97 153.16,14.97 152.83,15.3 152.14,15.3 v1(151.78,14.94) 151.45,15.27 118.34,15.27 117.63,15.98 114.99,15.98 114.51,16.46 114.51,18.71 114.79,18.99 114.79,19.83 114.45,20.18 114.11,20.18 113.61,20.68 113.61,25.71 111.72,27.6 111.72,28.55 111.59,28.67 111.59,29.01 v1(111.41,29.19)
WIFI_PCIE_CLK_DP: length 121.6
  IN1 w0.079: v1(112.14,29.19) 111.99,29.19 111.79,29.4 111.79,29.78 112.29,30.28 115.66,30.28 116.74,31.36 116.74,33.98 115.38,35.34 115.38,37.77 119.64,42.02 123.06,42.02 125.54,44.51 126.28,44.51 126.47,44.32 v1(126.47,44.16)
  BOTTOM w0.102: v1(112.14,29.19) 111.93,29.19 111.8,29.07 111.8,28.76 111.93,28.63 111.93,27.69 113.82,25.8 113.82,20.77 114.2,20.39 114.54,20.39 115,19.92 115,18.91 114.72,18.63 114.72,16.54 115.08,16.19 117.72,16.19 118.42,15.48 151.05,15.48 v1(151.78,16.21) 152.49,15.51 152.92,15.51 153.25,15.18 157.08,15.18 158.68,16.78 164.47,16.78 165.75,15.49 184.29,15.49 184.98,16.18 184.98,16.87 186.06,17.95 CN8.47 ; v1(126.47,44.16) 126.73,44.42 127.19,44.42 127.53,44.76 127.53,45.95 127.61,46.03 127.74,46.03 U80.A42
WLAN_OFF*: length 163.3
  TOP w0.102: v1(157.29,16.87) 159.35,18.93 164.58,18.93 166.11,17.4 179.64,17.4 180.81,18.58 182.11,18.58 186.82,13.87 190.84,13.87 192.13,15.16 v1(193.14,15.16) 194.15,15.16 C1105.1 R5117.1
  IN2 w0.079: v1(77.8,54.42) 77.8,54.41 75.96,52.57 75.96,51.69 75.4,51.14 75.4,50.35 75.88,49.87 75.88,48.04 75.39,47.55 75.39,43.1 75.87,42.62 75.87,41.5 77.65,39.72 77.65,37.23 78.07,36.81 78.07,33.8 78.85,33.03 78.85,32.22 80.4,30.67 80.4,29.4 80.84,28.96 82.34,28.96 83.73,27.57 86.57,27.57 86.82,27.32 86.82,25.6 90.91,21.51 92.4,21.51 95.61,18.31 96.7,18.31 96.89,18.12 104.26,18.12 104.7,17.68 109.63,17.68 110.18,17.13 113.58,17.13 116.67,20.22 121.17,20.22 121.93,19.47 141.37,19.47 141.6,19.69 143.43,19.69 145.84,17.28 156.89,17.28 v1(157.29,16.87)
  BOTTOM w0.102: v1(77.8,54.42) 78.04,54.18 78.04,53.09 78.52,52.61 80.59,52.61 81.37,51.82 R5078.2
WLAN_PCIE_WAKE*: length 163.7
  TOP w0.102: R1144.1 R1139.2 186.35,15.53 186.17,15.35 185.92,15.35 v1(184.52,16.74) 183.13,18.14 v1(183.13,19.69)
  IN2 w0.079: v1(183.13,19.69) 182.04,20.77 173.69,20.77 172.78,19.87 169.39,19.87 169.38,19.88 167.25,19.88 166.93,19.56 155.24,19.56 154.96,19.29 149.43,19.29 148.07,20.65 148.07,20.92 147.01,21.98 146.91,21.98 145.94,22.95 124.44,22.95 123.97,23.42 119.88,23.42 116.47,26.83 109.28,26.83 108.8,27.3 102.18,27.3 97.43,32.06 97.43,33.23 95.32,35.34 95.32,36.19 92.99,38.51 92.84,38.51 92.18,39.18 92.18,39.87 91.29,40.76 91.29,41.34 89.69,42.94 89.69,44.29 89.14,44.83 89.14,45.09 86.77,47.47 86.77,49.01 86.29,49.5 86.29,57.53 86.58,57.82 86.58,58.31 87.48,59.21 87.48,61.09 89.92,63.53 91.77,63.53 92.98,64.75 92.98,67.45 93.34,67.81 93.34,68.16 95.5,70.32 99,70.32 99.58,69.75 101.68,67.65 103.35,67.65 105.07,65.92 106.9,65.92 107.61,65.21 107.61,64.73 107.87,64.47 107.87,64.1 v3(107.52,63.75)
  BOTTOM w0.102: U80.AP7 107.5,63.75 v3(107.52,63.75)
XCLK_BIASREF: length 8.6
  BOTTOM w0.102: U80.E42 127.04,48.33 126.85,48.33 126.54,48.03 126.54,45.61 125.94,45.01 125.94,43.38 v1(127.07,42.25) 127.09,42.22 127.09,41.4 RAP1091.1
XDP_BPM<2>: length 6.5
  BOTTOM w0.076: U80.B54 134.57,46.16 134.57,45.75 134.57,45.75 134.57,44.16 135.89,42.83 135.89,42.3 135.97,42.22 135.97,41.06 TP23.1
XDP_BPM<3>: length 7.8
  BOTTOM w0.076: TP24.1 136.82,40.3 136.82,40.62 136.55,40.88 136.55,42.48 136.39,42.65 136.39,43.07 135.16,44.3 135.16,46.81 U80.C56
XDP_JTAG_TRST*: length 13.6
  TOP w0.102: v1(139.47,42.55) 139.29,42.73 138.98,42.73 138.21,43.5 v3(137.89,43.5)
  BOTTOM w0.076: v1(139.47,42.55) 139.47,42.19 140.1,41.56 TP271.1 ; U80.C61 137.9,46.91 138.3,46.51 138.3,46.02 138.32,45.95 138.34,45.93 138.34,45.56 138.16,45.39 138.16,45 139.59,43.57 139.59,43.04 139.84,42.78 ; U80.B59 137.1,46.11 137.1,44.66 137.89,43.87 v3(137.89,43.5)
  BOTTOM w0.102: 139.84,42.78 140.4,42.22 TP271.1
XDP_OVERRIDE*: length 77.2
  TOP w0.102: PU15.6 81.74,63.95 v1(81.85,63.84) 82.13,63.56 84.37,63.56 85.06,62.87 85.06,61.7 85.39,61.37 85.39,58.52 84.77,57.91 84.77,52.48 84.34,52.05 v1(84.34,52.03) ; PU11.6 101.83,32.15 v1(101.52,31.84)
  IN2 w0.079: v1(101.52,31.84) 101.87,32.19 101.87,32.69 100.42,34.14 98.41,34.14 97.35,35.21 v1(97.35,36.51) ; v1(81.85,63.84) 82.01,63.84 86.43,68.26 86.43,68.83 87.14,69.54 87.14,71.26 87.38,71.51 87.38,74.5 88.94,76.05 88.94,77.42 91.8,80.28 92.96,80.28 93.42,79.83 v1(93.59,79.83)
  BOTTOM w0.102: v1(93.59,79.83) 93.59,80.42 92.8,81.21 92.8,81.85 92.04,82.61 92.04,83.52 92.52,84.01 92.52,85.23 93.13,85.83 RAP1386.1 ; v1(84.34,52.03) 84.49,52.03 88.33,48.19 88.94,48.19 90.04,47.09 90.63,47.09 91.08,46.64 92.22,46.64 92.78,46.08 92.78,44.24 94.13,42.89 94.13,41.71 97.53,38.31 97.53,36.69 v1(97.35,36.51)
XDP_SPI0_IO2: length 0.9
  BOTTOM w0.102: RAP1044.1 93.21,82.33 93.26,82.38 RAP1385.1
XDP_TCLK0: length 1
  TOP w0.102: RAP1351.1 138.82,40.89 138.72,40.99 RAP1352.1
XDP_TCLK_JTAGX: length 5.9
  TOP w0.102: RAP1352.2 139.5,41.88 138.98,42.4 138.6,42.4 137.89,43.11 137.69,43.11 137.39,43.41 v3(137.39,43.76)
  BOTTOM w0.076: v3(137.39,43.76) 136.94,44.21 136.94,45.62 U80.A59
XDP_TDI: length 1
  BOTTOM w0.076: RAP1382.2 139.46,39.5 RAP1381.2
XDP_TDO: length 1
  TOP w0.102: RAP1377.2 RAP1376.2
XDP_TMS: length 1
  TOP w0.102: RAP1384.2 140.25,38.1 140.29,38.06 RAP1383.2
XTAL24_IN: length 9.2
  BOTTOM w0.102: U80.E37 124.63,48.5 125.17,47.96 125.17,47.63 125.27,47.54 125.27,47.27 125.2,47.2 125.2,46.96 125.27,46.89 125.27,46.64 124.92,46.29 124.92,45.48 124.59,45.16 124.59,44.22 124.25,43.87 124.25,41.68 RAP1087.1 124.57,41.37 RAP1089.2
XTAL24_IN_R: length 5.5
  BOTTOM w0.102: X5.3 123.84,35.75 123.84,37.03 124.44,37.63 C186.2 124.58,37.71 v1(124.58,38.67) 124.58,39.16 124.57,39.17 RAP1089.1
XTAL24_OUT: length 9.3
  BOTTOM w0.102: RAP1090.2 123.54,41.19 RAP1087.2 123.85,41.5 v1(123.85,42.69) 123.85,43.87 124.37,44.4 124.37,45.23 124.68,45.55 124.68,46.59 124.62,46.65 124.62,46.86 124.7,46.93 124.7,47.21 124.52,47.39 124.29,47.39 124.06,47.62 124.06,48 U80.E35
XTAL24_OUT_R: length 5.6
  BOTTOM w0.102: X5.1 123.01,36.89 C187.2 123.74,37.63 123.84,37.73 123.84,38.01 123.74,38.11 123.41,38.11 123.31,38.21 v1(123.31,38.49) 123.44,38.62 124,38.62 124.09,38.71 124.09,39.05 123.98,39.15 123.64,39.15 123.54,39.25 RAP1090.1
N621143: length 1.3
  TOP w0.102: v3(110.42,57.53) 110.27,57.68 TP254.1
  BOTTOM w0.102: v3(110.42,57.53) 110.42,57.76 U80.AD12
N826528: length 2.6
  BOTTOM w0.102: Q5.2 184.24,71.53 v1(184.37,71.41) 184.5,71.28 R873.2
N2450832: length 11
  BOTTOM w0.076: 106.98,68.7 107.33,68.7 107.55,68.48 107.55,68.08 U80.BA7
  BOTTOM w0.102: 106.98,68.7 106.42,68.7 106.23,68.89 106.18,68.89 105.21,69.86 104.92,69.86 103.09,71.69 102.25,71.69 102.07,71.86 102.07,72.78 102.38,73.08 102.38,74.38 TP223.1
N2450844: length 8.3
  BOTTOM w0.076: U80.AY7 107.28,67.43 107.44,67.59 107.46,67.67 107.46,67.76 107.7,68 107.7,68.55 107.38,68.87 106.98,68.87
  BOTTOM w0.102: 106.98,68.87 106.49,68.87 105.33,70.04 105.1,70.04 102.96,72.17 TP224.1
N2523339: length 23
  TOP w0.102: v1(98.17,71.92) 98.03,72.06 98.03,72.32 97.76,72.59 96.75,72.59 96.39,72.22 96.39,71.81 95.98,71.41 95.3,71.41 94.92,71.03 TP225.1
  IN1 w0.079: v1(98.17,71.92) 98.72,71.37 99.47,71.37 103.56,67.29 107.05,67.29 107.7,66.64 108.89,66.64 109.92,65.61 109.92,64.81 110.11,64.61 110.57,64.61 110.76,64.42 110.76,64.17 v1(111.22,63.71)
  BOTTOM w0.102: U80.AP13 110.84,63.34 111.21,63.71 v1(111.22,63.71)
N3058945: length 2.6
  BOTTOM w0.102: CN3.8 172.25,22.64 172,22.89 TP169.1
N3058949: length 8.6
  BOTTOM w0.102: 167.61,21.88 169.51,21.88 169.89,22.26 169.89,23.18 170.27,23.56 v1(172.04,23.56) RCP4037.2 173.25,23.25 CN3.7
N3652181: length 3.2
  TOP w0.102: U90.20 19.37,67.61 18.41,66.64 TP172.1
N5008121: length 10.5
  IN1 w0.079: v1(77.67,47.1) 77.63,47.06 v1(76.24,47.06)
  BOTTOM w0.102: v1(76.24,47.06) 76.08,46.9 CRPM3519.1 75.15,46.9 74.77,47.28 74.77,48.67 74.9,48.8 CRPM3518.1 ; EUPM3247.A34 79.46,47.54 v1(79.09,47.91) 79.08,47.92 CPM3436.2 78.83,48.93 78.65,48.75 78.65,48.24 77.67,47.25 v1(77.67,47.1)
N5041796: length 1.3
  BOTTOM w0.102: U123.5 87.17,26.33 87.18,26.32 R5050.1
N5043216: length 7.6
  BOTTOM w0.102: QPM3371.3 85.18,27.21 v1(85.2,27.19) 85.82,26.58 85.82,25.99 86,25.81 U123.6 87.21,25.81 C1025.1 88.2,25.79 89.39,25.79 R3591.1
N5044582: length 4.7
  BOTTOM w0.102: U123.7 86.96,25.31 87.72,24.55 C1026.1 88.6,23.4 v1(88.64,23.4) 88.99,23.4 R3592.1
N5046702: length 3.6
  BOTTOM w0.102: C1027.1 R3593.1 81.5,30.77 v1(81.25,30.51) 80.27,29.54 QPM3372.2
N5047139: length 4
  BOTTOM w0.102: QPM3373.2 76.46,30.18 76.74,30.45 77.09,30.45 v1(77.28,30.64) 78.04,31.39 R3594.1 C1028.1
N5279525: length 2.9
  BOTTOM w0.102: R979.1 14.48,53.62 14.38,53.72 U124.3 14.38,54.96 14.27,55.07 13.66,55.07 13.51,54.92 v1(13.51,54.82)
N5880717: length 2.7
  TOP w0.102: U130.5 43.27,45.88 43.4,46 R3604.2 43.96,46.21 43.64,46.53 U130.6
N5880753: length 7.6
  TOP w0.102: U130.3 40.9,45.23 40.51,45.63 40.51,47.53 40.56,47.58 v1(40.56,47.86) 40.51,47.91 40.51,48.55 39.71,49.34 R3608.1 39.02,49.34 38.16,50.2 37.94,50.2 37.8,50.34 U95.44
N16755433: length 42.8
  BOTTOM w0.178: PR141.2 157.61,27.61 167.66,27.61 168.71,28.66 179.93,28.66 180.83,29.56 180.83,31.78 181.65,32.6 184.83,32.6 185.16,32.27 187.38,32.27 v1(187.39,32.28) 187.48,32.2 196.14,32.2 PR155.2
N16801182: length 3.4
  TOP w0.305: R1A1.2 R1A2.1 27.33,17.38 v1(26.97,17.38) 26.36,16.77 U1.16
N16801272: length 2.3
  TOP w0.254: U1.11 26.35,14.27 27.24,13.38 C1C45.1
N16801274: length 2.5
  TOP w0.254: C1C45.2 27.51,12.6 26.34,13.77 U1.10
N16801326: length 29.5
  IN2 w0.079: v1(108.49,59.53) 108.16,59.87 104.78,59.87 103.62,58.7 100.2,58.7 99.51,58.02 96.95,58.02 96.26,57.33 95.57,57.33 95.19,57.72 94.59,57.72 94.38,57.51 92.57,57.51 91.61,56.55 91.15,56.55 90.6,56 90.6,55.32 90.82,55.1 90.82,54.3 90.94,54.18 90.94,52.32 91.44,51.81 91.44,51.17 90.91,50.64 v1(90.91,48.76)
  BOTTOM w0.102: v1(90.91,48.76) 91.15,49.01 TP275.1 ; v1(108.49,59.53) 108.49,59.87 U80.AH9
N16801328: length 30.4
  IN2 w0.079: v1(90.47,49.23) 90.47,50.45 91.26,51.25 91.26,51.74 90.75,52.25 90.75,54.11 90.64,54.22 90.64,55.03 90.42,55.24 90.42,56.08 91.08,56.73 91.54,56.73 92.49,57.69 94.31,57.69 94.52,57.9 95.26,57.9 95.65,57.51 96.18,57.51 96.87,58.2 99.44,58.2 100.12,58.88 103.55,58.88 104.71,60.05 108.66,60.05 v1(109.18,59.53)
  BOTTOM w0.102: v1(90.47,49.23) TP276.1 ; U80.AH10 109.18,59.83 v1(109.18,59.53)
N16820602: length 5.6
  TOP w0.102: v1(40,26.2) 40,24.89 R1B27.1 R1D11.1 38.42,24.16 38.02,23.76 U3.2
N16823303:
  vias: v1(35.1,12.61) v1(35.7,12.61)
N16823308:
  vias: v1(38.37,14.1) v1(38.37,13.44)
N16823317:
  vias: v1(32.61,14.13) v1(32.61,13.5) v1(33.7,14.84)
N16823326:
  vias: v1(30.57,14.51) v1(30.55,13.88)
N16913701: length 8.4
  TOP w0.102: v3(106.16,56.44) 105.82,56.44 105.25,55.88 102.24,55.88 101.97,55.61 101.89,55.68 TP277.1
  BOTTOM w0.102: v3(106.16,56.44) 105.64,55.92 U80.W4
N16916260: length 2.5
  TOP w0.203: v1(196.64,40.53) 196.62,40.51 196.62,40.5 196.6,40.47 PU5.4
  BOTTOM w0.203: PC9105.1 196.74,40.43 v1(196.64,40.53) 197,40.89 PR159.2
N16918204: length 4.3
  TOP w0.254: PR56.2 197.5,43.33 197.71,43.55 PR117.1 198.53,43.55 v1(198.58,43.6)
  BOTTOM w0.203: PR172.2 198.02,44.47 198.26,44.71 v1(198.26,45.07)
  BOTTOM w0.254: PR172.2 198.1,44.08 v1(198.58,43.6) 198.98,44 PC9096.2
N16918510: length 5.1
  TOP w0.203: PU5.5 196.2,40.25 196.18,40.26 196.18,41.05 v1(196.23,41.1) 196.38,41.25 v1(196.38,41.73)
  BOTTOM w0.203: v1(196.38,41.73) 196.69,41.73 PR151.1 197.12,43 PR149.1 PR172.1
N16919684: length 39.5
  TOP w0.203: PR177.2 197.27,42.57 PR143.1 196.83,42.38 v1(196.5,42.71)
  IN1 w0.203: v1(172.48,48.27) 172.97,48.75 172.97,51.74 175.92,54.69 186.96,54.69 190.31,51.34 190.31,45.4 191.15,44.56 194.07,44.56 195.92,42.71 v1(196.5,42.71)
  BOTTOM w0.203: PR162.2 v1(172.48,48.27)
N16924869: length 5.7
  TOP w0.203: PR57.2 195.98,42.48 v1(195.83,42.32) 195.7,42.2 v1(195.7,40.66) 195.8,40.56 PU5.6
  BOTTOM w0.203: v1(195.7,40.66) 195.78,40.58 PR116.2 PC1295.1
N16926106: length 2.3
  BOTTOM w0.203: v1(191.15,32.76) PC9091.2 193.14,32.76 PR156.2
N16926742: length 5.3
  TOP w0.203: PR150.1 194.7,32.75 194.75,32.7 v1(194.76,32.71) 194.76,32.38 PR168.1 195.09,32.13 195.6,32.13 195.96,32.5 195.96,33.03 195.8,33.2 PU5.25
  BOTTOM w0.203: v1(194.76,32.71) 194.46,33.01 PR156.1
N16929406: length 5.4
  TOP w0.203: PR60.2 195.46,31.73 PR168.2 ; v1(194.71,30.49) 195.05,30.83 PR168.2 ; PR168.2 194.56,31.32 PR115.1 193.59,32.29 192.72,32.29 PC9093.2
N16931159: length 5.7
  TOP w0.203: PU5.26 196.2,33.47 196.48,33.19 196.48,32.97 ; 196.48,32.97 197,32.45 197,31.73 PR61.2 ; 196.48,32.97 v1(196.48,32.91)
  BOTTOM w0.203: v1(196.48,32.91) 196.48,33.74 PR114.2 PC1297.1
N16935900: length 4.6
  TOP w0.203: PU5.20 193.06,35.25 192.65,34.84 192.2,34.84 191.7,34.33 v1(191.52,34.33)
  BOTTOM w0.203: v1(191.52,34.33) 191.52,34.12 191.22,33.82 191.1,33.82 PR186.1 190.35,33.07 PR131.1
N16938871: length 2.4
  BOTTOM w0.203: PR183.1 191.84,37.01 192.59,37.75 192.59,38.2 193.09,38.7 PC9115.1
N16939091: length 3.3
  TOP w0.203: PU5.16 192.5,36.85 192.45,36.8 v1(192.45,36.78)
  BOTTOM w0.203: PC9104.1 193.09,37.74 192.45,37.1 v1(192.45,36.78) 191.89,36.23 PR183.2
N16939409: length 1.8
  BOTTOM w0.203: v1(189.58,38.92) 189.59,38.93 PC9121.1 PR153.1
N16939413: length 6.1
  TOP w0.203: PU5.17 192.76,36.45 192.64,36.32 192.25,36.32 v1(191.84,36.73) 191.63,36.95 191.51,36.95 191.16,37.3 190.78,37.3 v1(190.74,37.34) 190.38,37.7 190.11,37.96 PR184.2 190.18,38.23 PR130.1
  BOTTOM w0.203: v1(190.74,37.34) 191.18,37.78 PR153.2
N16939441: length 6.6
  TOP w0.203: PC9095.1 189.22,38.27 PR184.1 189.33,38.06 189.93,37.46 189.93,37.01 PR58.1 190.19,36.74 v1(190.93,36.74)
  BOTTOM w0.203: v1(188.21,36.48) 188.56,36.13 189.36,36.13 PR112.1 190.83,36.64 v1(190.93,36.74)
N16939455: length 1.9
  TOP w0.203: v1(191,40.11) 190.8,40.11 190.58,39.89 PR130.2 PC9095.2
N16949411: length 3.7
  TOP w0.203: PU5.24 195.4,32.75 v1(195.45,32.69)
  BOTTOM w0.203: v1(195.45,32.69) 195.93,33.16 PR169.1 195.93,33.72 196.02,33.82 PC9106.1
N17027313: length 1.2
  TOP w0.102: TP114.1 68.36,76.14 v4(68.46,76.14)
  BOTTOM w0.102: v4(68.46,76.14) 68.46,76.67 PU3254.L12
N17027315: length 4.4
  BOTTOM w0.102: TP112.1 63.16,74.99 64.04,75.86 65.33,75.86 65.58,76.11 66.39,76.11 PU3254.M16
N17027317: length 1.5
  TOP w0.102: TP113.1 68.45,74.73 68.44,74.73 v4(68.44,75.13)
  BOTTOM w0.102: v4(68.44,75.13) 68.44,75.41 68.47,75.44 PU3254.N12
N17027335: length 8.7
  TOP w0.079: 75.56,72.73 73.83,72.73 v1(73.55,73.01) 73.42,73.13 73.42,74 73.12,74.3 72.91,74.3 72.49,74.72 v4(72.49,75.19)
  TOP w0.102: 75.56,72.73 76.02,72.73 76.42,73.13 78.24,73.13 PR41.1
  BOTTOM w0.102: PU3254.P3 v4(72.49,75.19)
N17027643: length 3.3
  TOP w0.079: TP71.1 66.39,75.06 67.03,75.71 67.03,76.27 67.46,76.7 v4(67.91,76.7)
  BOTTOM w0.079: PU3254.M13 67.97,76.64 v4(67.91,76.7)
N17032291: length 8.2
  TOP w0.079: 66.18,72.47 66.18,73.39 68.58,75.78 68.6,75.78 68.93,76.11 v4(68.93,76.72)
  TOP w0.102: v1(65.12,71) 65.72,71 PR148.1 66.18,71.47 66.18,72.47
  BOTTOM w0.102: v4(68.93,76.72) 68.97,76.68 PU3254.M11
N17032349: length 3.9
  TOP w0.079: v4(68.97,80.74) 68.9,80.8 68.9,81.74 69.02,81.87 v1(69.02,81.99) 69.02,82.39 68.93,82.48 PR54.2 PR136.1
  BOTTOM w0.102: v4(68.97,80.74) PU3254.D11
N17032386: length 4.3
  TOP w0.079: v1(75.33,79.61) 75.46,79.74 75.46,80.64 PR187.1
  BOTTOM w0.079: 74.28,79.44 73.86,79.44 73.61,79.19 PU3254.F3
  BOTTOM w0.102: v1(75.33,79.61) 75.01,79.29 74.43,79.29 74.28,79.44
N17032403: length 5.4
  TOP w0.079: PR75.1 65.28,76.34 66.02,77.09 PR53.2 66.82,77.09 67.28,77.55 67.88,77.55 v4(67.97,77.64)
  TOP w0.102: PR76.1 65.38,75.6 PR75.1
  BOTTOM w0.102: v4(67.97,77.64) 67.51,77.64 PU3254.J14
N17032485: length 2
  TOP w0.102: PR66.1 77.11,78.88 PC1266.2 77.87,78.03 v1(77.97,78.14)
N17032524: length 13.5
  TOP w0.079: v4(67.98,78.66) 67.97,78.66 67.46,78.66 67.03,79.09 67.03,79.48
  TOP w0.152: 67.03,79.48 65.53,80.98 64.89,80.98 64.4,80.49 63.76,80.49 62.73,79.46 62.32,79.46 v1(61.26,80.53) 61.1,80.68 61.1,83.7 60.87,83.94 60.58,83.94 PR23.1
  BOTTOM w0.102: PU3254.G12 68.44,78.66 67.98,78.66 v4(67.98,78.66)
N17032530: length 8.5
  TOP w0.102: PR36.2 64.09,78.43 64.32,78.2 PR77.1 64.32,76.82 63.9,76.4 63.9,74.9 v1(63.8,74.79)
  BOTTOM w0.079: 65.68,73.85 66.61,73.85 66.71,73.95 66.71,74.43 PU3254.R15
  BOTTOM w0.102: v1(63.8,74.79) 64.73,74.79 65.68,73.85
N17032584: length 2.2
  TOP w0.33: PC1264.2 66.99,69.17 PR69.1 66.68,68.8 66.5,68.8 v1(66.16,68.46)
N17032600: length 1.1
  TOP w0.254: PC1265.2 73.73,84.53 PR67.1
N17032831: length 16.2
  TOP w0.079: v4(69.43,79.19) 68.96,79.19 68.59,78.82 68.33,78.82 67.52,79.62 67.23,79.62
  TOP w0.152: 67.23,79.62 65.62,81.24 64.78,81.24 64.29,80.75 63.42,80.75 63.02,80.35 62.04,80.35 61.69,80.7 61.44,80.96 61.43,80.96 61.36,81.03 61.36,83.81 60.97,84.19 59.74,84.19 59.63,84.08 v1(59.33,84.08) 59.27,84.14 PR189.1
  BOTTOM w0.152: PU3254.G10 69.43,78.73 v4(69.43,79.19)
N17032859: length 12.4
  BOTTOM w0.305: PU3254.H15 PU3254.H16 66.39,78.27 62.4,78.27 62.02,78.65 62.02,82.23 63.34,83.55 v1(63.34,84.46) JP3571.2
N17034135:
  vias: v1(163.42,28.25)
N17034237: length 2.5
  TOP w0.305: PR70.2 164.86,28.9 v1(164.49,28.54) 164.13,28.18 PC1187.2
N17035157: length 2.9
  BOTTOM w0.254: v1(186.83,36.58) 186.52,36.9 PR84.1
  BOTTOM w0.381: PC1183.2 184.66,36.9 PR84.1
N17035494:
  vias: v1(83.25,58.96)
N17035762: length 7
  TOP w0.102: v1(105.71,29.62) 105.13,29.62 PR73.1 104.1,30.66 PR55.2 PR72.2 102.97,31.16 103.47,31.66 103.47,33.05 103.87,33.45 PU11.3
N17037951: length 8.4
  TOP w0.102: v1(47.13,47.61) 47.2,47.54 PR40.2 46.83,46.77 46.08,47.52 44.99,47.52 44.83,47.68 44.83,48.31 PR83.1 45.38,48.86 45.38,51.07 45.81,51.5 45.81,51.62 45.71,51.72 PU19.9
N17037965:
  vias: v1(215.89,30.34)
N17037990:
  vias: v1(100.91,94.83)
N17038224: length 2.3
  BOTTOM w0.102: v1(98.54,91.96) 98.4,92.1 PR37.2 98.65,93 98.77,92.87 PU18.2
N17042523: length 0.9
  BOTTOM w0.203: PR159.1 PC9116.1
N17042671: length 2.3
  BOTTOM w0.203: PR131.2 189.92,32.95 PC9098.2 189.57,33.59 189.36,33.38 v1(188.82,33.38)
N17042817: length 0.9
  BOTTOM w0.203: PR151.2 PC9120.2
N17042887: length 35.1
  IN2 w0.152: v1(188.65,35.1) 188.99,35.44 190.51,35.44 190.71,35.24 190.71,34.68 189.56,33.53 185.19,33.53 183.46,35.26 174.76,35.26 172.58,33.09 164.7,33.09 163.23,34.56 162.92,34.56 v1(162.76,34.71)
  BOTTOM w0.203: v1(188.65,35.1) 189.09,35.54 PR154.2 ; PR140.2 162.98,34.49 v1(162.76,34.71)
N17043312: length 3.1
  TOP w0.203: v1(194.74,40.54) 194.74,40.43 195,40.18 PU5.8
  BOTTOM w0.203: PR181.2 195.21,41.57 PC9097.1 195,40.8 v1(194.74,40.54)
N17043331: length 42.3
  TOP w0.203: PR142.2 190.84,39.08 v1(190.84,39.5)
  IN2 w0.152: v1(190.84,39.5) 190.84,37.96 191.44,37.36 191.44,35.81 191.99,35.26 191.99,34.09 190.81,32.91 181.3,32.91 180.05,31.66 168.11,31.66 167.2,32.57 164.35,32.57 163.01,33.91 161.99,33.91 161.2,34.69 v1(161.2,34.7)
  BOTTOM w0.203: v1(161.2,34.7) 161.22,34.68 PR163.2 ; v1(189.58,40.19) 189.59,40.18 PR175.2 190.4,39.95 v1(190.84,39.5)
N17043387: length 4.9
  TOP w0.178: v1(199.01,33.37) 198.98,33.37 198.76,33.6 197.44,33.6 197,34.04 PU5.28
  BOTTOM w0.203: PC25.1 200.4,32.67 200.33,32.74 PR173.1 199.82,32.74 199.19,33.37 v1(199.01,33.37)
N17043416: length 5.3
  TOP w0.203: v1(191.84,37.72) 191.91,37.65 PU5.14
  BOTTOM w0.203: v1(191.84,37.72) 192.13,38.01 PR185.2 192.61,38.82 192.61,39.16 193.09,39.63 PC9117.1 193.09,40.29 v1(192.73,40.65)
N17043440: length 3
  TOP w0.203: PU5.2 197.4,40.1 197.61,40.31 v1(197.61,40.51) 197.61,41.05 PC9119.1
  BOTTOM w0.203: v1(197.61,40.51) 197.7,40.42 PR182.2
N17043480: length 2.3
  BOTTOM w0.203: PC9096.1 199.59,43.64 v1(199.99,43.64)
  BOTTOM w0.254: PC9096.1 198.93,42.99 198.16,42.99 PR149.2
N17043520: length 1
  TOP w0.203: PC9093.1 193.27,32.71 PR150.2
N17043522: length 4.4
  TOP w0.203: PU5.23 195,33.57 v1(194.86,33.43) 193.79,33.43 v1(193.58,33.65)
  BOTTOM w0.203: PR166.2 194.09,33.89 193.86,33.65 v1(193.58,33.65) 193.43,33.65 193.13,33.94 PC9118.1
N17043589: length 2.3
  TOP w0.203: PU5.32 199.27,35.65 v1(199.74,35.19) 200.42,35.19 PR167.2
N17043595: length 3.3
  TOP w0.203: PU5.31 199.01,35.25 199.55,34.72 199.82,34.72 200.01,34.53 200.34,34.53 PR157.1 v1(200.54,33.48)
N17043625: length 5.2
  TOP w0.203: PU5.18 192.79,36.05 192.6,35.86 v1(192.45,35.86) 192.39,35.92 v1(190.85,35.92) PR59.1
  BOTTOM w0.203: v1(192.45,35.86) 192.56,35.98 PR113.2 193.09,36 PC1296.1
N17043865: length 1
  BOTTOM w0.203: PR169.2 195.15,34.16 PC9099.2
N17043953: length 35.8
  IN1 w0.203: v1(193.67,43.06) 193.67,43.06 192.47,44.25 191.03,44.25 190.01,45.27 190.01,51.21 186.91,54.31 176.07,54.31 173.35,51.59 173.35,48.19 v1(172.46,47.32)
  BOTTOM w0.203: PR152.2 194.08,42.65 v1(193.67,43.06) ; PR139.2 v1(172.46,47.32)
N17044003: length 2.1
  BOTTOM w0.203: PC9097.2 195.78,41.82 196.03,42.07 v1(196.03,42.27) 196.03,43.15 PR129.2
N17044099: length 2.1
  TOP w0.203: PU5.3 197,40.24 197.1,40.34 197.1,41.58 PR143.2
N17058418: length 5.1
  TOP w0.102: PR171.1 34.73,68.59 32.17,68.59 31.79,68.21 v1(31.79,67.93) 31.79,67.44 PU2.C2
N17135957:
  vias: v1(23.16,58.28)
N17145676: length 1.9
  TOP w0.254: v1(64.36,86.22) 64.35,86.21 PC3.2
  TOP w0.305: PC3.2 63.35,85.38 PR68.1
N17298006: length 20.1
  TOP w0.102: v1(5.94,88.15) 6.52,87.56 6.52,77.45 8.37,75.6 9.14,75.6 9.56,76.02 10.5,76.02 10.78,76.3 10.78,76.41 v1(11.19,76.82) 11.5,77.12 12.18,77.12 12.68,76.62 R1085.2
  BOTTOM w0.102: v1(5.94,88.15) 5.88,88.2 LED1.2
N17298012: length 21.3
  TOP w0.102: v1(5.83,89.7) 5.83,89.11 5.48,88.76 5.48,87.82 6.32,86.98 6.32,77.37 8.29,75.39 9.67,75.39 v1(9.82,75.55) 9.94,75.66 10.57,75.66 11.14,76.23 11.64,76.23 R1086.1
  BOTTOM w0.102: LED1.3 v1(5.83,89.7)
N17298024: length 3.7
  TOP w0.102: R1085.1 13.72,75.84 v1(13.91,75.65) 13.91,74.18 13.56,73.82 Q109.3
N17298033: length 3.9
  TOP w0.102: R1086.2 11.46,75.84 v1(11.17,75.55) 10.25,74.63 10.25,74.2 9.87,73.82 Q110.3
N17298607: length 2.2
  BOTTOM w0.102: UCP4007.6 85.54,16.94 85.59,16.99 v1(85.76,16.99) 85.79,16.96 RCP4074.2
N17298609: length 38.5
  BOTTOM w0.102: QCP4010.1 101.78,38.39 v1(101.37,38.8) 100.95,39.21 99.4,39.21 98.77,38.59 CCP4093.1 98.16,36.9 98.16,36.64 96.74,35.22 96.74,33.76 97.04,33.46 99.03,33.46 99.26,33.23 99.26,31.29 100.39,30.16 101.03,30.16 101.62,29.57 101.62,28.79 99.79,26.96 99.79,25.25 100.02,25.03 100.02,22.82 97.55,20.35 95.94,20.35 95.05,19.46 92.93,19.46 91.84,18.37 91.84,16.36 92.16,16.04 UCP4006.5
N17298611: length 38.2
  BOTTOM w0.102: UCP4006.4 92.17,16.54 92.04,16.67 92.04,18.29 93.02,19.26 95.13,19.26 96.02,20.15 97.63,20.15 100.22,22.74 100.22,25.11 99.99,25.34 99.99,26.87 101.82,28.7 101.82,29.65 101.11,30.36 100.47,30.36 99.51,31.33 99.51,33.32 99.16,33.66 97.12,33.66 96.94,33.84 96.94,35.14 98.54,36.73 CCP4093.2 100.74,36.73 101.11,36.36 QCP4010.3 101.31,37.37 QCP4010.2 99.43,38.39 v1(99.31,38.51)
N17298615: length 65.6
  IN1 w0.079: v1(91.45,14.12) 86.08,14.12 85.57,14.63 78.64,14.63 78.18,15.08 75.03,15.08 74.38,14.44 63.84,14.44 59.19,19.1 53.17,19.1 50.33,21.94 41.12,21.94 v1(40.91,21.72)
  BOTTOM w0.102: QCP4009.1 38.83,22.77 38.6,22.54 38.6,21.09 39,20.69 CCP4092.1 39.39,21.5 39.77,21.88 40.76,21.88 v1(40.91,21.72) ; v1(91.45,14.12) 92.38,14.12 94.07,15.81 94.07,16.8 93.83,17.04 UCP4006.3
N17298617: length 68.9
  IN1 w0.079: v1(91.76,13.6) 86.35,13.6 85.5,14.45 78.77,14.45 78.02,13.7 73.88,13.7 73.32,14.26 63.77,14.26 59.11,18.92 53.09,18.92 50.29,21.72 41.8,21.72 41.24,21.17 v1(41.17,21.17)
  BOTTOM w0.102: QCP4009.2 36.8,22.21 QCP4009.3 39.09,19.91 CCP4092.2 39.82,20.34 39.82,21.5 40,21.67 40.35,21.67 40.86,21.17 v1(41.17,21.17) ; UCP4006.2 93.84,17.54 94.28,17.1 94.28,15.73 92.15,13.6 v1(91.76,13.6)
N17298639: length 7.4
  BOTTOM w0.102: v1(78.48,19.11) 78.61,19.24 QCP4011.1 82.22,19.24 CCP4094.1 80.79,17.77 80.79,17.38 80.35,16.94 UCP4007.3
N17298643: length 10.3
  BOTTOM w0.102: QCP4011.3 79.62,21.27 QCP4011.2 81.53,21.27 v1(81.88,20.91) 82.24,20.56 CCP4094.2 82.75,19.49 82.75,19.03 80.99,17.28 80.99,16.94 80.35,16.29 UCP4007.2
N17298741: length 4.6
  BOTTOM w0.102: UCP4006.8 87.59,17.04 87.34,16.8 87.34,15.65 88.22,14.77 v1(88.33,14.77) RCP4072.1
N17306009: length 7.2
  BOTTOM w0.076: U80.A45 129.34,46.03 129.44,46.12 129.55,46.12 129.65,46.02 129.65,45.3 128.11,43.76 128.11,43.68
  BOTTOM w0.102: TP279.1 128.31,41.21 128.31,41.66 127.67,42.31 127.67,42.63 128.11,43.07 128.11,43.68
N17306011: length 6.8
  BOTTOM w0.076: 130.07,43.72 130.07,44.1 130.59,44.62 130.59,45.38 130.74,45.53 130.74,45.98 130.57,46.15 130.52,46.15 130.47,46.1 U80.A47
  BOTTOM w0.102: 130.07,43.72 130.07,41.64 130.42,41.28 130.85,41.28 130.95,41.18 TP281.1
N17306013: length 7.3
  BOTTOM w0.076: U80.B45 129.49,46.28 129.62,46.28 129.81,46.09 129.81,45.23 128.3,43.72 128.3,43.6
  BOTTOM w0.102: 128.3,43.6 128.3,42.99 127.86,42.55 127.86,42.37 128.52,41.71 128.52,41.31 TP280.1
N17306015: length 6.4
  BOTTOM w0.076: U80.B47 130.47,46.43 130.59,46.31 130.63,46.31 130.9,46.03 130.9,45.46 130.75,45.31 130.75,44.55 130.27,44.06 130.27,43.72
  BOTTOM w0.102: TP282.1 130.95,41.56 130.88,41.49 130.5,41.49 130.27,41.71 130.27,43.72
N17307145: length 5.6
  BOTTOM w0.102: U80.AD3 104.74,58.57 104.42,58.9 103.29,58.9 103.27,58.87 100.11,58.87 TP233.1
N17343677: length 6.8
  TOP w0.102: TP274.1 98.49,57.98 99.5,57.98 100.19,57.28 101.84,57.28 v3(102.07,57.05)
  BOTTOM w0.076: U80.AB2 104.17,57.22 103.96,57.01 103.15,57.01 102.88,56.74 102.38,56.74 v3(102.07,57.05)
N17344720: length 23.1
  IN2 w0.079: v3(102.74,57.08) 101.98,57.84 97.07,57.84 96.38,57.15 95.89,57.15 95.35,56.61 93.99,56.61 93.7,56.89 92.21,56.89 91.69,56.37 91.23,56.37 90.78,55.93 90.78,55.39 91,55.18 91,54.37 91.12,54.25 91.12,52.39 91.62,51.89 91.62,51.1 91.53,51.01 91.53,49.31 v1(91.64,49.2)
  BOTTOM w0.076: U80.AB1 102.9,57.25 v3(102.74,57.08)
  BOTTOM w0.102: v1(91.64,49.2) 91.9,49.46 92.88,49.46 TP278.1
N17578279:
  vias: v1(155.54,30.81)
N17586894:
  vias: v1(181.86,38.01) v1(183.91,40.02)
N17603103: length 2.3
  BOTTOM w0.254: PR84.2 186.2,37.68 v1(186.28,37.75)
  BOTTOM w0.279: PR84.2 185.43,37.92 185.88,38.37 PU8.4
N17603106: length 3
  BOTTOM w0.254: v1(183.18,38.11) 183.62,37.67 PC1183.1
  BOTTOM w0.279: PC1183.1 185.38,38.82 PU8.5
N17609123: length 2.1
  TOP w0.305: PC17.2 188.78,41.12 v1(189.02,41.36)
  BOTTOM w0.279: PU8.19 188.77,41.11 v1(189.02,41.36)
N17618076:
  vias: v1(174.34,40.34) v1(174.99,41.04)
N17619692: length 2.2
  BOTTOM w0.254: v1(175.95,36.23) PC1184.2
  BOTTOM w0.381: PR65.2 176.7,37.11 176.59,37.23 PC1184.2
N17619721: length 4.5
  BOTTOM w0.254: PR65.1 177.5,37.89 177.69,37.7 177.69,36.58 v1(177.34,36.23)
  BOTTOM w0.279: PU7.4 177.02,39.39 177.44,38.97 177.44,38.46 177.15,38.17 PR65.1
N17619724: length 2.8
  BOTTOM w0.254: v1(176.93,38.72) 176.64,38.43 PC1184.1
  BOTTOM w0.279: PC1184.1 175.95,38.71 176.52,39.27 PU7.5
N17621976: length 0.9
  TOP w0.254: v1(179.35,45.64) PC14.2
N17622303:
  vias: v1(186.48,45.25)
N17647625: length 1.9
  TOP w0.305: PC19.2 179.59,42.16 v1(180,41.76)
  BOTTOM w0.279: PU7.19 179.72,42.03 v1(180,41.76)
N17647893: length 1.8
  TOP w0.305: v1(168.56,40.01) 168.94,39.63 PC21.2
  BOTTOM w0.279: PU6.19 v1(168.56,40.01)
N17648742:
  vias: v1(170.6,35.23)
N17649316: length 1.5
  BOTTOM w0.381: PR35.2 173.26,36.22 173.43,36.05 PC1186.2
N17649331: length 2.2
  BOTTOM w0.279: PU6.5 170.98,36.49 171.18,36.28 171.18,35.86 v1(171.26,35.77) 171.71,35.33 PC1186.1
N17649342: length 1.8
  BOTTOM w0.279: PR35.1 172.48,36.78 172.12,36.78 171.92,36.99 v1(171.67,36.99) PU6.4
N17675286:
  vias: v1(164.33,36.96)
N17682231: length 1.8
  BOTTOM w0.203: PR12.2 200.29,31.78 200.4,31.89 PC25.2 v1(201.67,31.89)
N17700132: length 3.6
  TOP w0.203: v1(48.78,29.54) 48.78,30.34 PR161.1
  TOP w0.254: v1(48.78,29.54) 48.78,29.14 PC1314.1
  BOTTOM w0.203: v1(48.78,29.54) 48.98,29.34 PU4.18
N17700177: length 2.4
  BOTTOM w0.178: TP168.1 46.42,27.59 47.64,26.37 PU4.13
N17700263: length 2.9
  BOTTOM w0.178: TP167.1 53.5,28.23 53.5,27.69 53.25,27.44 53.25,27.44 53.24,27.44 53.1,27.44 52.83,27.17 PU4.26
N17700277: length 1.8
  TOP w0.203: PR133.1 PC1326.2 v1(55.97,25.8)
N17700362: length 3.1
  BOTTOM w0.178: PR2.2 42.64,32.06 42.78,32.21 44.78,32.21 PR124.2
  vias: v1(41.32,28)
N17700446:
  vias: v1(52.44,12.86)
N17700456:
  vias: v1(44.44,22.23)
N17700505: length 3.8
  BOTTOM w0.178: PU4.21 50.18,28.58 51.02,29.42 PR45.2 50.45,30.6 v1(50.17,30.88)
N17700521: length 3.1
  BOTTOM w0.178: PU4.22 50.58,28.5 v1(51.58,29.5) 52,29.92 PR44.2
N17702601: length 4.6
  TOP w0.203: PR128.2 47.48,29.21 v1(47.89,29.21)
  BOTTOM w0.254: v1(47.89,29.21) 47.89,29.34 48.33,29.78 v1(48.33,30.79) 48.23,30.89 48.23,32.22 PD4.3
N17714367:
  vias: v1(41.78,22.82)
N17724245: length 3.3
  BOTTOM w0.178: PR1.2 57.22,23.84 57.04,23.66 54.56,23.66 PR126.2
  vias: v1(56.74,27.67)
N17733184: length 2.5
  BOTTOM w0.102: PJ2.5 65.39,22.12 v1(65.3,22.21) 65.3,22.82 PR119.1
N18047939: length 4.2
  TOP w0.102: v1(196.77,15.69) 195.92,16.54 R5117.2
  BOTTOM w0.102: CN8.56 195.72,15.7 196.18,16.16 196.3,16.16 v1(196.77,15.69)
N18050341: length 4.9
  BOTTOM w0.102: R5051.2 69.7,34.44 69.31,34.83 QPM3382.3 69.18,37.75 v1(68.27,37.75)
N18054146: length 3.4
  TOP w0.102: v1(21.63,49.94) 21.54,50.04 QPM3383.3 19.51,49.64 R5038.1
N18054148: length 2.8
  TOP w0.102: v1(19.37,54.62) 18.88,54.13 R5039.2 18.88,53 18.89,52.99 QPM3383.1
N18054178: length 4.1
  TOP w0.102: v1(12.84,50.15) 13.16,50.46 R5042.1 14.06,50.83 15.77,50.83 16.1,50.5 QPM3384.3
N18054180: length 2.5
  TOP w0.102: QPM3384.1 14.47,51.46 R5043.2 v1(12.84,51.46)
N18054762: length 2.2
  TOP w0.102: U95.21 v1(29.73,48.34) 29.48,48.34 R5041.1
N18057554: length 2.1
  BOTTOM w0.102: EUPM3247.A49 89.1,44.79 v1(89.2,44.89) 89.47,44.89 R5040.2
N18061734: length 2.4
  TOP w0.102: v1(78.12,38.49) 77.34,38.49 R1074.1 76.68,39.15 QPM3387.3
N18066115: length 3.6
  BOTTOM w0.102: EUPM3247.B51 87.08,45.98 88.59,45.98 v1(88.82,46.21) 89.04,45.98 89.76,45.98 R5026.1
N18074160: length 1.9
  BOTTOM w0.102: TP285.1 89.17,39.86 88.71,39.86 88.65,39.79 EUPM3247.A59
N18133793: length 61.8
  TOP w0.102: v1(67.96,56.34) 68.05,56.34 68.59,55.79 R896.1
  IN2 w0.079: v1(82.49,21.21) 80.6,21.21 72.2,29.6 72.2,31.68 71.52,32.35 71.52,33.75 69.58,35.69 69.58,36.53 67.93,38.18 67.93,43.1 66.79,44.24 66.79,54.64 67.91,55.76 67.91,56.29 v1(67.96,56.34)
  BOTTOM w0.102: v1(82.49,21.21) 82.95,20.75 82.95,18.95 81.5,17.5 81.5,15.91 79.34,13.75 79.34,12.48 79.87,11.95 HOLE2.4 80.87,12.51 80.87,13.5 81.25,13.88 82.77,13.88 83.2,13.45 HOLE2.3
N18165504: length 10.2
  TOP w0.102: v1(74.26,45.63) 74.26,45.36 R5081.2 R5080.1 C1089.2 78.23,44.47 78.62,44.09 79.06,44.09 79.07,44.08 79.36,44.08 79.67,43.77 81.35,43.77 v1(81.91,44.33)
  BOTTOM w0.102: EUPM3247.B42 82.21,45.32 82.09,45.2 82.09,44.51 v1(81.91,44.33)
N18167653:
  vias: v1(173.22,21.8)
N18168197: length 5.7
  BOTTOM w0.102: v1(27.96,22.61) 27.96,22.35 27.32,21.71 27.32,21.66 R5090.1 R5091.1 26.13,20.99 26.37,20.74 CCP4216.1 26.11,20.08 U108.5
N18169543: length 5
  BOTTOM w0.102: R5078.1 81.37,49.59 v1(81.58,49.39) 82.05,49.39 R5079.1 82.15,49.05 81.83,48.72 81.83,47.97 82.46,47.35 EUPM3247.A40
N18180469: length 3.7
  TOP w0.102: v1(23.47,30.56) R41.2 R5092.2 25.47,28.88 U132.5
N18329473: length 5.5
  TOP w0.102: R5063.1 150.59,25.97 151.49,25.07 R5073.2 151.78,24.7 v1(151.27,24.19) 150.94,23.86 150.94,23.64 150.89,23.59 150.89,23.47 150.52,23.1 150.36,23.1 150.16,22.9 U83.3
N18329506: length 4.4
  TOP w0.102: U83.1 150.96,22.81 151.16,23.01 v1(151.79,23.01) C590.2 153.23,23.01 153.26,23.04 R5144.1 R5145.1
N18329561: length 2.8
  TOP w0.102: R5066.1 148.28,23.73 v1(148.66,23.35) 148.81,23.2 149.62,23.2 149.76,23.06 U83.4
N18329587: length 2.6
  TOP w0.102: R5068.1 147.36,21.33 147.56,21.14 v1(148,21.14) 148.14,21.29 U83.6
N18329644: length 6.4
  TOP w0.102: U83.12 151.8,21.69 152.57,22.46 153.83,22.46 v1(154.07,22.23) R5106.2 156.24,20.98 Q135.1
N18329650: length 8.9
  TOP w0.102: v1(152.16,21.37) 152.08,21.29 U83.11 ; v1(148.29,25.04) 148.37,24.96 R5152.2 R5072.2
  BOTTOM w0.102: v1(148.29,25.04) 148.29,23.84 150.77,21.37 v1(152.16,21.37)
N18365336: length 6.2
  TOP w0.102: PR160.1 26.85,64.67 PR98.1 26.56,64.46 26.56,63.63 26.45,63.52 v1(26.45,62.21) 26.75,61.91 26.94,61.91 27.12,61.73 27.12,61.4 26.84,61.12 PQ129.2
N18366094:
  vias: v1(27.58,71.08)
N18377771: length 2.7
  TOP w0.102: R5095.2 204.11,12.65 v1(204.11,12.94) 204.86,13.69 EU1B2.6
N18377774: length 2.2
  TOP w0.102: EU1B2.7 205.36,12.95 v1(205.38,12.94) 205.45,12.86 R5096.2
N18377783: length 2.6
  TOP w0.102: R5097.2 206.65,12.5 v1(206.65,12.94) 205.86,13.72 EU1B2.8
N18381748: length 5.6
  TOP w0.102: 26.13,33.18 26.89,33.94 27.68,33.94 R1082.1 28.54,34.04 28.56,34.06 R5099.1 R5101.1 29.87,33.61 v1(29.87,33.23)
N18388802: length 4.1
  BOTTOM w0.102: EUPM3247.B2 86.21,36.75 86.48,37.02 86.73,37.02 87.04,36.71 87.04,36.13 88.41,34.75 R5104.1
N18401065:
  vias: v1(99.51,85.45)
N18408850: length 6.5
  TOP w0.102: v1(48.3,48.12) 48,48.42 46.58,48.42 PR78.1 45.96,48.68 45.59,49.06 45.59,50.99 46.32,51.72 PU17.2
N18408888: length 4.8
  TOP w0.102: PC1278.1 49.53,49.86 JP5076.1 ; PC1278.1 49.23,49.01 v1(49.52,48.72) ; PC1278.1 48.84,49.96 48.84,50.76 48.63,50.97 PU17.5
N18408896: length 3.2
  TOP w0.102: v1(50.28,53.04) 50.28,52.77 PC1312.1 49.01,51.49 48.46,51.49 48.23,51.72 PU17.7
N18423443: length 4.6
  TOP w0.102: v1(90.06,89.45) RAP3046.1 RAP3045.1 CPM4431.2 93.46,88.92 U135.5
N18483788: length 5
  BOTTOM w0.102: EUPM3247.A17 76.95,37.29 76.8,37.14 76.8,35.86 R5084.1 75.43,34.48 75.43,34.2 75.43,34.19 75.43,34.01 74.93,33.51 v1(74.87,33.51)
N18760372: length 5.1
  BOTTOM w0.076: 108.09,70.53 108.09,69.83 108.4,69.53 108.69,69.53 108.88,69.72 109.24,69.72 109.64,69.31 U80.BB11
  BOTTOM w0.102: R5107.1 107.13,71.5 108.09,70.53
N18781214: length 4.6
  TOP w0.102: U26.16 20.3,48.18 20.16,48.32 19.93,48.32 19.63,48.01 v1(19.17,48.01)
  BOTTOM w0.102: v1(19.17,48.01) 17.21,48.01 16.83,48.39 R679.2
N18801748: length 11.3
  BOTTOM w0.102: D41.1 18.81,45.6 19.35,45.07 v1(19.35,44.38) 19.35,43.7 18.7,43.04 R680.1 20.13,42.93 20.8,42.26 20.8,41.07 20.07,40.33 18.86,40.33 18.38,40.81 18.38,41.43 R5116.1
N18910683: length 1.2
  TOP w0.102: R899.1 105,40.42 R5142.2
N18942554: length 2.4
  TOP w0.102: PU3.A2 v1(31.7,60.96) 32.36,60.29 PR8.2
N19425416: length 2.8
  TOP w0.102: v1(95.6,82.76) 95.42,82.94 R5137.1 94.78,82.47 94.97,82.27 U138.3
N19426006: length 3.2
  TOP w0.102: v1(92.91,83.42) 93.06,83.27 93.43,83.27 R5138.1 93.34,82.52 93.34,82.08 93.02,81.76 U138.6
N19431978: length 4.2
  TOP w0.102: v1(208.32,31.76) 208.32,30.2 PC309.2 207.47,29.34 PU51.12
N19431980: length 2.9
  TOP w0.102: PU51.10 208.27,28.43 208.42,28.59 208.42,29.28 PC310.2 v1(209.69,29.74)
N19465433: length 2.8
  TOP w0.102: U138.8 92.37,75.98 v2(91.31,77.05) 91.31,77.55 91.24,77.61 R3499.2
