# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
HG-ZHD-3
  custom 1.75x1.75 hole 5.994x3.988: 1(0,0)
  round 0.61 hole 0.356: 2(0,2.794) 3(2.976,1.976) 4(3.794,0) 5(2.976,-1.976) 6(0,-2.794) 7(-2.976,-1.976) 8(-3.794,0) 9(-2.976,1.976)
LED12-22-S2ST3D-C30-2C-3P-SMT
  rect 0.991x1.092 smd: 1(1.5,-0.1) 3(-1.5,-0.1)
  rect 0.889x0.889 smd: 2(0,-0.65)
LGA5-3X2_7
  rect 0.33x0.33 smd: 1(-0.918,-0.503) 4(0.719,-0.503)
  rect 0.406x0.711 smd: 2(-0.917,0.31)
  custom 0.228x0.228 smd: 3(0.423,0)
  rect 0.254x2.489 smd: 5(1.375,0)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
NGFF-NASE0-S6701-TSH4-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
POWER-3X3-65-10P-0_8H
  rect 0.457x0.457 smd: 1(-0.975,-1.386) 2(-0.325,-1.386) 3(0.325,-1.386) 4(0.975,-1.386) 5(0.975,1.386) 6(0.325,1.386) 7(-0.325,1.386) 8(-0.975,1.386)
  rect 2.438x1.041 smd: 9(0,0.434)
  rect 2.438x0.559 smd: 10(0,-0.671)
POWER-4_5X3_5-5-13P
  rect 0.279x0.762 smd: 1(-1,-2.175) 2(-0.5,-2.175) 3(0,-2.175) 4(0.5,-2.175) 5(1,-2.175)
  custom 0.322x0.322 smd: 6(1.303,-1)
  custom 0.439x0.439 smd: 9(0,0)
  custom 0.188x0.188 smd: 12(0,1.955)
  rect 0.762x0.279 smd: 19(-1.675,0) 20(-1.675,-0.5) 21(-1.675,-1)
  rect 0.737x0.279 smd: 22(-1.688,-1.5)
  rect 1.194x1.168 smd: 23(-0.412,-0.94)
POWER-5X5-1_27-5P
  rect 1.143x0.762 smd: 1(2.875,-1.905) 2(2.875,-0.635) 3(2.875,0.635) 4(2.875,1.905)
  custom 1.14x1.14 smd: 5(0,0)
QFN12-1_6X1_6-4
  rect 0.203x0.914 smd: 1(-0.6,-0.945) 4(0.6,-0.945) 7(0.6,0.945) 10(-0.6,0.945)
  rect 0.203x0.813 smd: 2(-0.2,-0.988) 3(0.2,-0.988) 8(0.2,0.988) 9(-0.2,0.988)
  rect 0.813x0.203 smd: 5(0.988,-0.2) 6(0.988,0.2) 11(-0.988,0.2) 12(-0.988,-0.2)
QFN16-3X3-5-17P-0_8H
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.092x1.092 smd: 17(0,0)
QFN16-3X3-5-17P-TPS2546RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN20-3X4-5-21P-0_55H
  rect 0.254x0.991 smd: 1(-1.25,-1.6) 2(-0.75,-1.6) 3(-0.25,-1.6) 4(0.25,-1.6) 5(0.75,-1.6) 6(1.25,-1.6) 11(1.25,1.6) 12(0.75,1.6) 13(0.25,1.6) 14(-0.25,1.6) 15(-0.75,1.6) 16(-1.25,1.6)
  rect 0.991x0.254 smd: 7(2.1,-0.75) 8(2.1,-0.25) 9(2.1,0.25) 10(2.1,0.75) 17(-2.1,0.75) 18(-2.1,0.25) 19(-2.1,-0.25) 20(-2.1,-0.75)
  rect 2.642x1.651 smd: 21(0,0)
QFN32-4X4-4-33P-ISL95853
  custom 0.05x0.05 smd: 1(-1.4,-1.9) 8(1.4,-1.9) 9(1.9,-1.4) 16(1.9,1.4) 17(1.4,1.9) 24(-1.4,1.9) 25(-1.9,1.4) 32(-1.9,-1.4)
  rect 0.203x0.61 smd: 2(-1,-1.9) 3(-0.6,-1.9) 4(-0.2,-1.9) 5(0.2,-1.9) 6(0.6,-1.9) 7(1,-1.9) 18(1,1.9) 19(0.6,1.9) 20(0.2,1.9) 21(-0.2,1.9) 22(-0.6,1.9) 23(-1,1.9)
  rect 0.61x0.203 smd: 10(1.9,-1) 11(1.9,-0.6) 12(1.9,-0.2) 13(1.9,0.2) 14(1.9,0.6) 15(1.9,1) 26(-1.9,1) 27(-1.9,0.6) 28(-1.9,0.2) 29(-1.9,-0.2) 30(-1.9,-0.6) 31(-1.9,-1)
  rect 2.642x2.642 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN32-5X5-5-33P-SLB9645VQ
  rect 0.254x0.711 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4) 17(1.75,2.4) 18(1.25,2.4) 19(0.75,2.4) 20(0.25,2.4) 21(-0.25,2.4) 22(-0.75,2.4) 23(-1.25,2.4) 24(-1.75,2.4)
  rect 0.711x0.254 smd: 9(2.4,-1.75) 10(2.4,-1.25) 11(2.4,-0.75) 12(2.4,-0.25) 13(2.4,0.25) 14(2.4,0.75) 15(2.4,1.25) 16(2.4,1.75) 25(-2.4,1.75) 26(-2.4,1.25) 27(-2.4,0.75) 28(-2.4,0.25) 29(-2.4,-0.25) 30(-2.4,-0.75) 31(-2.4,-1.25) 32(-2.4,-1.75)
  rect 3.607x3.607 smd: 33(0,0)
QFN40-3X6-4-41P
  custom 0.05x0.05 smd: 1(-2.6,-1.5) 14(2.6,-1.5) 15(3,-1) 20(3,1) 21(2.6,1.5) 34(-2.6,1.5) 35(-3,1) 40(-3,-1)
  rect 0.203x0.508 smd: 2(-2.2,-1.5) 3(-1.8,-1.5) 4(-1.4,-1.5) 5(-1,-1.5) 6(-0.6,-1.5) 7(-0.2,-1.5) 8(0.2,-1.5) 9(0.6,-1.5) 10(1,-1.5) 11(1.4,-1.5) 12(1.8,-1.5) 13(2.2,-1.5) 22(2.2,1.5) 23(1.8,1.5) 24(1.4,1.5) 25(1,1.5) 26(0.6,1.5) 27(0.2,1.5) 28(-0.2,1.5) 29(-0.6,1.5) 30(-1,1.5) 31(-1.4,1.5) 32(-1.8,1.5) 33(-2.2,1.5)
  rect 0.508x0.203 smd: 16(3,-0.6) 17(3,-0.2) 18(3,0.2) 19(3,0.6) 36(-3,0.6) 37(-3,0.2) 38(-3,-0.2) 39(-3,-0.6)
  rect 4.496x1.702 smd: 41(0,0)
QFN40-5X5-4-41P-ISL62771-SMT
  rect 0.203x0.838 smd: 1(-1.8,-2.514) 2(-1.4,-2.514) 3(-1,-2.514) 4(-0.6,-2.514) 5(-0.2,-2.514) 6(0.2,-2.514) 7(0.6,-2.514) 8(1,-2.514) 9(1.4,-2.514) 10(1.8,-2.514) 21(1.8,2.514) 22(1.4,2.514) 23(1,2.514) 24(0.6,2.514) 25(0.2,2.514) 26(-0.2,2.514) 27(-0.6,2.514) 28(-1,2.514) 29(-1.4,2.514) 30(-1.8,2.514)
  rect 0.838x0.203 smd: 11(2.514,-1.8) 12(2.514,-1.4) 13(2.514,-1) 14(2.514,-0.6) 15(2.514,-0.2) 16(2.514,0.2) 17(2.514,0.6) 18(2.514,1) 19(2.514,1.4) 20(2.514,1.8) 31(-2.514,1.8) 32(-2.514,1.4) 33(-2.514,1) 34(-2.514,0.6) 35(-2.514,0.2) 36(-2.514,-0.2) 37(-2.514,-0.6) 38(-2.514,-1) 39(-2.514,-1.4) 40(-2.514,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN48-7X7-5-49P-0_65H
  rect 0.305x0.559 smd: 1(-2.75,-3.375) 2(-2.25,-3.375) 3(-1.75,-3.375) 4(-1.25,-3.375) 5(-0.75,-3.375) 6(-0.25,-3.375) 7(0.25,-3.375) 8(0.75,-3.375) 9(1.25,-3.375) 10(1.75,-3.375) 11(2.25,-3.375) 12(2.75,-3.375) 25(2.75,3.375) 26(2.25,3.375) 27(1.75,3.375) 28(1.25,3.375) 29(0.75,3.375) 30(0.25,3.375) 31(-0.25,3.375) 32(-0.75,3.375) 33(-1.25,3.375) 34(-1.75,3.375) 35(-2.25,3.375) 36(-2.75,3.375)
  rect 0.559x0.305 smd: 13(3.375,-2.75) 14(3.375,-2.25) 15(3.375,-1.75) 16(3.375,-1.25) 17(3.375,-0.75) 18(3.375,-0.25) 19(3.375,0.25) 20(3.375,0.75) 21(3.375,1.25) 22(3.375,1.75) 23(3.375,2.25) 24(3.375,2.75) 37(-3.375,2.75) 38(-3.375,2.25) 39(-3.375,1.75) 40(-3.375,1.25) 41(-3.375,0.75) 42(-3.375,0.25) 43(-3.375,-0.25) 44(-3.375,-0.75) 45(-3.375,-1.25) 46(-3.375,-1.75) 47(-3.375,-2.25) 48(-3.375,-2.75)
  rect 5.588x5.588 smd: 49(0,0)
QFN132-11X11-5-133P
  rect 5.004x5.004 smd: 133(0,0)
  custom 0.07x0.07 smd: A1(-3.75,-5.45) A2(-3.25,-5.45) A3(-2.75,-5.45) A4(-2.25,-5.45) A5(-1.75,-5.45) A6(-1.25,-5.45) A7(-0.75,-5.45) A8(-0.25,-5.45) A9(0.25,-5.45) A10(0.75,-5.45) A11(1.25,-5.45) A12(1.75,-5.45) A13(2.25,-5.45) A14(2.75,-5.45) A15(3.25,-5.45) A16(3.75,-5.45) A17(5.45,-3.75) A18(5.45,-3.25) A19(5.45,-2.75) A20(5.45,-2.25) A21(5.45,-1.75) A22(5.45,-1.25) A23(5.45,-0.75) A24(5.45,-0.25) A25(5.45,0.25) A26(5.45,0.75) A27(5.45,1.25) A28(5.45,1.75) A29(5.45,2.25) A30(5.45,2.75) A31(5.45,3.25) A32(5.45,3.75) A33(3.75,5.45) A34(3.25,5.45) A35(2.75,5.45) A36(2.25,5.45) A37(1.75,5.45) A38(1.25,5.45) A39(0.75,5.45) A40(0.25,5.45) A41(-0.25,5.45) A42(-0.75,5.45) A43(-1.25,5.45) A44(-1.75,5.45) A45(-2.25,5.45) A46(-2.75,5.45) A47(-3.25,5.45) A48(-3.75,5.45) A49(-5.45,3.75) A50(-5.45,3.25) A51(-5.45,2.75) A52(-5.45,2.25) A53(-5.45,1.75) A54(-5.45,1.25) A55(-5.45,0.75) A56(-5.45,0.25) A57(-5.45,-0.25) A58(-5.45,-0.75) A59(-5.45,-1.25) A60(-5.45,-1.75) A61(-5.45,-2.25) A62(-5.45,-2.75) A63(-5.45,-3.25) A64(-5.45,-3.75)
  oval 0.279x0.559 smd: B1(-4,-4.57) B2(-3.5,-4.57) B3(-3,-4.57) B4(-2.5,-4.57) B5(-2,-4.57) B6(-1.5,-4.57) B7(-1,-4.57) B8(-0.5,-4.57) B9(0,-4.57) B10(0.5,-4.57) B11(1,-4.57) B12(1.5,-4.57) B13(2,-4.57) B14(2.5,-4.57) B15(3,-4.57) B16(3.5,-4.57) B17(4,-4.57) B35(4,4.57) B36(3.5,4.57) B37(3,4.57) B38(2.5,4.57) B39(2,4.57) B40(1.5,4.57) B41(1,4.57) B42(0.5,4.57) B43(0,4.57) B44(-0.5,4.57) B45(-1,4.57) B46(-1.5,4.57) B47(-2,4.57) B48(-2.5,4.57) B49(-3,4.57) B50(-3.5,4.57) B51(-4,4.57)
  oval 0.559x0.279 smd: B18(4.57,-4) B19(4.57,-3.5) B20(4.57,-3) B21(4.57,-2.5) B22(4.57,-2) B23(4.57,-1.5) B24(4.57,-1) B25(4.57,-0.5) B26(4.57,0) B27(4.57,0.5) B28(4.57,1) B29(4.57,1.5) B30(4.57,2) B31(4.57,2.5) B32(4.57,3) B33(4.57,3.5) B34(4.57,4) B52(-4.57,4) B53(-4.57,3.5) B54(-4.57,3) B55(-4.57,2.5) B56(-4.57,2) B57(-4.57,1.5) B58(-4.57,1) B59(-4.57,0.5) B60(-4.57,0) B61(-4.57,-0.5) B62(-4.57,-1) B63(-4.57,-1.5) B64(-4.57,-2) B65(-4.57,-2.5) B66(-4.57,-3) B67(-4.57,-3.5) B68(-4.57,-4)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-5P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,-0.65)
SC70-2_1-65-6P-SN74AVC1T45
  rect 0.889x0.406 smd: 1(1.1,-0.65) 2(1.1,0) 3(1.1,0.65) 4(-1.1,0.65) 5(-1.1,0) 6(-1.1,-0.65)
SOIC8-7_9-1_27
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON4-0_8X0_8-48-5P-0_4H
  custom 0.055x0.055 smd: 1(0.39,-0.24) 2(0.39,0.24) 3(-0.39,0.24) 4(-0.39,-0.24)
  custom 0.088x0.088 smd: 5(0,0)
SON8-1_95X1-5
  rect 0.305x0.991 smd: 1(-0.775,-0.6)
  rect 0.254x0.94 smd: 2(-0.25,-0.625) 3(0.25,-0.625) 6(0.25,0.625) 7(-0.25,0.625)
  rect 0.305x0.94 smd: 4(0.775,-0.625) 5(0.775,0.625) 8(-0.775,0.625)
SON8-2X2-5-9P
  rect 0.279x0.508 smd: 1(-0.75,-0.95) 2(-0.25,-0.95) 3(0.25,-0.95) 4(0.75,-0.95) 5(0.75,0.95) 6(0.25,0.95) 7(-0.25,0.95) 8(-0.75,0.95)
  rect 1.6x0.889 smd: 9(0,0)
SON8-3_3X3_3
  rect 1.092x0.66 smd: 1(-0.65,-1.475)
  rect 0.432x0.66 smd: 3(0.325,-1.475) 4(0.975,-1.475) 5(0.975,1.475) 6(0.325,1.475) 7(-0.325,1.475) 8(-0.975,1.475)
  custom 0.475x0.475 smd: 9(0,0)
SON10-2_5X1-5-0_55H
  rect 0.305x0.559 smd: 1(-1,-0.385) 2(-0.5,-0.385) 4(0.5,-0.385) 5(1,-0.385) 6(1,0.385) 7(0.5,0.385) 9(-0.5,0.385) 10(-1,0.385)
  rect 0.33x0.559 smd: 3(0,-0.385) 8(0,0.385)
SON10-2_5X1-5-SMT
  rect 0.305x0.559 smd: 1(-1,-0.385) 2(-0.5,-0.385) 3(0,-0.385) 4(0.5,-0.385) 5(1,-0.385) 6(1,0.385) 7(0.5,0.385) 8(0,0.385) 9(-0.5,0.385) 10(-1,0.385)
SON14-3X2-4-15P-SMT
  custom 0.05x0.05 smd: 1(-1.2,-1.076) 2(-0.8,-1.076) 3(-0.4,-1.076) 4(0,-1.076) 5(0.4,-1.076) 6(0.8,-1.076) 7(1.2,-1.076) 8(1.2,1.076) 9(0.8,1.076) 10(0.4,1.076) 11(0,1.076) 12(-0.4,1.076) 13(-0.8,1.076) 14(-1.2,1.076)
  rect 2.489x0.889 smd: 15(0,0)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-6-2_8-95-6P
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SPAD-RE315X1043NP
  rect 8.001x26.492 smd: 1(0,0)
SW-TME-533B-Q-TR-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TDFN8-2X1_5-5-6P
  rect 0.254x0.61 smd: 1(-0.75,-0.6) 2(-0.25,-0.6) 7(-0.25,0.6) 8(-0.75,0.6)
  rect 0.762x0.762 smd: 4(0.5,-0.517) 5(0.5,0.517)
TDFN9-2X1_5-4
  rect 0.203x0.787 smd: 1(-0.6,-0.75) 2(-0.2,-0.75) 7(-0.2,0.75) 8(-0.6,0.75)
  rect 0.61x0.991 smd: 3(0.4,-0.65) 5(0.4,0.65)
  rect 0.787x0.203 smd: 9(-1,0)
TP2050
  round 0.508 smd: 1(0,0)
TQFN32-3X6-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-2,-1.5) 2(-1.6,-1.5) 3(-1.2,-1.5) 4(-0.8,-1.5) 5(-0.4,-1.5) 6(0,-1.5) 7(0.4,-1.5) 8(0.8,-1.5) 9(1.2,-1.5) 10(1.6,-1.5) 11(2,-1.5) 12(3,-0.8) 13(3,-0.4) 14(3,0) 15(3,0.4) 16(3,0.8) 17(2,1.5) 18(1.6,1.5) 19(1.2,1.5) 20(0.8,1.5) 21(0.4,1.5) 22(0,1.5) 23(-0.4,1.5) 24(-0.8,1.5) 25(-1.2,1.5) 26(-1.6,1.5) 27(-2,1.5) 28(-3,0.8) 29(-3,0.4) 30(-3,0) 31(-3,-0.4) 32(-3,-0.8)
  rect 4.597x1.803 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.5,-0.5) 35(-0.5,-0.5) 36(0.5,-0.5) 37(1.5,-0.5) 38(1.5,0.5) 39(0.5,0.5) 40(-0.5,0.5) 41(-1.5,0.5)
TSSOP10-4_9-5
  rect 0.279x1.499 smd: 1(-1,-2.3) 2(-0.5,-2.3) 3(0,-2.3) 4(0.5,-2.3) 5(1,-2.3) 6(1,2.3) 7(0.5,2.3) 8(0,2.3) 9(-0.5,2.3) 10(-1,2.3)
TSSOP14-6_4-65-TXB0104PWR
  rect 0.356x1.6 smd: 1(-1.95,-2.8) 2(-1.3,-2.8) 3(-0.65,-2.8) 4(0,-2.8) 5(0.65,-2.8) 6(1.3,-2.8) 7(1.95,-2.8) 8(1.95,2.8) 9(1.3,2.8) 10(0.65,2.8) 11(0,2.8) 12(-0.65,2.8) 13(-1.3,2.8) 14(-1.95,2.8)
UB31-DX07B024XJ1AR1000-24P-SMT
  round 0.813 hole 0.813 unplated: (-3.6,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.6,0)
  oval 1.092x1.956 hole 0.61x1.448: 1(-4.8,-0.875) 2(4.8,-0.875)
  oval 1.092x2.388 hole 0.61x1.6: 3(-5.8,-5.1) 4(5.8,-5.1)
  rect 0.254x1.092 smd: A1(-2.75,0.66) A2(-2.25,0.66) A3(-1.75,0.66) A4(-1.25,0.66) A5(-0.75,0.66) A6(-0.25,0.66) A7(0.25,0.66) A8(0.75,0.66) A9(1.25,0.66) A10(1.75,0.66) A11(2.25,0.66) A12(2.75,0.66)
  round 0.61 hole 0.457: B1(2.8,-0.55) B2(2.4,-1.35) B3(1.6,-1.35) B4(1.35,-0.55) B5(0.8,-1.35) B6(0.4,-0.55) B7(-0.4,-0.55) B8(-0.8,-1.35) B9(-1.35,-0.55) B10(-1.6,-1.35) B11(-2.4,-1.35) B12(-2.8,-0.55)
UDFN10-2_5X1-5-9P
  rect 0.203x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.406x1.549 smd: 3(0,0)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
USB-53065-00902-001-9P-SMT
  round 1.295 hole 0.813: 1(3.5,8.7) 2(1,8.7) 3(-1,8.7) 4(-3.5,8.7) 5(-4,7.2) 6(-2,7.2) 7(0,7.2) 8(2,7.2) 9(4,7.2)
  oval 1.397x2.388 hole 0.787x1.803: 10(6.4,7.8) 11(-6.4,7.8)
  oval 1.397x3.2 hole 0.787x2.591: 12(-7.85,0) 13(7.85,0)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6-0_9H
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)

## Nets
+3V3DSW_PG: PU3254.B11(PGVR3) TP136.1
+V1P00A: PC1146.2 PC1207.1 PC1208.1 PC1209.1 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1216.1 PC1217.1 PC1218.1 PC1319.1 PL1.2 PR30.2 PU12.2(D#1) PU12.3(D#2) PU14.2(D#1) PU14.3(D#2) PU16.2(D#1) PU16.3(D#2) RAP1322.1 RPM3282.2 RPM3283.2 RPM3284.2 RPM3285.2 RPM3286.2 RPM3287.2 RPM3288.2 RPM3289.2 RPM3290.2 RPM3291.2 RPM3292.2 RPM3293.2 RPM3294.2 RPM3295.2 RPM3296.2 RPM3297.2 RPM3298.2
+V1P00A_GND: PR31.1 PU3254.K11(FBVR1N)
+V1P00S_VCCST: C1140.2 C1141.2 CAP1249.1 CAP1261.1 PC1269.1 PR118.1 PR174.2 PU12.5(S#1) PU12.7(S#2) PU3254.K7(VSG) R49.1 R88.1 R5081.1 RAP1062.1 RAP1324.2 RAP1450.2 RAP1451.2 U80.A18(VCCST) U80.K20(VCCSFR_K20) U80.K21(VCCSFR_K21)
+V1P00S_VCCSTG: CAP1260.1 CAP1277.2 CAP1278.2 CAP1280.2 CAP1283.2 CAP1288.2 CAP1292.2 CAP1298.2 CAP1302.2 CAP1307.1 CAP1313.1 JP949.1 PU3254.L10(VSD) R66.1 R129.1 R130.1 R131.1 R132.1 R133.1 R134.1 RAP1013.1 RAP1343.2 U80.A22(VCCSTG) U80.AK28(VCCIO_AK28) U80.AK30(VCCIO_AK30) U80.AL30(VCCIO_AL30) U80.AL42(VCCIO_AL42) U80.AM28(VCCIO_AM28) U80.AM30(VCCIO_AM30) U80.AM42(VCCIO_AM42) U80.G20(VCCFUSEPRG)
+V1P8_SOC: JP5076.2 PR86.2 PR87.2 PR88.2 PR89.2
+V1P8A: C1109.2 CN2.3 PC1.1 PC1144.2 PC1147.2 PC1204.1 PC1205.1 PC1206.1 PL2.2 PR189.2 PU17.4(D) PU18.4(D) PU23.4(D) QPM3388.2(G) R11.2 R5086.1 R5088.1 R5091.2 R5146.1 RAP1047.2 RAP1049.2 RPM3305.2 RPM3309.2 RPM3324.2 RPM3331.2 U138.14(VCC)
+V1P8S: JP951.1 PU3254.J8(VSF) QPM3390.2(G) R957.1 R5085.1 R5090.2 RAP3043.1 RAP3044.1
+V1P8S_AUDIO_AVDD: C1M4.1 C1M9.1 C2M3.1 FB1C8.2 R1B26.1 U1.1(VDDA#1) U1.6(VDDA#2)
+V1P8S_AUDIO_DVDD: C1M6.1 C1M8.1 C2M5.1 FB1C10.2 Q129.2(G) R1A1.1 U1.20(VDDB) U1.22(VDDC)
+V1P8S_EMMC: CSM2157.2 CSM2158.2 Q111.2(G) R957.2 R1129.2 RSM2143.1 RSM2144.1 RSM2145.1 RSM2146.1 RSM2147.1 RSM2148.1 RSM2149.1 RSM2151.1 RSM2155.1 USM2006.C6(VCCQ#1) USM2006.M4(VCCQ#2) USM2006.N4(VCCQ#3) USM2006.P3(VCCQ#4) USM2006.P5(VCCQ#5)
+V1P8S_R: C1C28.1 C1C29.1 FB1C8.1 FB1C10.1 R5085.2 R5086.2 R5092.1 U132.4(OUT)
+V1P8S_R951: JP951.2 PC1272.1 PU23.5(S)
+V1P8U: CSM1018.1 CSM1022.2 CSM2030.1 CSM2031.1 CSM2035.2 CSM2098.1 CSM2099.1 CSM2103.2 CSM2130.1 CSM2134.2 JP952.1 PU3254.M9(VSB) USM2000.A3(VDD1#2) USM2000.A4(VDD1#3) USM2000.A5(VDD1#4) USM2000.A6(VDD1#5) USM2000.A10(VDD1#1) USM2000.U3(VDD1#7) USM2000.U4(VDD1#8) USM2000.U5(VDD1#9) USM2000.U6(VDD1#10) USM2000.U10(VDD1#6) USM2001.A3(VDD1#2) USM2001.A4(VDD1#3) USM2001.A5(VDD1#4) USM2001.A6(VDD1#5) USM2001.A10(VDD1#1) USM2001.U3(VDD1#7) USM2001.U4(VDD1#8) USM2001.U5(VDD1#9) USM2001.U6(VDD1#10) USM2001.U10(VDD1#6) USM2002.A3(VDD1#2) USM2002.A4(VDD1#3) USM2002.A5(VDD1#4) USM2002.A6(VDD1#5) USM2002.A10(VDD1#1) USM2002.U3(VDD1#7) USM2002.U4(VDD1#8) USM2002.U5(VDD1#9) USM2002.U6(VDD1#10) USM2002.U10(VDD1#6) USM2003.A3(VDD1#2) USM2003.A4(VDD1#3) USM2003.A5(VDD1#4) USM2003.A6(VDD1#5) USM2003.A10(VDD1#1) USM2003.U3(VDD1#7) USM2003.U4(VDD1#8) USM2003.U5(VDD1#9) USM2003.U6(VDD1#10) USM2003.U10(VDD1#6)
+V3_LDO: C1024.1 PC1315.1 PC1316.1 PC1320.2 PC9114.1 PR14.1 PR20.2 PR51.2 PR74.1 PR111.1 PR136.2 PU3254.F1(VDDIO_F1) PU3254.G2(VDDPG) PU3254.L1(EN3V3SW) PU3254.P16(VDDIO_P16) Q135.2(G) R1B32.1 R3535.1 R3591.2 R3592.2 R3596.2 R3597.1 R5049.1 R5094.2 R5145.2 R5160.2 RPM3591.2 RPM3592.2 U123.2(D) U123.8(VCC)
+V3P3_BIOS_SPI: CAP1422.2 CAP1423.2 CR5.1(CATHODE) CR7.1(CATHODE) RAP1412.2 RAP1413.2 RAP1414.2 UAP1008.5(VCC) UAP1012.8(VCC)
+V3P3_BIOS_SPI_SERVO: CN17.6 CR7.2(ANODE)
+V3P3_INA: CN17.35 RPM3576.1 RPM3577.1
+V3P3_THM: CCP4089.1 CCP4090.1 RPM3338.1 UCP4006.1(V+) UCP4007.1(V+)
+V3P3_TP: CCP4215.2 R964.1 U86.7(VOUT#2) U86.8(VOUT#1)
+V3P3_TP_OUT: CN3.1 QPM3362.2(G) R964.2 RAP1009.2 RAP1010.2 RCP4037.1
+V3P3_USBPD: C849.2 C850.2 C870.2 C871.2 C872.2 C873.2 JP3507.1 R1168.1 R1169.1 RCP4160.1 U4.5(VDD) U90.8(VDDIO) U90.11(VBAT) U96.1(MODE) U96.4(VDD#1) U96.7(VDD#2) U96.10(VDD#3) U96.13(VDD#4) U96.23(VDD#5) U96.26(VDD#6) U96.29(VDD#7) U96.32(VDD#8)
+V3P3A: CN2.1 CN2.2 CN17.18 CR5.2(ANODE) JP950.1 PC1267.2 PC1268.2 PC1307.1 PR82.2 PU11.1(B) PU11.5(VCC) PU15.1(B) PU15.5(VCC) PU21.4(D) PU3254.F7(VSA) Q137.2(G) Q137.5(G) R1B30.1 R1B33.1 R59.1 R217.1 R891.2 R892.1 R894.1 R960.1 R1040.2 R1041.2 R1042.2 R1043.2 R1113.1 R1131.2 R1134.1 R1178.1 R4434.2 R5010.2 R5124.1 RAP1000.1 RAP1001.1 RAP1002.1 RAP1014.1 RAP1016.1 RAP1051.2 RAP1052.2 RAP1387.2 RAP1434.1 RAP1436.1 RAP1438.1 RAP1440.1 RAP1452.1 RAP1453.1 RAP3045.2 RAP3049.1 RAP3053.2 RAP3054.2 RPM3310.1 RPM3314.2 RPM3315.2 RPM3316.2 RPM3323.1 RPM3326.2 RPM3327.2 RPM3328.2 RPM3329.2 RPM3333.2 RPM3589.1 U132.1(S\H\D\N\) U132.3(IN)
+V3P3A_AUDIO_FET: C1C50.1 Q136.2(G) R1B33.2 R1D18.2 R1D19.2
+V3P3A_DSW: C133.1 JP3571.1 LED1.1 LED2.1 PC1148.2 PC1149.2 PC1224.1 PC1225.1 PC1226.1 PC1227.1 PC1228.1 PC1229.1 PC1230.1 PC1231.1 PC1251.1 PC1252.1 PC1253.1 PC1254.1 PC1255.1 PC1256.1 PC1257.1 PC1311.1 PC1322.2 PC9110.2 PL8.1 PR24.2 PR105.1 PR106.1 PR107.1 PR108.1 PR109.1 PU19.2(D#1) PU19.3(D#2) PU20.2(D#1) PU20.3(D#2) PU22.4(D) PU3254.N10(VDDLV) R56.1 R3620.2 R5073.1 R5144.2 R5152.1 RAP1005.1 RAP1008.1 RAP1011.1 RAP1077.1 RAP1081.1 RAP3020.1 RPM3312.2 RPM3338.2 RPM3458.2 RPM3467.2 RPM3470.2 RPM3472.2 RPM3475.2 RPM3476.2 RPM3590.1 U8.4(IN#1) U8.5(IN#2)
+V3P3A_DSW_GND: PR25.1 PU3254.E8(FBVR3N)
+V3P3A_EC: CN17.34 CPM3428.2 CPM3432.2 CPM3433.2 CPM3435.2 CPM3438.2 CPM3440.2 CR6.2(ANODE) CRPM3519.2(ANODE) EUPM3247.A19(VCC1#2) EUPM3247.A42(VCC1#4) EUPM3247.A53(VCC1#5) EUPM3247.B7(VCC1#1) EUPM3247.B31(VCC1#3) EUPM3247.B63(VCC1#6) FB1.1 PR100.1 PR101.1 PR102.1 PR104.1 PU3254.P1(ECVCC) R1A4PD1.1 R1049.1 R1050.1 R1051.1 R1075.1 RAP1430.1 RAP3042.1 RPM3123.1 RPM3337.2 RPM3427.2 RPM3452.1
+V3P3A_EC_ANA: CPM3434.2 CPM3437.2 EUPM3247.B22(AVCC) FB1.2
+V3P3A_EC_SPI: CPM3479.2 CR6.1(CATHODE) CR8.1(CATHODE) RPM3457.1 RPM3468.1 RPM3473.1 UPM3253.8(VCC)
+V3P3A_EC_SPI_SERVO: CN17.13 CR8.2(ANODE)
+V3P3A_R950: JP950.2 PC1274.1 PC1305.1 PU19.5(S#1) PU19.7(S#2)
+V3P3A_RTC: PC1317.1 PU3254.D16(V3P3A_RTC) RAP1072.1 RAP1075.1 RAP1078.1 RPM3317.2
+V3P3A_TPM: CAP1498.2 CAP1499.2 CAP1500.2 R960.2 RAP1423.1 RAP1424.1 RAP3021.2 RAP3023.2 U82.1(NCI/VDD[0]) U82.8(VDD[1]) U82.14(NCI/VDD[2]) U82.22(VDD[3])
+V3P3A_WIFI: C32.1 C35.1 C43.2 C789.1 C790.1 C791.2 CN8.2 CN8.4 CN8.72 CN8.74 JP948.1 PR82.1 Q113.2(G) Q127.2(G) R1144.2 R3491.1 R5020.1
+V3P3DSW_DOR: R1002.1 R3620.1 RPM3337.1
+V3P3DSW_EC: C867.2 C868.2 C893.2 C1080.2 CN17.29 R999.2 R1002.2 R1084.1 R1162.1 R1163.1 R1181.1 R3604.1 U95.1(VBAT) U95.9(VDDA) U95.24(VDD#1) U95.48(VDD#2) U130.4(S2)
+V3P3DX_EDP_FUSE: C8L3.2 F100.2 J8L1.18 J8L1.19
+V3P3S: C1142.2 J8L1.6 J8L1.7 JP955.1 PR103.1 PU3254.G6(VSE) Q139.2(G) R338.1 R346.1 R873.1 R874.1 R877.2 R879.2 R958.1 R5087.1 R5115.2 R5157.1 R5158.2 RAP1003.1 RAP1004.1 RAP1046.1 RAP1061.1 RAP1432.1 RAP3046.2
+V3P3S_AUDIO_VDDMIC: C1M5.1 C2M4.1 FB1C2.2 U1.3(VDDMIC)
+V3P3S_HDMI: C340.2 C341.2 C343.2 C344.2 R681.1 R682.1 R687.1 R5108.1 R5109.1 R5110.1 R5115.1 R5124.2 U26.11(VDD) U26.30(VDDIO)
+V3P3S_JD: FB1C11.2 R2B2.2
+V3P3S_R: C1C4.2 FB1C2.1 FB1C11.1 R59.2 R3535.2 R5087.2
+V3P3S_R955: JP955.2 PC1273.1 PU20.5(S#1) PU20.7(S#2)
+V5_LDO: PC1310.1 PC1321.2 PC9113.1 PR48.1 PR50.2 PU12.1(VDD) PU13.1(VDD) PU14.1(VDD) PU16.1(VDD) PU17.1(VDD) PU18.1(VDD) PU19.1(VDD) PU22.1(VDD) PU3254.D3(VPROGOTP)
+V5_LDO_T9: PR50.1 PU3254.T9(LDO5V)
+V5_LDO_T10: PR51.1 PU3254.T10(LDO3V)
+V5A: C1D8.1 C1D17.1 C2B3.1 C843.2 CPM4189.1 CPM4192.1 CPM4346.1 EU1B2.1(IN) EUCP4040.1(IN) FB1D1.1 FB1D2.1 PC20.1 PC301.1 PC302.1 PC307.1 PC1192.1 PC1193.1 PC1194.2 PC1195.2 PC1232.1 PC1233.1 PC1234.1 PC1235.1 PC1236.1 PC1237.1 PC1238.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1245.1 PC1246.1 PC1301.1 PC1304.1 PC1306.1 PC1318.1 PC9100.1 PC9101.1 PL10.1 PR10.2 PR11.2 PR28.2 PR49.2 PU2.A1(VIN#1) PU2.B1(VIN#2) PU5.34(VCC) PU6.2(VCIN) PU6.21(VDRV) PU9.6(VCC) PU20.1(VDD) PU21.1(VDD) PU23.1(VDD) PU50.5(VCC) PU51.1(VIN1#1) PU51.2(VIN1#2) PU51.4(VBIAS) PU51.6(VIN2#1) PU51.7(VIN2#2) PU3254.T7(VIN5VSW) R1157.1 R3603.1 R5095.1 R5096.1 R5097.1 R5123.2 RCP4190.1 RCP4191.1 U86.4(VBIAS)
+V5A_AUDIO_SPKVDD_L: C2M1.1 CAP14491.1 FB1D1.2 R1B28.2 U5.7(VDD1) U5.8(VDD2)
+V5A_AUDIO_SPKVDD_R: C2M2.1 CAP14490.1 FB1D2.2 R1B27.2 U3.7(VDD1) U3.8(VDD2)
+V5A_GND: PR29.1 PU3254.H5(FBVR5N)
+V5A_USBC: C1009.1 C1115.1 R3603.2 U97.2(IN) U98.2(IN)
+V5S_FAN: PC303.1 PC304.1 PU51.13(VOUT1#1) PU51.14(VOUT1#2) R3534.1
+V5S_FAN_C: C131.1 C132.2 CN4.1 R872.1 R3534.2
+V5S_HDMI: PC305.1 PC306.1 PU51.8(OUT2#1) PU51.9(OUT2#2) R5018.2
+V5S_HDMI_C: D41.2(ANODE) Q10.3(VIN) R5018.1 R5123.1
+VBATA: C8L15.1 C8L16.1 EC2.1 EC3.1 JP3535.2 JP3536.2 JP3537.2 JP3538.2 JP3539.2 JP3545.2 JP3546.2 JP3547.2 PC1159.1 PC1160.1 PC1161.1 PC1162.1 PC1163.1 PC1164.1 PC1165.1 PC1166.1 PC1185.2 PC1277.1 PC9124.1 PD4.2(CATHODE2) PQ2.1(VIN) PR1.1 PR52.1 PR127.2 PR135.2 PU4.3(VSYS) PU5.33(VIN) PU3254.H7(VINPP) R8A16.1
+VBATA_C: C8L7.1 C8L9.1 C8L11.1 J8L1.1 J8L1.2 J8L1.3 R8A16.2
+VBATA_T8: PC1190.1 PC1191.1 PR52.2 PU3254.R10(VINLDO3) PU3254.T8(VIN)
+VBATT: PC1168.1 PC1188.1 PC1293.2 PJ2.7 PJ2.8 PQ1.5(D) PU4.31(VBAT)
+VCC19P2_1P0: RPM3293.1 U80.A14(VCC19P2_1P0_A14)
+VCC24TBT_1P0: CAP1297.1 RPM3298.1 U80.A10(VCC24TBT_1P0_A10)
+VCCAMPHYPLL_1P0: C1087.2 C1088.2 CPM4429.1 L15.1 U80.K15(VCCAMPHYPLL_1P0_K15) U80.L15(VCCAMPHYPLL_1P0_L15)
+VCCAMPHYPLL_1P0_R: L15.2 RPM3287.1
+VCCAPLL_1P0: CAP1255.2 RPM3288.1 U80.V15(VCCAPLL_1P0_V15)
+VCCAPLLEBB_1P0: CAP1271.1 RPM3291.1 U80.N18(VCCAPLLEBB_1P0_N18)
+VCCATS: CAP1311.1 PR86.1 RPM3305.1 U80.AA1(VCCATS_AA1)
+VCCCORE: CAP1171.2 CAP1172.2 CAP1173.2 CAP1174.1 CAP1176.2 CAP1177.2 CAP1181.2 CAP1183.2 CAP1184.1 CAP1186.2 CAP1187.2 CAP1191.2 CAP1192.2 CAP1193.2 CAP1194.1 CAP1196.2 CAP1197.2 CAP1201.2 CAP1203.2 CAP1204.1 CAP1206.2 CAP1207.2 CAP1208.2 CAP1210.2 CAP1211.1 CAP1213.2 CAP1214.2 CAP1215.2 CAP1217.2 CAP1218.1 CAP1220.2 CAP1221.2 CAP1223.2 CAP1224.1 CAP1226.2 CAP1227.2 CAP1229.2 CAP1231.2 CAP1232.2 CAP1234.2 CAP1235.2 CAP1236.2 CAP1424.2 CAP1425.2 CAP1426.2 CAP1427.2 CAP1428.2 CAP1429.2 CAP1430.2 CAP1431.2 CAP1432.2 CAP1433.2 CAP1434.2 CAP1435.2 CAP1436.2 CAP1437.2 CAP1438.2 CAP1439.2 CAP1441.2 CAP1442.1 CAP1443.1 CAP1444.1 CAP1445.1 CAP1446.1 CAP1447.1 CAP1448.1 CAP1449.1 CAP14473.2 CAP14474.2 CAP14475.2 CAP14476.2 CAP14477.2 CAP14478.2 CAP14479.2 CAP14480.2 PC4.1 PC5.1 PL4.2 PR34.2 PR112.2 U80.A30(VCCCORE_A30) U80.A34(VCCCORE_A34) U80.A39(VCCCORE_A39) U80.A44(VCCCORE_A44) U80.AK33(VCCCORE_AK33) U80.AK35(VCCCORE_AK35) U80.AK37(VCCCORE_AK37) U80.AK38(VCCCORE_AK38) U80.AK40(VCCCORE_AK40) U80.AL33(VCCCORE_AL33) U80.AL37(VCCCORE_AL37) U80.AL40(VCCCORE_AL40) U80.AM32(VCCCORE_AM32) U80.AM33(VCCCORE_AM33) U80.AM35(VCCCORE_AM35) U80.AM37(VCCCORE_AM37) U80.AM38(VCCCORE_AM38) U80.G30(VCCCORE_G30) U80.G32(VCCCORE_G32) U80.G33(VCCCORE_G33) U80.G35(VCCCORE_G35) U80.G37(VCCCORE_G37) U80.G38(VCCCORE_G38) U80.G40(VCCCORE_G40) U80.G42(VCCCORE_G42) U80.J30(VCCCORE_J30) U80.J33(VCCCORE_J33) U80.J37(VCCCORE_J37) U80.J40(VCCCORE_J40) U80.K33(VCCCORE_K33) U80.K35(VCCCORE_K35) U80.K37(VCCCORE_K37) U80.K38(VCCCORE_K38) U80.K40(VCCCORE_K40) U80.K42(VCCCORE_K42) U80.K43(VCCCORE_K43)
+VCCDSW_1P0: CAP1267.1 U80.AL1(VCCDSW_1P0_AL1)
+VCCDTS_1P0: RPM3292.1 U80.T1(VCCDTS_1P0_T1)
+VCCDUSB_1P0: CAP14482.2 RPM3282.1 U80.AB17(VCCDUSB_1P0_AB17) U80.Y18(VCCDUSB_1P0_Y18)
+VCCF24NS_1P0: CAP1306.2 RAP1091.2 RPM3297.1 U80.L19(VCCF24NS_1P0_L19)
+VCCF100_1P0: CAP1321.2 RPM3294.1 U80.K19(VCCF100_1P0_K19)
+VCCF100OC_1P0: CAP1312.2 RPM3296.1 U80.N20(VCCF100OC_1P0_N20)
+VCCF135_1P0: RPM3295.1 U80.L21(VCCF135_1P0_L21)
+VCCFHV: RPM3290.1 U80.AK20(VCCFHV_2P8_AK20)
+VCCGT: C51.2 C62.2 C63.2 C64.2 C65.2 C1029.2 C1030.2 C1031.2 C1032.2 C1033.2 CAP1101.1 CAP1102.2 CAP1103.2 CAP1108.1 CAP1109.2 CAP1110.2 CAP1115.1 CAP1116.2 CAP1117.2 CAP1122.1 CAP1123.2 CAP1124.2 CAP1129.1 CAP1130.2 CAP1131.2 CAP1136.1 CAP1137.2 CAP1138.2 CAP1141.1 CAP1142.2 CAP1147.1 CAP1148.2 CAP1150.1 CAP1152.1 CAP1155.2 CAP1156.1 CAP1157.1 CAP1159.2 CAP1161.2 CAP1162.1 CAP1164.2 CAP1165.1 CAP1166.2 CAP1167.1 CAP1168.2 CAP1169.1 CAP1178.2 CAP1179.1 CAP1189.1 CAP1199.1 CAP1450.1 CAP1451.1 CAP1452.1 CAP1456.1 CAP1457.1 CAP1458.1 CAP1459.1 CAP1460.1 CAP1461.1 CAP1462.1 CAP1463.1 CAP1464.1 CAP1465.1 CAP1467.1 CAP1468.1 CAP1469.1 CAP1470.1 CAP1471.1 CAP1472.1 CAP1473.1 CAP1474.1 CAP1475.1 CAP1476.2 CAP1477.2 CAP1478.2 CAP1479.2 CAP1480.2 CAP1481.2 CAP1482.2 CAP1483.2 CAP1484.2 CAP1485.2 CAP1486.2 CAP1487.2 CAP1488.2 CAP1489.2 CAP1490.2 CAP1491.2 CAP1492.2 CAP1493.2 CAP1494.2 CAP1495.2 CAP14466.1 PC6.1 PC7.1 PC10.1 PC11.1 PL5.2 PL6.2 PR85.1 PR91.1 PR94.1 PR95.1 PR117.2 U80.A48(VCCGT_A48) U80.A53(VCCGT_A53) U80.A58(VCCGT_A58) U80.A62(VCCGT_A62) U80.A66(VCCGT_A66) U80.AA63(VCCGT_AA63) U80.AA64(VCCGT_AA64) U80.AA66(VCCGT_AA66) U80.AA67(VCCGT_AA67) U80.AA69(VCCGT_AA69) U80.AA70(VCCGT_AA70) U80.AA71(VCCGT_AA71) U80.AC64(VCCGT_AC64) U80.AC65(VCCGT_AC65) U80.AC66(VCCGT_AC66) U80.AC67(VCCGT_AC67) U80.AC68(VCCGT_AC68) U80.AC69(VCCGT_AC69) U80.AC70(VCCGT_AC70) U80.AC71(VCCGT_AC71) U80.J43(VCCGT_J43) U80.J45(VCCGT_J45) U80.J46(VCCGT_J46) U80.J48(VCCGT_J48) U80.J50(VCCGT_J50) U80.J52(VCCGT_J52) U80.J53(VCCGT_J53) U80.J55(VCCGT_J55) U80.J56(VCCGT_J56) U80.J58(VCCGT_J58) U80.J60(VCCGT_J60) U80.K48(VCCGT_K48) U80.K50(VCCGT_K50) U80.K52(VCCGT_K52) U80.K53(VCCGT_K53) U80.K55(VCCGT_K55) U80.K56(VCCGT_K56) U80.K58(VCCGT_K58) U80.K60(VCCGT_K60) U80.L62(VCCGT_L62) U80.L63(VCCGT_L63) U80.L64(VCCGT_L64) U80.L65(VCCGT_L65) U80.L66(VCCGT_L66) U80.L67(VCCGT_L67) U80.L68(VCCGT_L68) U80.L69(VCCGT_L69) U80.L70(VCCGT_L70) U80.L71(VCCGT_L71) U80.M62(VCCGT_M62) U80.N63(VCCGT_N63) U80.N64(VCCGT_N64) U80.N66(VCCGT_N66) U80.N67(VCCGT_N67) U80.N69(VCCGT_N69) U80.N70(VCCGT_N70) U80.N71(VCCGT_N71) U80.R63(VCCGT_R63) U80.R64(VCCGT_R64) U80.R65(VCCGT_R65) U80.R66(VCCGT_R66) U80.R67(VCCGT_R67) U80.R68(VCCGT_R68) U80.R69(VCCGT_R69) U80.R70(VCCGT_R70) U80.R71(VCCGT_R71) U80.T62(VCCGT_T62) U80.U65(VCCGT_U65) U80.U68(VCCGT_U68) U80.U71(VCCGT_U71) U80.W63(VCCGT_W63) U80.W64(VCCGT_W64) U80.W65(VCCGT_W65) U80.W66(VCCGT_W66) U80.W67(VCCGT_W67) U80.W68(VCCGT_W68) U80.W69(VCCGT_W69) U80.W70(VCCGT_W70) U80.W71(VCCGT_W71) U80.Y62(VCCGT_Y62)
+VCCMPHYAON_1P0: CAP1262.1 RPM3285.1 U80.K17(VCCMPHYAON_1P0_K17) U80.L1(VCCMPHYAON_1P0_L1)
+VCCMPHYGTAON_1P0: C1102.2 C1103.2 CAP1244.1 RPM3286.1 U80.N15(VCCMPHYGTAON_1P0_N15) U80.N16(VCCMPHYGTAON_1P0_N16) U80.N17(VCCMPHYGTAON_1P0_N17) U80.P15(VCCMPHYGTAON_1P0_P15) U80.P16(VCCMPHYGTAON_1P0_P16)
+VCCPAZIO: CAP1268.1 PR87.1 Q105.1(S) RPM3309.1 RPM3310.2 U80.AJ19(VCCPAZIO_AJ19)
+VCCPDSW_3P3: CAP1245.2 CAP1252.2 RPM3312.1 U80.AD17(VCCPDSW_3P3_AD17) U80.AD18(VCCPDSW_3P3_AD18) U80.AJ17(VCCPDSW_3P3_AJ17)
+VCCPGPPA: RPM3326.1 U80.AK15(VCCPGPPA_AK15)
+VCCPGPPB: CAP1279.1 RPM3327.1 U80.AG15(VCCPGPPB_AG15)
+VCCPGPPC: CAP1287.1 RPM3328.1 U80.Y16(VCCPGPPC_Y16)
+VCCPGPPD: PR88.1 RPM3323.2 RPM3324.1 U80.Y15(VCCPGPPD_Y15)
+VCCPGPPE: CAP1296.1 RPM3329.1 U80.T16(VCCPGPPE_T16)
+VCCPGPPF: C2.2 PR89.1 RPM3331.1 U80.AF16(VCCPGPPF_AF16)
+VCCPGPPG: C1C7.1 RPM3333.1 U80.AD15(VCCPGPPG_AD15)
+VCCPRIM_1P0: CAP1276.1 CAP14483.2 RPM3283.1 U80.AB19(VCCPRIM_1P0_AB19) U80.AB20(VCCPRIM_1P0_AB20) U80.P18(VCCPRIM_1P0_P18)
+VCCPRIM_3P3: CAP1275.1 RPM3315.1 U80.AJ21(VCCPFUSE_3P3_AJ21) U80.V19(VCCPHVC_3P3)
+VCCPRIM_CORE: CAP1272.1 RPM3284.1 U80.AF18(VCCPRIM_CORE_AF18) U80.AF19(VCCPRIM_CORE_AF19) U80.V20(VCCPRIM_CORE_V20) U80.V21(VCCPRIM_CORE_V21)
+VCCPRTC_3P3: CAP1318.1 RPM3317.1 U80.AK19(VCCPRTC_3P3_AK19) U80.BB14(VCCPRTC_3P3_BB14)
+VCCPRTCPRIM_3P3: CAP1317.1 CAP1319.2 CAP1320.2 RPM3316.1 U80.AK17(VCCPRTCPRIM_3P3_AK17)
+VCCPSPI: RPM3314.1 U80.AJ16(VCCPSPI_AJ16)
+VCCSA: CAP1281.1 CAP1284.1 CAP1285.1 CAP1286.2 CAP1289.1 CAP1290.1 CAP1291.2 CAP1293.1 CAP1294.1 CAP1295.2 CAP1299.1 CAP1300.1 CAP1301.2 CAP1303.1 CAP1304.1 CAP1305.2 CAP1308.2 CAP1309.1 CAP1310.2 CAP1316.2 PC1198.1 PC1199.1 PC1200.1 PC1201.1 PC1202.1 PC1203.1 PL7.2 PR33.2 PR115.2 U80.AK23(VCCSA_AK23) U80.AK25(VCCSA_AK25) U80.G23(VCCSA_G23) U80.G25(VCCSA_G25) U80.G27(VCCSA_G27) U80.G28(VCCSA_G28) U80.J22(VCCSA_J22) U80.J23(VCCSA_J23) U80.J27(VCCSA_J27) U80.K23(VCCSA_K23) U80.K25(VCCSA_K25) U80.K27(VCCSA_K27) U80.K28(VCCSA_K28) U80.K30(VCCSA_K30)
+VCCSFR_OC: CAP1250.2 CAP14493.2 JP5100.2 PR32.2 U80.AL23(VCCSFR_OC)
+VCCSRAM_1P0: CAP1256.1 CAP14481.1 RPM3289.1 U80.AF20(VCCSRAM_1P0_AF20) U80.AF21(VCCSRAM_1P0_AF21) U80.T19(VCCSRAM_1P0_T19) U80.T20(VCCSRAM_1P0_T20)
+VDDQ_MEM: CSM1020.1 CSM1021.2 CSM1023.1 CSM1024.2 CSM1025.1 CSM1026.2 CSM1027.2 CSM1028.2 CSM1029.2 CSM1030.2 CSM2033.1 CSM2034.2 CSM2036.1 CSM2037.2 CSM2038.1 CSM2039.2 CSM2040.2 CSM2041.2 CSM2042.2 CSM2043.2 CSM2101.1 CSM2102.2 CSM2104.1 CSM2105.2 CSM2106.1 CSM2107.2 CSM2108.2 CSM2109.2 CSM2110.2 CSM2111.2 CSM2133.2 CSM2135.1 CSM2136.2 CSM2137.1 CSM2138.2 CSM2139.2 CSM2140.2 CSM2141.2 CSM2142.2 CSM3132.1 PC1219.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1247.1 PC1248.1 PC1249.1 PC1250.1 PL9.1 PR26.2 R3571.2 RAP1029.1 RAP1031.1 RAP1033.1 USM2000.A8(VDD2#18) USM2000.A9(VDD2#19) USM2000.A11(VDDQ#1) USM2000.C12(VDDQ#2) USM2000.D4(VDD2#20) USM2000.D5(VDD2#1) USM2000.D6(VDD2#2) USM2000.E8(VDDQ#4) USM2000.E12(VDDQ#3) USM2000.F2(VDDCA#1) USM2000.G2(VDDCA#2) USM2000.G5(VDD2#3) USM2000.G12(VDDQ#5) USM2000.H3(VDDCA#3) USM2000.H5(VDD2#5) USM2000.H6(VDD2#6) USM2000.H8(VDDQ#7) USM2000.H9(VDDQ#8) USM2000.H11(VDDQ#6) USM2000.H12(VDD2#4) USM2000.J5(VDD2#7) USM2000.J6(VDD2#8) USM2000.J9(VDDQ#10) USM2000.J10(VDDQ#9) USM2000.K5(VDD2#10) USM2000.K6(VDD2#11) USM2000.K8(VDDQ#12) USM2000.K11(VDDQ#11) USM2000.K12(VDD2#9) USM2000.L2(VDDCA#4) USM2000.L5(VDD2#12) USM2000.L12(VDDQ#13) USM2000.M2(VDDCA#5) USM2000.N8(VDDQ#15) USM2000.N12(VDDQ#14) USM2000.P4(VDD2#13) USM2000.P5(VDD2#14) USM2000.P6(VDD2#15) USM2000.R12(VDDQ#16) USM2000.U8(VDD2#16) USM2000.U9(VDD2#17) USM2000.U11(VDDQ#17) USM2001.A8(VDD2#18) USM2001.A9(VDD2#19) USM2001.A11(VDDQ#1) USM2001.C12(VDDQ#2) USM2001.D4(VDD2#20) USM2001.D5(VDD2#1) USM2001.D6(VDD2#2) USM2001.E8(VDDQ#4) USM2001.E12(VDDQ#3) USM2001.F2(VDDCA#1) USM2001.G2(VDDCA#2) USM2001.G5(VDD2#3) USM2001.G12(VDDQ#5) USM2001.H3(VDDCA#3) USM2001.H5(VDD2#5) USM2001.H6(VDD2#6) USM2001.H8(VDDQ#7) USM2001.H9(VDDQ#8) USM2001.H11(VDDQ#6) USM2001.H12(VDD2#4) USM2001.J5(VDD2#7) USM2001.J6(VDD2#8) USM2001.J9(VDDQ#10) USM2001.J10(VDDQ#9) USM2001.K5(VDD2#10) USM2001.K6(VDD2#11) USM2001.K8(VDDQ#12) USM2001.K11(VDDQ#11) USM2001.K12(VDD2#9) USM2001.L2(VDDCA#4) USM2001.L5(VDD2#12) USM2001.L12(VDDQ#13) USM2001.M2(VDDCA#5) USM2001.N8(VDDQ#15) USM2001.N12(VDDQ#14) USM2001.P4(VDD2#13) USM2001.P5(VDD2#14) USM2001.P6(VDD2#15) USM2001.R12(VDDQ#16) USM2001.U8(VDD2#16) USM2001.U9(VDD2#17) USM2001.U11(VDDQ#17) USM2002.A8(VDD2#18) USM2002.A9(VDD2#19) USM2002.A11(VDDQ#1) USM2002.C12(VDDQ#2) USM2002.D4(VDD2#20) USM2002.D5(VDD2#1) USM2002.D6(VDD2#2) USM2002.E8(VDDQ#4) USM2002.E12(VDDQ#3) USM2002.F2(VDDCA#1) USM2002.G2(VDDCA#2) USM2002.G5(VDD2#3) USM2002.G12(VDDQ#5) USM2002.H3(VDDCA#3) USM2002.H5(VDD2#5) USM2002.H6(VDD2#6) USM2002.H8(VDDQ#7) USM2002.H9(VDDQ#8) USM2002.H11(VDDQ#6) USM2002.H12(VDD2#4) USM2002.J5(VDD2#7) USM2002.J6(VDD2#8) USM2002.J9(VDDQ#10) USM2002.J10(VDDQ#9) USM2002.K5(VDD2#10) USM2002.K6(VDD2#11) USM2002.K8(VDDQ#12) USM2002.K11(VDDQ#11) USM2002.K12(VDD2#9) USM2002.L2(VDDCA#4) USM2002.L5(VDD2#12) USM2002.L12(VDDQ#13) USM2002.M2(VDDCA#5) USM2002.N8(VDDQ#15) USM2002.N12(VDDQ#14) USM2002.P4(VDD2#13) USM2002.P5(VDD2#14) USM2002.P6(VDD2#15) USM2002.R12(VDDQ#16) USM2002.U8(VDD2#16) USM2002.U9(VDD2#17) USM2002.U11(VDDQ#17) USM2003.A8(VDD2#18) USM2003.A9(VDD2#19) USM2003.A11(VDDQ#1) USM2003.C12(VDDQ#2) USM2003.D4(VDD2#20) USM2003.D5(VDD2#1) USM2003.D6(VDD2#2) USM2003.E8(VDDQ#4) USM2003.E12(VDDQ#3) USM2003.F2(VDDCA#1) USM2003.G2(VDDCA#2) USM2003.G5(VDD2#3) USM2003.G12(VDDQ#5) USM2003.H3(VDDCA#3) USM2003.H5(VDD2#5) USM2003.H6(VDD2#6) USM2003.H8(VDDQ#7) USM2003.H9(VDDQ#8) USM2003.H11(VDDQ#6) USM2003.H12(VDD2#4) USM2003.J5(VDD2#7) USM2003.J6(VDD2#8) USM2003.J9(VDDQ#10) USM2003.J10(VDDQ#9) USM2003.K5(VDD2#10) USM2003.K6(VDD2#11) USM2003.K8(VDDQ#12) USM2003.K11(VDDQ#11) USM2003.K12(VDD2#9) USM2003.L2(VDDCA#4) USM2003.L5(VDD2#12) USM2003.L12(VDDQ#13) USM2003.M2(VDDCA#5) USM2003.N8(VDDQ#15) USM2003.N12(VDDQ#14) USM2003.P4(VDD2#13) USM2003.P5(VDD2#14) USM2003.P6(VDD2#15) USM2003.R12(VDDQ#16) USM2003.U8(VDD2#16) USM2003.U9(VDD2#17) USM2003.U11(VDDQ#17)
+VDDQ_MEM_GND: PR27.1 PU3254.E6(FBVR4N)
+VDDQ_MEM_SOC: CAP1240.1 CAP1241.1 CAP1242.1 CAP1243.2 CAP1247.1 CAP1248.2 CAP1253.1 CAP1254.2 CAP1257.1 CAP1258.2 CAP1259.2 CAP1264.2 CAP1265.1 CAP1270.2 CAP1274.2 PC1150.2 PR32.1 PU13.2(D#1) PU13.3(D#2) R3571.1 U80.AM40(VCCDDQ_CLK) U80.AU23(VCCDU_AU23) U80.AU28(VCCDU_AU28) U80.AU35(VCCDU_AU35) U80.AU42(VCCDU_AU42) U80.BB23(VCCDU_BB23) U80.BB32(VCCDU_BB32) U80.BB41(VCCDU_BB41) U80.BB47(VCCDU_BB47) U80.BB51(VCCDU_BB51)
