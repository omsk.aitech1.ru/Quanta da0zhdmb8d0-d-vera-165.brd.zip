# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+V3_LDO: length 468
  TOP w0.254: v1(79.04,70.65) 79.32,70.37 81.2,70.37 81.88,71.05 81.88,72.17 81.46,72.59 RPM3591.2 81.91,73.07 81.91,74.18 RPM3592.2 ; PR136.2 69.94,83.74 v1(69.47,84.21) 69.18,84.21 68.03,85.36 PR111.1 ; v1(75.41,79.01) 75.22,79.01 PC1316.1 ; v1(117.06,16.75) 116.72,16.75 R5094.2 ; PR74.1 76.75,75.83 76.45,76.13 75.05,76.13 v4(74.63,76.55) 74.4,76.79 74.28,76.79 PC1320.2
  TOP w0.381: v1(53.66,68.46) 53.66,68.36 54.1,67.92 55.74,67.92 55.91,68.09 56.9,68.09 57.52,68.72 57.52,71.27 56.75,72.04 56.75,73.77 57.89,74.91 60.14,74.91 60.72,74.33 PC9114.1 60.76,73.39 61.71,73.39 PC1315.1 61.98,73.19 64.21,73.19 64.73,73.7 PR51.2 65.36,73.7 v3(65.88,74.22)
  TOP w0.508: v1(186.16,75.56) 184.6,77.12 178.91,77.12 176.19,79.84 176.19,83.27 v1(176.46,83.54) 176.73,83.8 R5160.2
  TOP w0.762: 158.67,24.21 160.52,22.36 160.52,21.14 160.01,20.63 158.29,20.63 154.83,17.18 154.83,16.72
  IN1 w0.254: v1(71.82,84.44) 71.82,84.11 72.87,83.06 72.87,81.77 73.91,80.73 73.91,79.48 74.38,79.01 v1(75.41,79.01) 75,78.6 74.64,78.6 74.18,78.14 74.18,77.56 74.49,77.25 74.49,76.7 v4(74.63,76.55) 74.68,76.55 75.15,76.08 76.4,76.08 77.06,75.42 77.06,72.58 78.99,70.65 v1(79.04,70.65)
  IN1 w0.508: v1(156.81,24.82) 168.09,24.82 169.49,26.22 187.88,26.22 189.37,27.71 197.44,27.71 201.31,31.57 201.31,36.77 200.07,38.01 200.07,39.02 201.87,40.83 201.87,44.31 196.59,49.59 196.59,56.47 192.65,60.41 192.65,63.13 186.91,68.87 186.91,74.81 v1(186.16,75.56)
  IN1 w0.762: 18.69,24.54 18.51,24.72 18.51,32.07 15.33,35.24 15.33,36.97 13.84,38.47 13.84,40.11 15.51,41.79 15.51,47.56 15.05,48.01 13.91,48.01 v5(12.72,49.21) ; 19.52,23.81 18.61,22.89 18.61,19.72 18.28,19.39 18.28,15.63 16.25,13.6 16.25,12.53 15.61,11.89 v1(15.05,11.89)
  IN2 w0.203: v4(74.63,76.55) 74.77,76.42 74.77,75.35 73.35,73.93 72.76,73.93 72.72,73.96 71.63,73.96 71.16,74.43 70.23,74.43 70.16,74.35 69.18,74.35 69.05,74.22 v3(65.88,74.22)
  IN2 w0.254: v1(69.47,84.21) 69.95,84.21 70.53,84.79 71.11,84.79 71.47,84.44 v1(71.82,84.44)
  IN2 w0.508: v1(84.09,25.49) v1(83.28,25.49)
  IN2 w0.762: 23.77,24.34 23.77,27.01 25.19,28.43 25.19,30.41 27.17,32.39 28.51,32.39 30.29,34.17 31.84,34.17 39.46,41.79 43.99,41.79 52.09,33.69 53.81,33.69 ; 55.97,33.56 56.33,33.92 59.2,33.92 64.76,28.35 67.89,28.35 v1(70.35,25.89) 70.35,24.32 76.9,17.76 83.72,17.76 85.19,16.29 90.13,11.35 111.43,11.35 116.83,16.75 v1(117.06,16.75) 150.93,16.75 151.92,15.76 153.21,15.76 ; v5(12.72,49.21) 13.15,48.78 16.22,48.78 16.96,49.51 19.25,49.51 19.45,49.72 21.43,49.72 21.99,50.27 24.15,50.27 26.41,52.53 26.64,52.53 27.55,53.45 27.55,56.12 28.19,56.75 28.19,58.91 29.84,60.56 34.89,60.56 35.65,61.32 37.18,61.32
  BOTTOM w0.203: PU3254.L1 74.43,76.69 74.57,76.55 v4(74.63,76.55) ; PU3254.G2 PU3254.F1 ; v3(65.88,74.22) 65.88,74.6 PU3254.P16
  BOTTOM w0.254: v1(75.41,79.01) 74.33,79.01 74.15,79.19 PU3254.F1 ; v1(84.09,25.49) 84.29,25.49 84.47,25.31 U123.2
  BOTTOM w0.508: v1(38.58,62.06) 38.58,63.03 44.01,68.46 v1(53.66,68.46) ; PR14.1 v1(186.16,75.56) ; PR20.2 54.73,32.27 v1(55.08,31.91) ; v1(70.35,25.89) 70.75,25.49 v1(83.28,25.49)
  vias: v1(22.32,23.78) v1(23,23.78) v1(37.94,62.01) v1(154.2,15.78) v1(154.83,15.78)
+V3P3_BIOS_SPI:
  vias: v1(74.51,59.39) v1(74.51,58.78) v1(76.27,58.99)
+V3P3_BIOS_SPI_SERVO: length 73.6
  TOP w0.508: v1(75.58,59.47) 74.82,60.23 CR7.2
  IN2 w0.508: v1(75.58,59.47) 75.58,56.01 74.4,54.83 73.33,54.83 71.93,53.42 71.93,51.57 71.05,50.7 71.05,46.27 71.95,45.37 71.95,44.9 72.2,44.64 72.2,44.15 72.73,43.63 72.73,41.23 73.22,40.74 73.22,40.13 73.97,39.38 73.97,35.45 74.36,35.06 74.64,35.06 75,34.7 75,33.03 75.45,32.58 75.45,31.68 77.99,29.14 77.99,28.39 79.86,26.51 80.45,26.51 84.14,22.82 85.24,22.82 89.18,18.88 91.42,18.88 94.41,15.9 94.41,15.9 94.7,15.61 94.94,15.61 95.12,15.44 95.23,15.33 97.87,15.33 98.15,15.6 101.63,15.6 101.96,15.27 104.9,15.27 v1(105.2,14.97)
  BOTTOM w0.203: CN17.6 106.33,15.23 106.07,14.97 105.2,14.97 v1(105.2,14.97)
+V3P3_INA: length 24.2
  BOTTOM w0.102: RPM3577.1 101.07,9.8 100.33,10.54 CN17.35 100.33,11.84 99.69,12.48 96.83,12.48 95.92,11.56 92.33,11.56 92.04,11.85 92.04,12.45 94.69,15.1 v1(95.05,15.1) 96.31,15.1 96.87,15.65 96.87,16.92 96.64,17.15 96.64,17.65 97.97,18.98 98.49,18.98 98.65,18.83 98.65,18.57 RPM3576.1
+V3P3_THM: length 26.9
  TOP w0.254: v1(78.19,14.52) 79.61,15.93 87.29,15.93 90.21,13.01 v1(91.91,13.01)
  BOTTOM w0.254: UCP4007.1 78.46,15.64 CCP4090.1 v1(78.19,14.52) ; UCP4006.1 94.06,18.04 RPM3338.1 CCP4089.1 v1(94.7,16.58) 94.7,15.62 92.09,13.01 v1(91.91,13.01)
+V3P3_TP:
  vias: v1(173.68,25.26)
+V3P3_TP_OUT: length 115.1
  TOP w0.508: v1(87.86,50.95) 87.86,50.95 87.86,50.09 88.92,49.03 89.41,49.03 92.65,45.79 92.65,44.97 93.62,44 93.62,43.95 95.19,42.37 95.19,34.86 94.3,33.97 94.3,32.24 95.47,31.07 97.07,31.07 101.98,26.16 106.19,26.16 106.68,26.65 112.51,26.65 114.26,28.4 118.71,28.4 119.19,28.89 135.86,28.89 136.09,29.12 v1(136.11,29.12) ; v1(168.7,22.61) 168.72,22.64 168.72,22.87 v1(170.43,24.57) 172.13,26.27 172.13,26.78 v1(172.18,26.83) 172.56,27.21 173.06,27.21 R964.2
  IN2 w0.508: v1(172.18,26.83) 171.67,26.32 159.23,26.32 158.67,26.88 152.55,26.88 150.88,28.55 137.68,28.55 137.11,29.12 v1(136.11,29.12)
  BOTTOM w0.203: v1(87.86,50.95) 87.38,50.95 86.36,51.97 RAP1009.2 86.36,52.45 86.32,52.48 RAP1010.2
  vias: v1(169.33,22.61) v1(179.41,22.7) v1(180.14,22.7)
+V3P3_USBPD: length 109.5
  TOP w0.254: U90.11 23.19,70.45 23.37,70.64 C849.2 ; C850.2 24.99,68.37 24.74,68.11 U90.8
  TOP w0.381: R1169.1 R1168.1 v1(88.24,43.92) 88.23,45.13 86.06,47.31 86.06,47.48 v1(85.29,48.24) ; v1(82.16,51.77) 81.15,52.79 75.52,52.79 74.31,54 70.4,54 70.12,53.72 65.12,53.72 64.95,53.55 63.21,53.55 v1(63.09,53.68)
  TOP w0.508: v1(26.26,68.37) C850.2 ; v1(26.26,68.37) 26.26,67.09 26.15,66.99 26.15,63.99 25.57,63.41 24.86,63.41 ; v1(26.26,68.37) 26.26,70.57 25.93,70.9 25.08,70.9 24.82,70.64 C849.2
  IN1 w0.381: v1(26.26,68.37) 27.05,69.16 39.57,69.16 42.7,66.02 48.95,66.02 50.74,64.23 51.1,64.23 51.58,63.75 56.99,63.75 61,59.74 61,56.04 60.67,55.71 60.67,55.21 61.11,54.78 61.9,54.78 63,53.68 v1(63.09,53.68)
  IN2 w0.508: 13.43,66.28 14.78,66.28 15.73,65.32 19.04,65.32 v1(19.78,64.58)
  BOTTOM w0.203: U96.26 v1(19.78,62.18) ; U96.4 v1(24.2,64.18) ; U96.13 v1(24.15,60.58) ; v1(19.7,60.71) 19.97,60.98 U96.23 ; U96.7 v1(24.15,62.98) ; U96.1 v1(24.22,65.38) ; U96.32 v1(19.78,64.58) ; U96.29 v1(19.78,63.38) ; U96.10 v1(24.15,61.78)
  BOTTOM w0.254: v1(19.65,59.14) 19.65,58.97 19.86,58.8 19.86,58.28 RCP4160.1
  BOTTOM w0.381: v1(82.16,51.77) 82.75,51.77 84.04,50.48 84.04,49.41 84.68,48.78 84.76,48.78 v1(85.29,48.24)
  vias: v1(12.13,66.12) v1(12.74,66.12)
+V3P3A: length 409.8
  TOP w0.305: v1(105.43,32.15) PU11.1 ; PU11.5 101.9,32.8 101.57,33.13 101.21,33.13 100.87,32.79 PC1268.2
  TOP w0.381: PU15.1 82.67,63.95 82.02,64.6 PU15.5 80.35,64.6 80.23,64.72 PC1267.2 v1(79.62,63.91) ; R1B30.1 36.12,27.64 36.12,35.99 37.57,37.43 v1(40.39,37.43) 43.21,37.43 43.92,38.15 49.51,38.15 49.71,38.35
  TOP w0.508: RPM3589.1 171.92,19.59 v1(171.59,19.26) ; v1(105.43,32.15) 105.55,32.02 105.55,31.22 106.06,30.72 v1(107.36,30.72) ; v1(100.22,31.93) 100.22,32.09 100.68,32.55 PC1268.2 ; v1(95.27,87.36) 92.65,87.36 92.17,87.84 v1(92.09,87.84) 91.91,88.02 RAP3045.2 ; v1(96.51,84.96) 96.82,84.96 RPM3310.1 97.86,84.27 97.86,84.78 RPM3315.2 ; v1(82.92,54.49) 79.86,54.49 78.71,55.64 77.21,55.64 76.83,55.25 76.22,55.25 76.12,55.15 69.92,55.15 69.69,54.92 68.85,54.92 68.09,55.68 67.66,55.68 67.28,56.07 67.28,56.52 v1(67.68,56.93) ; R960.1 58.76,52.48 v1(58.67,52.56) ; v1(108.96,21.37) 109.62,20.71 109.62,19.92 112.87,16.67 112.87,15.02 ; v1(19.57,22.41) 19.55,22.29 R1B33.1
  TOP w1.524: 189.1,11.21 187.61,11.21 182.74,16.08 165.2,16.08 164,17.28 159.44,17.28 155.71,13.55 142.08,13.55 140.73,14.89 123.79,14.89 ; 52.5,36.07 57.48,31.1 57.9,31.1 60.84,28.16 71.51,28.16 73.11,26.55 79.75,26.55 82.86,23.44 83.49,23.44 87.16,19.77 89.34,19.77 94.53,14.59 96.89,14.59 99.05,12.43
  IN1 w0.079: v4(71.03,79.64) 71.03,80.27 71.09,80.33 71.1,80.33 71.32,80.55 71.32,80.92 70.98,81.26
  IN1 w0.203: 70.98,81.26 70.22,82.03 70.22,82.49
  IN1 w0.508: v1(171.59,19.26) 172.28,19.95 179.04,19.95 179.47,19.51 179.47,17.71 181.07,16.11 183.23,16.11 186,13.34 189.45,13.34 190.21,12.58 v1(190.21,12.01) ; 70.22,82.49 70.1,82.61 70.1,84.87 69.41,85.55 67.55,85.55 65.68,87.43 65.68,93.89 66.31,94.52 82.44,94.52 85.85,91.12 87.19,91.12 v1(89.32,88.98) ; v1(72.64,61.89) 72.67,61.91 75.28,61.91 76.67,63.3 79.23,63.3 79.62,63.7 v1(79.62,63.91)
  IN1 w1.016: 54.32,46.64 54.32,48.41 52.8,49.94 v1(52.8,50.96) 52.8,51.72 53.11,52.03 53.11,53.24 51.56,54.79 50.3,54.79 49.51,55.58
  IN2 w0.508: v1(67.68,56.93) v1(72.64,61.89) ; v1(93.74,50.76) 98.15,50.76 98.67,51.29 99.74,51.29 v1(100.91,52.46) 101.61,51.76 101.61,48.94 102.41,48.13 102.41,46.47 103.12,45.76 v1(103.12,43.85) 103.12,43.41 103.62,42.92 103.62,42.22 103.26,41.86 103.26,40.38 103.52,40.11 v1(103.52,39.76) 105.78,37.5 105.78,34.04 104.79,33.05 104.79,32.42 105.06,32.15 v1(105.43,32.15) ; v1(89.32,88.98) 90.95,88.98 v1(92.09,87.84)
  IN2 w1.524: 191.77,13.4 191.77,14.12 192.89,15.25 194.56,15.25 195.64,14.17 206.09,14.17
  BOTTOM w0.203: v1(100.91,52.46) 100.88,52.48 RAP3053.2 RAP3054.2 ; v1(103.12,43.85) 103.12,43.36 103.37,43.11 RAP1453.1 ; 103.27,39.3 101.37,39.3 101.12,39.56 98.82,39.56 98.39,39.99 R1134.1 ; CN17.18 103.93,13.06 103.42,12.56 v1(103.42,12.28) ; PU3254.F7 70.97,79.58 v4(71.03,79.64)
  BOTTOM w0.254: v1(102.46,75.98) 102.35,75.98 102.08,75.71 RAP1452.1
  BOTTOM w0.508: v1(52.8,50.96) 55.43,53.59 57.64,53.59 v1(58.67,52.56) 59.48,53.37 61.56,53.37 61.94,52.99 63.32,52.99 64.69,51.62 65.55,51.62 66.01,52.08 66.01,55.25 v1(67.68,56.93) ; v1(100.22,31.93) 100.14,31.86 100.14,31.28 100.63,30.79 101.34,30.79 102.66,29.47 103.7,29.47 103.83,29.6 105.58,29.6 106.7,30.72 v1(107.36,30.72) 107.36,29.88 107.56,29.67 107.56,28.64 109.09,27.11 109.09,24.42 108.2,23.53 108.2,22.13 v1(108.96,21.37) ; v1(88.33,58.5) 89.04,57.79 RPM3333.2
  BOTTOM w1.524: 214.9,24.72 207.54,17.36 207.54,15.7
  vias: v1(17.62,25.94) v1(17.62,25.31) v1(22.14,29.14) v1(22.14,28.15) v1(22.83,29.14) v1(45.22,63.1) v1(45.25,62.49) v1(46.3,45.73) v1(46.32,45.09) v1(46.88,41.49) v1(46.94,45.17) v1(47.26,40.98) v1(50.21,37.96) v1(50.74,37.5) v1(54.48,44.86) v1(55.08,44.86) v1(88.02,54.86) v1(91.64,72.83) v1(91.62,60.64) v1(91.99,73.33) v1(92.23,60.6) v1(97.22,74.68) v1(97.85,74.62) v1(190.82,12.01) v1(191.43,12.01) v1(207.43,14.1) v1(208.09,14.1) v1(208.7,14.13) v1(215.61,27.29) v1(215.97,26.75) v1(216.32,27.26)
+V3P3A_AUDIO_FET: length 9
  TOP w0.102: R1B33.2 C1C50.1 R1D19.2 R1D18.2 15.55,21.11 15.08,20.63 v1(15.08,20.58)
  BOTTOM w0.102: 18.51,17.94 17.44,17.94 15.08,20.3 v1(15.08,20.58)
+V3P3A_DSW: length 324.6
  TOP w0.203: RAP3020.1 RAP1081.1 RAP1011.1 RAP1005.1
  TOP w0.254: PR108.1 PR109.1 70.53,85.31 70.53,84.51 v1(70.73,84.31) ; RAP1005.1 107.77,73.77 107.03,73.77 106.34,74.46 105.99,74.46 105.94,74.51 105.38,74.51 104.47,75.41 v1(104.01,75.41) 104.01,74.94 104.46,74.48 104.46,73.96 RPM3312.2 ; v1(62.7,86.15) 62.7,85 62.71,85 PR107.1 63.52,84.37 v1(64.87,83.02) ; PR106.1 PR105.1 76.79,83.83 v1(76.79,84.42) ; v4(69.47,75.17) 69.98,74.66 69.98,73.61 v1(69.48,73.1) 69.48,72.52 PC9110.2
  TOP w0.508: v1(96.13,19.02) 96.13,20.61 90.24,26.5 90.24,29.6 93.06,32.42 93.06,36.81 92.17,37.7 92.17,38.27 92.78,38.88 v1(92.78,39.32) ; v1(5.86,78.7) 5.91,78.75 v1(5.91,86.7) ; 153.04,17.05 153.04,15.69 153.65,15.07 155.34,15.07 156.37,16.1 156.37,17.67 158.59,19.9 160.32,19.9 161.26,20.84 ; 153.04,17.05 153.04,17.05 ; 153.04,17.05 153.04,17.05 ; RPM3590.1 167.4,20.61 166.69,19.9 162.2,19.9 161.26,20.84 ; v1(113.58,18.04) 115.7,15.91 117.44,15.91 120.36,18.83 139.16,18.83 140.94,17.05 153.04,17.05 ; 153.04,17.05 154.38,18.4 154.73,18.4 155.63,19.3 R56.1 ; 153.79,25.59 154.2,25.99 157.95,25.99 161.26,22.69 161.26,20.84 ; 153.79,25.59 152.26,25.59 152,25.85 R5073.1 151.42,25.85 150.69,26.57 147.99,26.57 147.46,26.04 147.46,24.95 148.05,24.37 148.82,24.37 148.82,24.36 149.03,24.36 R5152.1 ; 153.79,25.59 R5144.2 ; RPM3472.2 88.89,40.03 88.92,40 89.2,40 89.63,39.56 89.63,39.19 v1(90.51,38.3) 91.04,38.3 91.97,39.23 91.97,43.59 91.38,44.18 90.91,44.18 88.81,46.28 v1(88.81,46.86) ; RPM3467.2 RPM3458.2 84.01,49.54 v1(84.75,49.54) 85.18,49.97 85.18,57.74 85.79,58.35 85.79,61.54 85.56,61.76 85.56,63.84 84.57,64.83 84.57,66.16 84.15,66.58 84.15,67.41 84.55,67.8 84.55,68.51 85.84,69.81 85.84,71.54 88.15,73.85 v1(88.15,76.4) ; RPM3470.2 v1(87.22,39.15) 87.22,38.27 RPM3476.2 RPM3475.2 88.51,38.14 89.78,36.87 v1(89.78,36.81)
  IN1 w0.254: v1(92.07,79.71) 92.73,79.71 93.34,79.1 97.13,79.1 98.07,78.16 98.67,78.16 100.18,76.66 102.51,76.66 103.76,75.41 v1(104.01,75.41) ; v1(64.87,83.02) 64.87,82.85 65.35,82.38 65.35,81.26 66.31,80.3 66.31,79.28 65.43,78.4 65.43,75.56 67.1,73.9 68.32,73.9 69.11,73.1 v1(69.48,73.1)
  IN1 w0.508: v1(92.78,39.32) 92.26,38.79 91.01,38.79 v1(90.51,38.3) 89.78,37.57 v1(89.78,36.81) ; v1(5.86,78.7) 5.86,77.55 8.4,75.01 11.12,75.01 11.57,75.47 13.23,75.47 16.71,71.99 v1(17.54,71.99) ; v1(84.75,49.54) 86.4,49.54 88.81,47.14 v1(88.81,46.86) ; v1(88.15,76.4) 88.58,76.4 91.89,79.71 v1(92.07,79.71)
  IN2 w0.254: v1(73.96,71.51) 73.58,71.13 72.58,71.13 72.05,71.66 71.82,71.66 70.37,73.1 v1(69.48,73.1) ; v1(64.87,83.02) 64.61,83.28 64.61,83.85 64.97,84.21 66.05,84.21 66.65,83.61 70.04,83.61 v1(70.73,84.31) 70.91,84.31 71.76,83.45 73.63,83.45 74.92,84.74 76.46,84.74 v1(76.79,84.42)
  IN2 w0.508: v1(113.58,18.04) 113.24,17.7 110.44,17.7 109.79,18.36 104.85,18.36 104.43,18.77 97.23,18.77 96.98,19.02 v1(96.13,19.02)
  BOTTOM w0.254: v4(69.47,75.17) PU3254.N10 ; v1(92.07,79.71) 92.07,78.7 93.6,77.17 93.6,76.38 95.65,74.33 RAP1077.1 95.96,73.31 96.01,73.26 RAP1008.1 ; v1(88.15,76.4) 85.53,73.78 82.61,73.78 81.89,73.06 78.22,73.06 77.59,72.42 77.59,71.23 77.31,70.95 74.29,70.95 73.96,71.28 v1(73.96,71.51)
  BOTTOM w0.508: v1(96.13,19.02) 95.79,18.68 RPM3338.2 ; LED2.1 v1(5.86,78.7) ; LED1.1 v1(5.91,86.7)
  vias: v1(17.85,71.36) v1(18.28,71.81) v1(18.59,71.28) v1(18.89,71.84) v1(24.33,56.58) v1(24.4,55.76) v1(24.89,56.83) v1(24.89,56.15) v1(41.74,52.37) v1(42.03,52.9) v1(42.64,52.89) v1(42.69,52.26) v5(55.72,87.61) v5(56.23,88.12) v5(56.74,87.61) v5(57.24,88.12) v5(57.75,87.61) v5(58.26,88.12) v5(58.77,87.61) v5(59.28,88.12) v5(59.78,87.61)
+V3P3A_DSW_GND: length 20.3
  TOP w0.254: v1(61.89,83.9) 61.38,84.41 61.38,84.87 60.96,85.3 v1(60.7,85.3) 60.7,85.56 60.45,85.81 57.46,85.81 PR25.1
  IN1 w0.079: v4(70.44,79.2) 70.44,79.7 70.11,80.02 70.11,80.3 70.38,80.56 70.38,81.1 69.76,81.72 69.76,81.89
  IN1 w0.203: 69.76,81.89 69.44,82.21 69.44,83.34 68.8,83.98 68.8,84.59 68.45,84.95 v1(67.45,84.95)
  IN2 w0.254: v1(67.45,84.95) 67.38,85.02 63.95,85.02 63.01,84.08 62.07,84.08 v1(61.89,83.9)
  BOTTOM w0.152: v4(70.44,79.2) 70.47,79.23 PU3254.E8
+V3P3A_EC: length 185.2
  TOP w0.254: v3(74.5,74.49) 74.81,74.8 75.35,74.8 PR101.1
  TOP w0.381: PR102.1 62.17,70.18 PR104.1 62.94,70.38 PR100.1 63.51,71.09 64.2,71.79 65.22,71.79 65.34,71.92 65.34,71.92 v1(65.58,72.15)
  TOP w0.508: v1(72.89,46.24) 72.89,45.75 v1(68.55,41.41) 71.11,41.41 72.33,42.63 v1(73.53,42.63) 74.72,42.63 76.14,41.21 77.18,41.21 77.58,40.81 R1A4PD1.1 77.94,41.56 77.68,41.82 CPM3440.2 77.68,42.57 78,42.88 78.03,42.88 78.07,42.93 78.39,42.93 78.5,43.05 78.5,43.07 78.86,43.42 78.88,43.42 v1(78.88,43.43) ; v1(97.23,85.89) 97.23,86 96.72,86.52 92.61,86.52 90.85,84.76 90.85,83.88 89.22,82.26 89.22,78.47 88.13,77.38 v1(88.13,77.1) 88.38,77.1 88.82,76.66 88.82,73.65 86.45,71.28 86.45,69.55 86.11,69.21 86.11,66.03 87.06,65.08 87.06,62.42 87.22,62.27 87.22,57.76 86.65,57.2 86.65,50.09 89.41,47.32 v1(89.41,46.53) 91.16,44.79 91.63,44.79 91.64,44.79 v1(91.73,44.79) 91.73,44.72 92.8,43.64 92.8,43.59 93.72,42.68 93.72,42.17 93.69,42.15 93.69,37.12 94.58,36.23 94.58,35.11 93.69,34.22 93.69,32.19 91.74,30.23 CR6.2 90.85,28.23 90.85,26.75 91.15,26.45 v1(92.04,26.45) 98.01,20.48 v1(99.84,20.48)
  IN1 w0.203: v3(74.5,74.49) 74.2,74.49 73.98,74.27 73.98,73.21 73.14,72.37 v1(73.14,71.64)
  IN1 w0.381: v1(65.58,72.15) 65.58,72.45 66.62,73.49 67.63,73.49 68.7,72.43 72.05,72.43 72.84,71.64 v1(73.14,71.64)
  IN1 w0.508: v1(82.36,48.04) 82.73,48.41 83.21,48.41 83.71,48.91 85.53,48.91 86.38,48.06 86.38,47.43 87.6,46.21 89.09,46.21 v1(89.41,46.53) ; v1(68.55,41.41) 68.9,41.05 71.22,41.05 v1(73.14,39.12)
  IN2 w0.508: v1(86.1,32.39) 86.73,31.76 87.72,31.76 90.78,28.7 90.78,27.71 v1(92.04,26.45)
  BOTTOM w0.203: v3(74.5,74.49) 74.5,74.65 PU3254.P1 ; 100.8,17.43 100.8,16.77 100.73,16.7 CN17.34 ; v1(97.23,85.89) 97.38,85.75 RAP1430.1
  BOTTOM w0.254: v1(83.63,37.17) 83.71,37.09 EUPM3247.B7 ; v1(85.87,39.2) 86.21,39.54 EUPM3247.B63 ; v1(78.88,43.43) 78.77,43.54 EUPM3247.B31 ; CPM3438.2 75.5,37.35 75.96,37.35 76.91,38.29 EUPM3247.A19 ; CPM3432.2 83.76,48.69 83.76,48.32 83.67,48.23 83.67,47.06 83.46,46.84 EUPM3247.A42
  BOTTOM w0.381: v1(88.13,77.1) 88.07,77.1 85.18,74.2 82.44,74.2 81.72,73.48 77.53,73.48 76.11,72.06 73.57,72.06 v1(73.14,71.64) ; v1(72.89,46.24) 72.69,46.44 CRPM3519.2
  BOTTOM w0.508: CPM3432.2 83.35,49.05 82.78,48.48 82.78,48.46 v1(82.36,48.04) ; v1(75.84,36.84) 75.31,36.84 CPM3438.2 ; v1(99.84,20.48) 100.8,19.51 100.8,17.43
+V3P3A_EC_ANA: length 10.5
  TOP w0.508: v1(79.04,39.07) 79,39.11 77.56,39.11 77.14,39.53 v1(77.14,39.65) 77.14,39.76 76.76,40.14 v1(75.81,40.14)
  BOTTOM w0.254: v1(79.04,39.07) 79.01,39.04 EUPM3247.B22
  BOTTOM w0.508: FB1.2 70.67,41.14 71.93,39.89 73.86,39.89 CPM3434.2 CPM3437.2 75.79,40.16 v1(75.81,40.14)
+V3P3A_EC_SPI: length 61.9
  TOP w0.203: v1(65.85,59.39) 65.98,59.39 67.66,57.72 67.91,57.72 68.3,57.33 RPM3457.1
  TOP w0.254: v1(64.33,42.67) 64.33,42.11 68.14,38.3 68.14,37.98 68.83,37.29 68.83,35.99 70.95,33.87 73.82,33.87 75.91,31.78 82.92,31.78 84.49,30.21 87.52,30.21 v1(89.63,28.1)
  IN2 w0.254: v1(65.85,59.39) 65.4,59.39 63.72,57.72 63.72,53.6 63.39,53.27 63.39,48.74 62.35,47.7 62.35,43.26 62.94,42.67 v1(64.33,42.67)
  BOTTOM w0.203: RPM3468.1 v1(89.63,28.1)
  BOTTOM w0.508: v1(89.63,28.1) 89.88,28.35 v1(92.93,28.35) ; v1(96.87,29.12) 96.99,28.99 UPM3253.8
+V3P3A_EC_SPI_SERVO: length 23.6
  TOP w0.508: v1(105.63,13.55) 102.03,17.15 102.03,19.67 100.45,21.24 98.39,21.24 v1(95.41,24.23) 92.42,27.21 CR8.2
  BOTTOM w0.203: v1(105.63,13.55) 105,12.91 105,12.19 104.73,11.92 CN17.13
+V3P3A_R950:
  vias: v1(43.73,49.64)
+V3P3A_RTC: length 96.1
  TOP w0.508: v1(97.53,77.55) 97.53,77.56 98.22,76.87 99.76,76.87 100.73,77.83 100.73,79.41 101.2,79.88 107.36,79.88 110.43,76.81 110.43,75.5 v1(110.36,75.42) 110.31,75.38 110.31,73.47 110.17,73.34 110.17,72.21 RPM3317.2
  IN1 w0.635: v1(88.89,92.51) 86.26,92.51 82.91,95.87 65.84,95.87 64.39,94.42 64.39,89.89 63.39,88.88 63.39,84.43 62.38,83.42 62.38,81.7 v1(62.55,81.53) ; v1(97.53,77.55) 97.53,77.93 96.91,78.56 91.75,78.56 v1(90.52,77.33)
  BOTTOM w0.381: v1(62.55,81.53) 63.04,81.53 PC1317.1 63.87,80.7 65.88,80.7 66.39,80.19 PU3254.D16
  BOTTOM w0.635: v1(88.89,92.51) 90.14,91.27 90.14,87.71 90.82,87.03 90.82,84.9 90.26,84.34 90.26,78.8 90.52,78.54 v1(90.52,77.33) 90.52,75.19 91.01,74.7 91.91,74.7 92.57,75.36 RAP1075.1
+V3P3A_TPM: length 7.6
  TOP w0.203: v1(65.17,54.95) 64.91,54.95 64.79,54.82 RAP1424.1
  IN1 w0.508: v1(63.39,59.11) 63.39,58.3 63.85,57.84 63.85,55.71 64.61,54.95 v1(65.17,54.95)
  vias: v1(55.13,58.88) v1(56.53,55.48) v1(63.24,59.88)
+V3P3A_WIFI: length 10.5
  TOP w0.203: 188.23,19.85 188.23,17.48 R3491.1 189.96,17.02 190.64,16.34 190.64,15.3 190.11,14.77 v1(189.17,14.77) 188.23,14.77 188,15 187.12,15 187.01,14.89 R1144.2
  vias: v1(190.89,22.42) v1(191.5,22.44) v1(197.17,22.08) v1(197.2,21.42) v1(197.81,22.11) v1(197.81,21.42) v1(218.38,28.96) v1(218.69,28.4) v1(219.02,28.96) v1(219.35,28.38) v1(219.65,28.94)
+V3P3DSW_DOR: length 62.1
  TOP w0.254: v1(51.5,45.27) 53.31,45.27 53.46,45.42 56.42,45.42 56.55,45.3 62.55,45.3 64.53,47.28 64.87,47.28 65.23,47.63 66.08,47.63 66.9,46.82 66.9,43.21 67.58,42.53 67.58,41.13 68.47,40.24 70.68,40.24 71.72,39.2 71.72,38.31 70.66,37.24 70.66,36.36 71.06,35.95 73.78,35.95 74.13,36.3 75.15,36.3 76.01,35.44 v1(79.23,35.44) 82.45,35.44 RPM3337.1 ; v1(48.99,45.5) 48.79,45.5 47.77,44.48 45.99,44.48 45.59,44.89 45.59,45.68 45.2,46.06 44.54,46.06 43.65,46.95 43.43,46.95 43.17,47.2 41.93,47.2 40.78,48.34 40.78,48.83 40.63,48.98 40.63,50.35 41.14,50.86 R3620.1 40.88,51.08 R1002.1
  BOTTOM w0.254: v1(48.99,45.5) 49.04,45.45 49.14,45.45 49.47,45.12 51.35,45.12 v1(51.5,45.27)
+V3P3DSW_EC: length 68.1
  IN2 w0.762: v1(92.73,12.28) 90.43,12.28 84.08,18.63 77.26,18.63 71.21,24.67 71.21,26.32 68.32,29.22 65.12,29.22 59.25,35.09 55.39,35.09 47.87,42.6 47.87,46.26
  BOTTOM w0.762: 100.45,13.32 100.14,13.01 96.61,13.01 95.88,12.28 94.86,12.28
  vias: v1(29.18,45.97) v1(29.64,45.51) v1(32.05,54.95) v1(32.35,55.53) v1(36.44,54.39) v1(38.1,53.25) v1(38.17,45.17) v1(38.73,53.25) v1(45,45.55) v1(93.57,12.1)
+V3P3DX_EDP_FUSE:
  vias: v1(43.78,58.53)
+V3P3S: length 373.7
  TOP w0.254: v1(96.79,71.89) 97.01,72.1 RAP1432.1 ; v1(62.53,78.87) 62.53,78.25 PR103.1 ; v1(101.62,80.8) 101.19,80.37 100.88,80.37 100.25,79.73 100.25,78.14 99.67,77.56 v1(98.39,77.56)
  TOP w0.381: v1(49.81,61.76) 49.77,61.76 49.63,61.62 R346.1 49.63,59.63 49.42,59.42 49.42,58.12 48.38,57.09 v1(48.1,57.09)
  TOP w0.508: v1(136.95,29.75) 135.04,29.75 134.79,29.5 118.94,29.5 118.46,29.01 114.01,29.01 112.34,27.34 106.24,27.34 105.68,26.77 102.23,26.77 97.32,31.68 95.72,31.68 94.91,32.49 94.91,33.72 95.8,34.6 95.8,41.87 v1(95.95,42.02) ; v1(200.86,42.45) 200.86,43.8 194.68,49.98 194.68,57.87 191.56,60.99 191.56,64.27 189.37,66.45 186.99,66.45 185.06,68.38 v1(184.85,68.38) ; v1(83.38,52.97) 83.38,53.4 82.97,53.8 79.68,53.8 78.46,55.03 77.47,55.03 77.08,54.64 76.47,54.64 76.38,54.54 70.17,54.54 69.89,54.26 68.65,54.26 67.84,55.07 67.41,55.07 66.67,55.81 66.67,57.39 66.72,57.44 66.72,57.92 66.31,58.33 65.98,58.33 65.24,59.06 65.24,60.1 v1(65.37,60.23) ; RAP3046.2 90.9,88.09 v1(91.64,87.36)
  TOP w0.635: v1(65.37,60.23) 65.37,61.83 61.43,65.77 v1(61,65.77) 58.54,65.77 57.42,64.65 54.98,64.65 53.92,65.72 52.81,65.72 52.04,66.49 v1(50.21,66.49) 48.39,66.49 48.09,66.19 R338.1 47.64,65.82 v1(46.91,65.08)
  IN1 w0.254: v1(60.85,71.99) 60.85,75.01 61.69,75.85 61.69,78.04 v1(62.53,78.87)
  IN2 w0.203: v4(71.01,78.65) 71.5,79.14 73.34,79.14 73.93,79.74 73.93,81.92 74.13,82.13 74.13,82.56 73.76,82.93 73.01,82.93
  IN2 w0.254: v1(60.85,71.99) 60.85,70.86 60.22,70.23 60.22,66.55 v1(61,65.77) ; v1(62.53,78.87) 62.53,78.98 61.89,79.61 61.89,81.79 62.17,82.07 62.81,82.07 63.19,81.69 63.19,81.06 63.59,80.65 64.39,80.65 65.22,81.49 65.22,82.43 65.35,82.56 65.35,83.17 65.65,83.47 66.03,83.47 66.49,83.01 69.84,83.01 70.22,82.63 72.71,82.63 73.01,82.93 ; v1(94.2,76.79) 96.17,76.79 96.61,77.23 96.95,77.23 97.48,76.7 97.93,76.7 98.39,77.16 v1(98.39,77.56)
  IN2 w0.508: v1(100.53,41.77) 100.17,42.12 96.06,42.12 v1(95.95,42.02) 93.26,44.71 93.26,46.85 v1(93.03,47.07) ; v1(136.95,29.75) 136.97,29.73 137.36,29.73 137.87,29.22 151.07,29.22 152.8,27.49 158.92,27.49 159.48,26.93 168.14,26.93 170.15,28.94 175.15,28.94 175.61,28.48 187.07,28.48 188.44,29.85 190.31,29.85 191.99,28.18 200.14,28.18 200.45,27.87 v1(202.72,27.87) ; v1(94.2,76.79) 93.49,76.08 93.49,75.95 90.99,73.45 90.99,71.47 90.72,71.2 90.72,68.33 87.5,65.12 87.5,64.24 85.31,62.04 85.31,60.99 84.62,60.3 83.96,60.3 83.27,59.61 83.27,57.23 82.83,56.78 82.83,55.55 83.67,54.71 83.67,53.25 v1(83.38,52.97)
  BOTTOM w0.254: v4(71.01,78.65) 71.05,78.69 PU3254.G6 ; RAP1061.1 102.03,81.21 v1(101.62,80.8) ; v1(94.2,76.79) 94.2,76.28 96,74.48 96,74.33 96.97,73.37 96.97,72.07 v1(96.79,71.89) ; RAP1046.1 98.34,77.51 v1(98.39,77.56)
  BOTTOM w0.381: R5157.1 v1(48.1,57.09) ; v1(49.81,61.76) 49.81,62.18 v1(46.91,65.08)
  BOTTOM w0.508: v1(93.03,47.07) 93.03,47.13 92.27,47.89 R877.2 91.66,48.18 91.38,47.9 90.38,47.9 89.13,49.14 88.52,49.14 84.6,53.07 83.48,53.07 v1(83.38,52.97) ; v1(200.86,42.45) 201.7,41.61 201.7,39.87 202.44,39.13 202.44,38.93 207.06,34.32 207.06,32.21 v1(202.72,27.87) ; v1(91.64,87.36) 92.17,86.82 92.17,86.02 91.71,85.56 91.71,84.44 91.23,83.95 91.23,82.28 91.99,81.52 91.99,80.87 92.68,80.19 92.68,78.77 94.2,77.25 v1(94.2,76.79) ; v1(184.85,68.38) 184.57,68.11 R874.1 184.12,68.24 184.12,68.99 184.5,69.38 R873.1
  BOTTOM w0.635: v1(46.91,65.08) 46.12,64.3 44.39,64.3 v5(43.4,63.3) ; v1(65.37,60.23) 65.14,60 65.14,58.68 63.91,57.45 R958.1
  vias: v1(15.61,38.44) v1(16.12,38.87) v1(22.32,25.28) v1(23,25.28) v1(25.6,49.31) v1(25.54,48.5) v1(25.95,47.96) v1(26.08,48.85) v1(26.46,48.37) v1(36.49,58.73) v1(36.7,59.32) v1(37.13,58.73)
+V3P3S_AUDIO_VDDMIC: length 13.2
  TOP w0.254: C2M4.1 21.86,10.68 21.86,11.16 22.46,11.75 U1.3
  IN1 w0.635: 22.78,12 23.18,12.4 24.55,12.4 25.35,13.2 25.35,17.39 23.39,19.36 23.39,20.05
  vias: v1(21.81,22.13) v1(22.32,22.87) v1(23,22.92) v5(22.69,10.9)
+V3P3S_HDMI: length 19.1
  TOP w0.178: U26.30 21.1,40.88 20.73,40.5 20.73,39.76
  TOP w0.381: R682.1 21.22,39.14 ; R681.1 23.21,39.04 23.21,38.34 v1(22.01,37.14)
  BOTTOM w0.381: v1(20.41,37.4) 21.3,38.29 21.3,41.13 25.12,44.95 25.12,46.36 24.85,46.63 R5108.1 ; R5110.1 20.64,48.06 20.34,48.37 20.34,49.36
  vias: v1(18.25,50.33) v1(18.89,50.33) v1(20.41,36.79) v1(22.34,49.31)
+V3P3S_JD: length 2
  TOP w0.381: FB1C11.2 16.75,24.75 v1(15.97,24.75) 15.71,24.49 R2B2.2
+V3P3S_R:
  vias: v1(20.16,26.98)
+V3P3S_R955:
  vias: v1(25.6,52.69)
+V5_LDO: length 208.9
  TOP w0.203: v1(103.82,34.43) 103.82,34.84 103.54,35.12 PU12.1
  TOP w0.254: v1(74.59,82.28) 73.86,81.55 PC9113.1 73.38,81.55 73.09,81.26 73.09,80.76 v4(73.01,80.68)
  TOP w0.508: v1(67.04,72.19) 67.04,71.9 67.45,71.48 68.45,71.48 68.56,71.38 ; PR50.2 69.43,69.69 68.92,70.2 PC1321.2 68.56,70.75 68.56,71.38 ; 68.56,71.38 PR48.1
  TOP w0.762: 58.11,63.58 v1(55.16,63.58) 52.21,63.58 51.9,63.27 51.9,61.3 51.27,60.68 51.27,57.31 49.62,55.66 48.58,55.66 46.86,53.93
  IN1 w0.254: v1(74.59,82.28) 74.59,82.25 76.37,80.47 76.37,79.72 77.92,78.17 80.42,78.17 81.23,77.36 82.83,77.36 88.87,83.4 v1(88.87,84.01)
  IN1 w0.508: v1(89.83,85.76) 92.35,85.76 93.95,87.36 93.95,88.2 94.71,88.96 99.18,88.96 99.62,88.51 v1(100.93,88.51) 101.54,89.12 101.54,90.15 100.88,90.81 100.32,90.81 v1(99.31,91.83)
  IN1 w0.762: 76.14,61.27 75.84,60.97 70,60.97 69.59,60.56 66.9,60.56 66.26,61.2 64.76,61.2 64.47,61.49 62.16,61.49 v1(61.97,61.3) 61.51,61.3 59.89,62.92
  IN2 w0.508: v1(77.87,59.93) 77.39,59.44 77.39,58.02 78.22,57.18 78.22,55.61 78.73,55.11 v1(78.73,53.57) ; v1(103.82,34.43) 103.5,34.75 103.5,35.47 104.11,36.08 104.11,38.03 103.55,38.59 102.53,38.59 101.36,39.76 101.36,42.83 101.06,43.14 101.06,48.03 99.02,50.07 98.68,50.07 98.6,50.15 94.08,50.15 94.06,50.13 92.38,50.13 v1(92.26,50.25) ; v1(67.04,72.19) 66.46,71.62 66.46,68.87 63.14,65.55 63.14,62.47 v1(61.97,61.3)
  BOTTOM w0.203: v1(100.93,88.51) 101.25,88.51 102.1,87.66 102.1,87.38 101.96,87.25 PU13.1
  BOTTOM w0.254: v4(73.01,80.68) 72.97,80.64 PU3254.D3
  BOTTOM w0.508: v1(78.73,53.57) 78.73,53.56 79.06,53.22 81.7,53.22 82.16,53.68 84.65,53.68 85.08,54.11 89.17,54.11 89.96,53.32 89.96,51.29 90.52,50.73 91.78,50.73 v1(92.26,50.25) ; v1(89.83,85.76) 89.58,85.76 88.87,85.05 v1(88.87,84.01) 88.87,78.25 89.11,78.01 89.11,70.92 89.35,70.68 89.35,64.61 86.83,62.09 84.22,62.09 84.14,62.01 83.58,62.01 82.64,62.95 v1(80.89,62.95)
  BOTTOM w0.762: 25.49,53.58 26.5,52.57 28.61,52.57 30.6,50.58 30.6,46.97 31.42,46.15 37.01,46.15 37.61,46.74 37.61,48.27 38.14,48.8 42.29,48.8 43.29,49.8 43.29,50.98 44.77,52.46 44.77,52.76
  vias: v1(24.4,54.95) v1(24.43,54.34) v1(45.24,53.45) v1(45.53,53.98) v1(58.54,64.47) v1(58.98,63.95) v1(78.5,61.75)
+V5_LDO_T9: length 5.4
  TOP w0.254: PR50.1 70.21,69.84 v1(70.55,70.19) 70.55,70.62 v1(70.05,71.13)
  BOTTOM w0.279: v1(70.05,71.13) 70.1,71.18 70.1,74.06 PU3254.T9
+V5_LDO_T10: length 6.8
  TOP w0.254: PR51.1 64.74,72.64 v1(64.35,72.64)
  IN2 w0.254: v1(64.35,72.64) 64.34,72.64 64.34,72.63 65.58,72.63 66.66,73.71 69.42,73.71 v3(69.44,73.74)
  BOTTOM w0.254: PU3254.T10 69.47,73.81 69.44,73.78 v3(69.44,73.74)
+V5A: length 70.2
  TOP w0.178: PC307.1 207.87,23.92 PU51.4
  TOP w0.381: PC307.1 207.36,23.92 v1(207.36,24.29)
  IN1 w0.508: v1(171.61,38.63) 171.61,32.48 167.43,28.3 158.74,28.3 v1(157.47,29.57)
  IN2 w0.254: v1(78.83,74.18) 78.83,74 78.48,73.64 77.71,73.64 77.29,73.22 74.35,73.22 73.97,73.61 72.63,73.61 72.59,73.65 71.11,73.65 v3(71.03,73.73)
  IN2 w0.508: v1(193.37,40.96) 193.37,40.49 194.48,39.38 198.85,39.38 199.84,38.39 v1(199.84,36.53) 200.4,36.53 200.68,36.25 200.68,34.94 201.16,34.45 201.16,30.74 203.6,28.3 v1(203.6,27.36)
  BOTTOM w0.254: v1(78.83,74.18) 79.28,74.62 84.26,74.62 84.76,75.13 84.76,82.37 83.74,83.4
  BOTTOM w0.381: v3(71.03,73.73) 71.03,73.73 71.03,74.13 PU3254.T7
  vias: v1(21.79,58.33) v1(22.34,51.49) v1(22.42,58.35) v1(23,51.49) v1(24.55,26.68) v1(27.17,57.44) v1(27.18,56.83) v1(28.8,14.51) v1(29.43,14.51) v1(30.45,29.01) v1(30.64,33.43) v1(30.66,32.79) v1(31.27,33.42) v1(31.27,32.8) v1(31.59,26.82) v1(31.95,27.36) v1(33.93,64.78) v1(34.31,64.27) v1(34.69,64.78) v1(35.07,64.27) v1(35.45,64.78) v1(35.83,64.27) v1(36.21,64.78) v1(36.59,64.27) v1(36.92,65.69) v1(37.3,65.18) v1(37.81,65.69) v1(38.32,65.18) v1(38.83,65.69) v1(117.06,12.23) v1(117.06,11.59) v1(117.06,10.96) v1(117.06,10.32) v1(117.06,9.69) v1(177,19.21) v1(177.26,18.58) v1(177.64,19.21) v1(178.02,18.58) v1(178.27,19.21) v1(182.52,24.87) v1(183.13,24.87) v1(183.74,24.87) v1(203.17,18.99) v1(203.12,18.33) v1(203.78,18.33) v1(203.83,18.96) v1(204.21,24.52) v1(204.59,11.24) v1(204.87,24.52) v1(205.28,11.23) v1(205.5,24.52) v1(205.96,11.23) v1(206.14,24.54) v1(209.42,24.34) v1(210.05,24.34) v1(210.66,24.37) v1(211.29,24.37) v1(211.96,24.37) v1(212.62,24.34) v5(79.25,84.89) v5(79.85,84.17) v5(80.39,84.87) v5(80.94,84.16) v5(81.48,84.87) v5(81.98,84.12) v5(82.42,84.87) v5(82.98,84.11)
+V5A_AUDIO_SPKVDD_L: length 8.2
  TOP w0.508: v1(34.1,24.93) 34.1,24.45 R1B28.2
  BOTTOM w0.508: v1(30.45,18.96) 31.46,19.97 31.46,21.32 v1(32.78,22.64) 34.1,23.96 v1(34.1,24.93)
+V5A_AUDIO_SPKVDD_R: length 1.9
  TOP w0.381: v1(38.37,26.25) 39.06,26.25 39.57,25.74 R1B27.2
  vias: v1(34.51,26.2) v1(34.51,25.56) v1(35.15,16.92) v1(35.7,17.2)
+V5A_GND: length 15.5
  TOP w0.102: v1(76.52,85.78) 76.57,85.84 PR29.1
  IN2 w0.079: v4(72.49,77.13) 72.68,77.33 73.78,77.33 74,77.54 75.23,77.54 76.72,79.04 76.72,80.73 75.46,82 75.46,82.96 76.41,83.92 76.84,83.92 77.23,84.31 77.23,85.07 v1(76.52,85.78)
  BOTTOM w0.152: v4(72.49,77.13) 71.97,77.64 PU3254.H5
+V5A_USBC:
  vias: v1(19.47,57.77)
+V5S_FAN: length 49.8
  BOTTOM w0.381: v1(207.13,30.69) 207.13,31.4 207.61,31.88 207.61,34.54 202.99,39.16 202.99,39.36 202.25,40.1 202.25,46.42 200.69,47.97 200.69,51.27 196.85,55.12 196.85,57.86 193.01,61.7 193.01,63.94 187.39,69.56 187.39,70.62 186.9,71.12 R3534.1
+V5S_FAN_C: length 14.1
  BOTTOM w0.381: R872.1 180.26,68.11 v1(179.94,68.42) 179.62,68.74 179.62,72.07 180.13,72.58 184.65,72.58 185.13,72.09 185.13,70.34 185.74,69.73
+V5S_HDMI: length 193.6
  TOP w1.016: 112.13,9.63 v1(111.85,9.92) 111.57,10.2 110.21,10.2 109.49,9.48 97.69,9.48 88.78,18.4 86.6,18.4 82.92,22.07 79.23,22.07 77.54,23.76 71.24,23.76 69.34,25.66 58.22,25.66 54.96,28.93 54.96,29.29 49.87,34.37 45.33,34.37 44.26,35.44
  IN1 w1.016: 210.08,28.81 209.4,28.13 206.37,28.13 204.72,26.47 189.63,26.47 186.83,23.68 181.93,23.68 180.92,24.7 169.21,24.7 167.99,23.48 152.65,23.48 151.58,24.54 149.03,24.54 148.65,24.16 137.56,24.16 136.06,25.66 125.72,25.66 119.78,19.72 117.29,19.72 114.42,16.85 113.33,16.85 ; 41.37,36.18 33.72,36.18 33.24,36.66 32.05,36.66
  vias: v1(23.69,47.48) v1(24.3,47.51) v1(42.38,35.69) v1(42.97,35.42) v1(113.02,9.74) v1(113.63,9.74) v1(211.07,29.24) v1(211.68,29.24)
+V5S_HDMI_C: length 8.8
  BOTTOM w0.508: D41.2 16.48,45.6 17.21,46.34 19.37,46.34 v1(19.78,46.74) 20.19,47.15 22.26,47.15 R5018.1
+VBATA: length 74.9
  TOP w0.508: 76.81,79.87 76.14,79.2 v1(76.01,79.2) ; EC2.1 170.92,26.57 v1(170.4,27.08)
  TOP w0.762: 64.87,66.07 v1(64,66.07) 63.14,66.07 62.3,66.91 58.03,66.91 57.01,65.9 55.34,65.9 54.38,66.85 53.22,66.85 52.34,67.72 45.26,67.72 41.47,63.94 39.73,63.94 38.72,62.92 37.3,62.92 36.39,62.01 35.53,62.01
  IN1 w0.508: v1(199.92,35.82) 200.5,35.24 200.5,32.09 199,30.59 195.47,30.59 193.9,32.16 186.28,32.16 184.26,34.18 v5(179.39,34.18)
  IN2 w0.381: 74.74,78.75 73.68,77.68 71.97,77.68 v4(71.44,78.22)
  BOTTOM w0.178: PR1.1 57.22,23.21 57.05,23.37 55.18,23.37 PR127.2
  BOTTOM w0.203: PU4.3 50.58,23.78 50.66,23.7 50.66,21.13
  BOTTOM w0.254: v4(71.44,78.22) 71.41,78.19 PU3254.H7
  BOTTOM w0.508: EC2.1 170.92,26.57 v1(170.4,27.08)
  vias: v1(57.57,32.75) v1(58.18,32.72) v1(65.93,64.96) v1(65.93,64.3) v1(66.54,64.93) v1(66.54,64.3) v1(67.15,65.54) v1(67.15,64.93) v1(67.15,64.27) v1(67.76,65.54) v1(67.76,64.93) v1(67.76,64.27) v1(68.39,65.54) v1(68.39,64.93) v1(68.39,64.27) v1(69,64.9) v1(69,64.27) v1(84.04,71.81) v1(84.04,71.2) v5(53.05,21.37) v5(53.43,20.61) v5(53.81,21.37) v5(54.2,20.61) v5(54.58,21.37) v5(55.08,20.61) v5(55.34,21.37) v5(55.85,20.61) v5(57.68,72.88) v5(57.7,72.07) v5(58.26,71.36) v5(58.46,72.91) v5(58.49,72.12) v5(59.23,72.93) v5(59.23,72.12) v5(60.77,96.55) v5(61.16,95.92) v5(61.54,96.55) v5(61.92,95.92) v5(62.3,96.55) v5(71.44,88.93) v5(72.18,88.93) v5(77.56,80.98) v5(77.56,80.22) v5(175.73,33.53) v5(176.17,34.18) v5(176.54,33.52) v5(176.98,34.17) v5(177.34,33.53) v5(177.78,34.18) v5(178.13,33.52) v5(178.57,34.17) v5(178.95,33.53)
+VBATA_C:
  vias: v1(33.62,58.96) v1(33.88,59.6) v1(34.26,58.96) v1(34.51,59.6)
+VBATA_T8: length 12.3
  TOP w0.254: PR52.2 67.84,67.09 PC1190.1 67.79,67.14 PC1191.1 v1(68.6,68.11) 68.93,68.44 68.93,69.3 v1(68.72,69.5)
  BOTTOM w0.203: PU3254.R10 69.97,74.69 PU3254.T8
  BOTTOM w0.254: PU3254.T8 70.55,74.1 70.55,70.39 69.66,69.5 v1(68.72,69.5)
+VBATT: length 11.3
  IN2 w0.254: v1(53.15,24.28) 54.53,22.9 v1(62.27,22.9)
  BOTTOM w0.203: PU4.31 52.25,25.17 52.61,24.81 52.63,24.81 v1(53.15,24.28)
  vias: v1(62.92,22.9)
+VCC19P2_1P0: length 5.9
  TOP w0.508: RPM3293.1 108.55,42.36 v3(111.19,45.01)
  BOTTOM w0.152: v3(111.19,45.01) 111.31,45.12 111.31,46.09 U80.A14
+VCC24TBT_1P0: length 6.7
  BOTTOM w0.203: U80.A10 108.84,45.32
  BOTTOM w0.254: 108.84,45.32 108.84,43.94 108.54,43.63 108.54,42.67 v1(107.87,41.99) 107.82,41.94 CAP1297.1
  BOTTOM w0.508: RPM3298.1 107.54,41.25 107.04,41.76 CAP1297.1
+VCCAMPHYPLL_1P0: length 14.6
  IN2 w0.254: v3(111.3,51.64) 111.04,51.38 111.04,50.7 110.42,50.07 110.19,50.07 109.87,49.74 109.87,47.32 109.8,47.25
  IN2 w0.508: v1(108.15,39.63) 108.15,40.83 109.8,42.48 109.8,47.25
  BOTTOM w0.254: U80.L15 111.3,51.72 v3(111.3,51.64) 111.3,51.56 U80.K15
+VCCAMPHYPLL_1P0_R:
  vias: v1(103.98,33.71)
+VCCAPLL_1P0: length 25
  TOP w0.508: v1(91.58,52.48) 91.3,52.2 RPM3288.1
  IN2 w0.254: 106.1,53.54 106.22,53.65 109.37,53.65 109.46,53.74 110.53,53.74 111.36,54.57 v3(111.36,54.99)
  IN2 w0.508: 106.1,53.54 104.99,52.42 102.98,52.42 101.59,53.82 99.29,53.82 98.95,53.47 98.6,53.47 98.36,53.24 96.91,53.24 95.89,52.22 93.79,52.22 93.52,52.48 v1(91.58,52.48)
  BOTTOM w0.254: v3(111.36,54.99) 111.36,55.12 U80.V15
  BOTTOM w0.508: CAP1255.2 91.67,52.57 v1(91.58,52.48)
+VCCAPLLEBB_1P0: length 20.8
  TOP w0.508: v1(106.64,43.16) CAP1271.1 RPM3291.1
  IN2 w0.254: v3(113.93,53.36) 113.93,53.17 113.65,52.9 111.71,52.9 111.2,52.38 111.2,52.21 110.43,51.44 107.39,51.44 106.99,51.05 106.99,49.2 106.64,48.85
  IN2 w0.508: 106.64,48.85 106.42,48.85 105.48,47.91 105.48,46.44 106.8,45.12 106.8,44.6 106.64,44.44 v1(106.64,43.16)
  BOTTOM w0.254: U80.N18 113.6,53.03 v3(113.93,53.36)
+VCCATS: length 68.6
  TOP w0.508: v1(89.44,58.45) 89.46,58.45 89.48,58.43 92.73,58.43 93.03,58.12 RPM3305.1 94.93,57.71 95.07,57.57 v1(96.28,57.57) 96.36,57.64 98.25,57.64 98.32,57.57 99.33,57.57 100.02,56.87 100.73,56.87 100.88,56.73 v3(100.88,56.73) ; PR86.1 53.46,49.31 54.03,49.88 54.03,53.5 53.1,54.43 53.1,59.88 53.9,60.68 54.72,60.68 56.25,62.21 v1(56.48,62.21)
  BOTTOM w0.305: v3(100.88,56.73) 101.29,56.32 103.12,56.32 103.38,56.59 U80.AA1
  BOTTOM w0.508: v1(89.44,58.45) 89.44,58.46 88.79,59.11 87.06,59.11 85.9,57.95 84.08,57.95 80.79,61.25 80.19,61.25 79.85,61.58 79.37,61.58 78.93,61.14 78.24,61.14 77.86,61.53 77.31,61.53 76.32,62.52 61,62.52 60.69,62.21 v1(56.48,62.21) ; v3(100.88,56.73) 100.88,56.73 100.68,56.93 CAP1311.1
+VCCCORE: length 117.7
  TOP w0.203: PR34.2 189.59,34.35 v1(189.22,33.97)
  IN2 w0.152: v1(160.66,38.04) 160.88,37.82 160.88,35.85 161.57,35.16 163.13,35.16 164.92,33.36 172.5,33.36 174.65,35.52 183.56,35.52 185.11,33.97 v1(189.22,33.97)
  IN2 w0.203: v1(189.16,37.52) 188.77,37.14 186.32,37.14 185.62,37.83 175.28,37.83 170.03,43.09 158.87,43.09 152.85,37.07 148.68,37.07
  BOTTOM w0.127: 122.64,60.83 U80.AK33 ; U80.AK33 122.36,61.1 ; U80.AK33 122.64,61.38 ; 123.83,62.04 U80.AM35 ; U80.AM35 123.55,62.32 ; U80.AM35 123.55,61.76 ; U80.AM35 123.27,62.04 ; 121.72,61.74 U80.AM32 121.72,62.35 ; 124.47,60.83 U80.AK37 ; U80.AK37 124.47,61.38 ; U80.AK37 124.19,61.1 ; 124.92,50.55 U80.J37 ; U80.J37 124.92,49.99 ; U80.J37 124.64,50.27 ; U80.J37 125.2,50.27 ; 122.18,61.85 U80.AL33 ; U80.AL33 121.9,61.57 ; U80.AL33 122.46,61.57 ; U80.AL33 122.18,61.29 ; U80.AK35 123.55,61.38 ; U80.AK35 123.83,61.1 ; U80.AK35 123.55,60.83 ; 126.3,50.45 U80.K40 ; U80.K40 126.3,51.01 ; U80.K40 126.57,50.73 ; U80.K38 125.38,51.01 ; U80.K38 125.1,50.73 ; U80.K38 125.38,50.45 ; 124.01,61.29 U80.AL37 ; U80.AL37 123.73,61.57 ; U80.AL37 124.29,61.57 ; U80.AL37 124.01,61.85 ; 122.64,61.76 U80.AM33 ; U80.AM33 122.92,62.04 ; U80.AM33 122.36,62.04 ; U80.AM33 122.64,62.32 ; 125.38,60.83 U80.AK38 ; U80.AK38 125.38,61.38 ; U80.AK38 125.66,61.1 ; 125.1,62.04 U80.AM38 ; U80.AM38 125.38,61.76 ; U80.AM38 125.38,62.32 ; U80.AM38 125.66,62.04 ; U80.G35 123.39,49.71 v3(123.1,49.55) U80.G33 ; U80.G35 123.27,49.8 ; U80.G35 123.55,49.92 123.56,50.21 ; U80.G35 123.55,50.08 ; 123.55,51.01 U80.K35 ; U80.K35 123.55,50.45 ; U80.K35 123.27,50.73 ; v3(121.27,49.55) U80.G32 121.72,50.08 ; 126.3,60.83 U80.AK40 ; U80.AK40 126.02,61.1 ; U80.AK40 126.57,61.1 ; U80.AK40 126.3,61.38 ; U80.G37 124.47,49.6 124.57,49.5 ; U80.G37 124.47,50.08 ; U80.G37 124.75,49.8 ; U80.J30 121.55,50.27 ; U80.J30 121.27,49.99 ; U80.J30 121.27,50.55 ; 124.19,62.04 U80.AM37 ; U80.AM37 124.47,62.32 ; U80.AM37 124.47,61.76 ; U80.AM37 124.75,62.04 ; U80.K37 124.75,50.73 ; U80.K37 124.47,51.01 ; U80.K37 124.47,50.45 ; 122.82,50.27 U80.J33 ; U80.J33 123.1,50.55 ; U80.J33 123.1,49.99 ; U80.J33 123.37,50.27 ; U80.AL40 125.56,61.57 ; U80.AL40 125.84,61.85 ; U80.AL40 125.84,61.29 ; U80.AL40 126.12,61.57 ; 126.75,50.55 U80.J40 ; U80.J40 127.03,50.27 ; U80.J40 126.47,50.27 ; U80.J40 126.75,49.99 ; 127.21,51.01 U80.K42 ; U80.K42 127.21,50.45 ; U80.K42 126.75,50.96 ; v3(128.13,51.29) 128.12,51.28 U80.K43 ; 122.64,50.08 U80.G33 ; U80.G33 122.76,49.92 122.86,50.02 ; U80.K33 122.92,50.73 ; U80.K33 122.64,51.01 ; U80.K33 122.64,50.45 ; 124.96,49.57 U80.G38
  BOTTOM w0.152: 127.21,50.14 U80.G42 127.01,49.8 126.75,49.55 v3(126.73,49.55) 126.57,49.55 126.32,49.8 U80.G40 126.3,50.15 ; U80.G38 125.38,50.16
  BOTTOM w0.203: v3(121.27,49.55) U80.G30 ; v3(121.23,45.54) U80.A30 ; v3(128.48,45.65) 128.48,45.91 U80.A44 ; v3(123.71,45.53) U80.A34 ; U80.A39 126.06,45.98 126.06,45.67 v3(125.94,45.54)
  BOTTOM w0.254: 158.52,38.04 v1(160.66,38.04)
  BOTTOM w0.305: CAP1446.1 125.21,43.09 125.43,43.31 125.43,44.6 125.57,44.74 125.57,45.18 v3(125.94,45.54)
  vias: v1(125.05,56.01) v3(121.01,51.54) v3(121.27,51.04) v3(121.29,44.85) v3(121.29,44.29) v3(121.29,43.73) v3(121.57,51.54) v3(122.04,54.97) v3(122.18,60.88) v3(122.32,58.17) v3(122.63,60.53) v3(123.1,62.44) v3(123.22,51.74) v3(123.22,51.16) v3(123.46,53.58) v3(123.57,60.51) v3(124.01,62.44) v3(124.01,60.88) v3(124.16,58.03) v3(124.46,60.53) v3(124.9,51.11) v3(124.9,49.4) v3(124.92,62.44) v3(124.92,51.69) v3(125.04,55.39) v3(125.28,58.07) v3(125.38,60.53) v3(125.84,60.88) v3(126.76,52.2) v3(126.73,51.54) v3(126.92,56.73) v3(127.13,55.5) v5(128.72,34.12) v5(129.18,34.7) v5(129.63,34.07) v5(129.74,35.26) v5(130.18,34.58) v5(130.32,33.88) v5(130.65,35.21) v5(130.9,34.55) v5(131.16,35.85) v5(131.41,35.09) v5(131.82,36.2) v5(132.1,35.52) v5(132.68,36.1) v5(135.5,33.94) v5(136.06,34.42) v5(136.59,35.01) v5(137.13,35.57) v5(141.32,36.1) v5(141.32,35.34) v5(141.32,34.45) v5(142.08,36.1) v5(142.08,35.34) v5(142.21,34.45) v5(142.84,36.1) v5(142.84,35.34) v5(142.97,34.45) v5(143.6,36.1) v5(143.6,35.34) v5(143.73,34.45) v5(144.37,36.1) v5(144.37,35.34) v5(144.49,34.45) v5(145.13,36.1) v5(145.25,35.34) v5(145.25,34.45) v5(146.02,36.1) v5(146.02,35.34)
+VCCDSW_1P0: length 4.9
  BOTTOM w0.203: U80.AL1 102.24,61.89
  BOTTOM w0.254: CAP1267.1 100.17,60.36 v1(100.55,60.36) 100.71,60.36 102.24,61.89
+VCCDTS_1P0: length 16.1
  TOP w0.254: RPM3292.1 91.5,57.21 94.37,57.21 v1(94.56,57.02)
  BOTTOM w0.178: U80.T1 103.47,54.3 102.54,54.3 101.62,55.23 99.08,55.23 98.93,55.07
  BOTTOM w0.254: 98.93,55.07 98.47,54.62 96.77,54.62 96.53,54.38 v1(96.17,54.38) 95.88,54.67 95.17,54.67 94.89,54.95 94.89,56.44 94.56,56.76 v1(94.56,57.02)
+VCCDUSB_1P0: length 27.5
  TOP w0.381: v3(113.27,55.83) v1(113.27,56.66) 113.27,56.91 112.93,57.25 111.15,57.25 110.79,56.89 110.17,56.89 109.76,57.3 109.76,57.55 109.38,57.93 108.75,57.93 108.75,57.94 108.31,57.94 108.31,57.93 108.12,57.93 108.11,57.94 107.68,57.94 107.67,57.93 107.53,57.93 107.52,57.94 107.09,57.94 107.08,57.93 104.67,57.93 103.07,56.33 101.91,56.33 101.72,56.14 99.61,56.14 99.47,56.28 98.76,56.28 98.75,56.29 98.75,56.29 97.95,57.09 96.58,57.09 96.51,57.02 95.97,57.02 95.42,56.46 94.27,56.46 93.95,56.79 92.79,56.79 92.47,56.47 RPM3282.1
  BOTTOM w0.203: U80.AB17 113.6,56.44 U80.Y18 113.27,55.92 v3(113.27,55.83)
+VCCF24NS_1P0: length 46.9
  IN2 w0.254: v1(125.82,41.69) 125.61,41.69 124.18,43.11 124.18,48.04 123.55,48.67 123.55,49.74 122.81,50.48 121.91,50.48 121.84,50.55 117.4,50.55 117.17,50.78 117.17,51.51 116.59,52.1 115.29,52.1 114.9,52.48 v1(114.57,52.48) 113.94,52.48 113.81,52.35 112.62,52.35 112.02,51.74 112.02,51.36 111.67,51.01 111.67,50 111.67,49.18 111.67,49.18 111.67,48.8 111.67,48.8 111.67,48.65 112.03,48.28 112.03,46.87 111.83,46.67 111.83,45.8
  IN2 w0.508: v1(112.62,39.04) 113.04,39.47 113.04,41.9 111.83,43.11 111.83,45.8
  BOTTOM w0.254: U80.L19 114.25,52.16 v1(114.57,52.48) ; v1(125.82,41.69) 125.98,41.54 125.98,41.44 126.02,41.39 RAP1091.2
  BOTTOM w0.508: RPM3297.1 108.43,33.32 CAP1306.2 109.49,34.39 110.77,34.39 v1(111.47,35.09) 112.17,35.79 112.17,38.6 v1(112.62,39.04)
+VCCF100_1P0: length 38.7
  TOP w0.254: v3(113.96,51.7) 114.08,51.7 114.38,51.39 114.38,47.17 113.17,45.96 110.66,45.96 110.13,45.42 109.64,45.42
  TOP w0.508: 109.64,45.42 103.27,45.42 99.79,41.94 99.79,40.98 v1(100.16,40.61)
  IN1 w0.508: v1(101.36,32.49) 102.38,33.51 102.38,35.77 103.24,36.63 v1(103.24,37.24)
  IN2 w0.508: v1(103.24,37.24) 102.99,37.24 100.16,40.08 v1(100.16,40.61)
  BOTTOM w0.254: U80.K19 114.25,51.42 v3(113.96,51.7)
  BOTTOM w0.508: CAP1321.2 99.7,34.36 100.73,33.33 101.93,33.33 RPM3294.1 101.96,32.81 101.64,32.49 v1(101.36,32.49)
+VCCF100OC_1P0: length 30.7
  TOP w0.254: 109.57,44.61 109.99,44.61 110.89,45.51 113.57,45.51 115.32,47.26 115.32,50.29 114.96,50.66 v1(114.96,50.95) 114.96,51.23 114.73,51.46 114.73,51.87 115.07,52.21 115.07,53.21 v3(115.22,53.37)
  TOP w0.508: 109.57,44.61 107.08,44.61 106.03,43.56 106.03,40.1 v1(105.28,39.35)
  BOTTOM w0.254: v3(115.22,53.37) 115.22,53.22 U80.N20
  BOTTOM w0.508: RPM3296.1 102.93,33.48 CAP1312.2 102.93,35.31 103.88,36.26 103.88,38.54 104.36,39.02 104.97,39.02 105.28,39.33 v1(105.28,39.35)
+VCCF135_1P0: length 15.4
  TOP w0.508: v1(112.67,43.16) 110.91,43.16 109.57,41.82 RPM3295.1
  IN2 w0.254: v3(115.21,51.63) 114.6,51.63 114.13,51.15 113.22,51.15 112.71,50.63 112.71,48.63 112.39,48.31 112.39,47.93 112.39,47.93 112.39,43.44 v1(112.67,43.16)
  BOTTOM w0.254: U80.L21 115.21,51.72 v3(115.21,51.63)
+VCCFHV: length 13.5
  TOP w0.508: v1(93.24,61.83) 92.83,61.83 v1(92.27,61.27) 91.74,61.27 RPM3290.1
  IN1 w0.203: v1(107.55,63.11) 108.11,62.56 108.62,62.56 109.23,61.95 110.6,61.95 110.82,62.17 111.37,62.17 111.66,61.88 111.66,61.62 111.91,61.37 112.15,61.37 113.09,60.43 113.45,60.43 114.31,61.29 115.25,61.29 v3(115.78,61.82)
  BOTTOM w0.203: U80.AK20 114.98,61.28 115.37,61.67 115.63,61.67 v3(115.78,61.82)
+VCCGT: length 109.6
  IN1 w0.508: v3(133.76,45.61) 131.66,45.61 v3(131.15,45.1)
  IN2 w0.203: 174.34,52.66 179.67,52.66 181.5,54.49 190.15,54.49 193.72,50.92 193.72,46.69 194.53,45.88 197.49,45.88 v1(198.81,44.56) ; v1(180.62,49.86) 180.74,49.99 180.74,53.12 181.74,54.12 189.86,54.12 193.24,50.75 193.24,46.16 v1(194.15,45.24) ; v1(182.12,49.84) 181.91,50.05 181.91,52.65 182.13,52.87 189.41,52.87 192.02,50.26 192.02,45.53 v1(191.59,45.1)
  BOTTOM w0.127: U80.J52 133.15,50.57 ; U80.J52 133.45,50.27 ; U80.J52 132.86,50.27 ; 129.5,50.57 U80.J45 ; U80.J45 129.8,50.26 ; U80.J45 129.8,50.27 ; U80.J45 129.5,49.96 ; U80.J45 129.49,50.56 ; U80.J45 129.2,50.27 ; U80.J53 133.76,50.27 ; U80.J53 134.07,50.57 ; U80.J53 134.37,50.27 ; U80.J53 133.76,50.26 ; U80.J53 134.44,50.28 ; U80.J53 134.06,50.57 ; U80.J50 131.9,50.27 ; U80.J50 132.24,50.57 ; U80.J50 132.23,50.57 ; U80.J50 132.54,50.27 ; 130.41,50.59 U80.J46 ; U80.J46 130.06,50.26 ; U80.J46 130.79,50.27 ; U80.J46 130.41,50.57 ; U80.J46 130.1,50.27 ; U80.J48 131.32,49.96 ; U80.J48 131.02,50.27 ; U80.J48 131.32,50.56 ; U80.J48 131.32,50.57 ; U80.J48 131.66,50.27 ; U80.J48 131.03,50.28 ; 134.98,50.59 U80.J55 ; U80.J55 135.31,50.27 ; U80.J55 134.98,50.57 ; U80.J55 134.67,50.27 ; U80.J43 128.87,50.38 ; U80.J43 128.58,50.59 ; U80.J43 128.83,50.08
  BOTTOM w0.152: v3(131.15,45.1) U80.A48
  BOTTOM w0.203: PL5.2 177.29,50.37 177.8,49.86 v1(180.62,49.86) ; U80.A66 141.06,45.12 v3(141.08,45.1) ; v1(182.12,49.84) 182.3,49.84 182.33,49.81 185.02,49.81 185.36,50.14 PL6.2 ; v3(136.1,45.1) U80.A58 ; U80.A53 133.62,46.1 133.73,46 133.73,45.65 v3(133.76,45.61) ; v1(191.59,45.1) 191.25,44.76 PR85.1 PR95.1 ; U80.A62 138.58,45.17 v3(138.71,45.04) ; v1(194.15,45.24) 194.56,44.83 PR91.1 195.95,44.83 PR94.1
  vias: v1(129.88,55.54) v1(130.01,59.27) v1(130.12,51.7) v1(130.51,55.55) v1(131.2,55.53) v1(131.62,59.27) v1(131.9,55.52) v1(132.6,55.53) v1(133.29,59.27) v1(133.28,55.52) v1(134.01,55.55) v1(134.64,55.52) v1(134.89,59.27) v1(136.11,58.96) v1(137.36,59.09) v1(137.52,55.24) v1(137.97,59.06) v1(141.23,56.21) v3(130.41,51.01) v3(131.22,52.02) v3(131.32,51.01) v3(131.78,52.02) v3(133.15,51.01) v3(133.15,48.9) v3(133.56,51.97) v3(134.07,51.01) v3(134.12,51.98) v3(134.98,51.01) v3(135.44,51.98) v3(135.71,55.43) v3(135.9,51.01) v3(136.42,55.35) v3(136.48,51.99) v3(136.81,51.01) v3(137.25,52.23) v3(137.7,51.01) v3(138.02,52.23) v3(139.27,54.21) v3(139.89,56.08) v3(139.92,55.13) v3(140.57,56.06) v3(140.57,54.21) v3(140.59,52.35) v3(141.22,56.96) v3(141.22,53.28) v3(141.87,56.06) v3(141.87,55.13) v3(141.87,54.21) v3(141.87,52.35) v3(142.5,57.03) v3(142.52,53.28) v3(143.17,56.06) v3(143.17,54.21) v3(143.77,55.12) v3(143.82,56.96) v3(143.82,53.39) v5(146.65,54.77) v5(146.65,52.99) v5(147.54,54.01) v5(147.67,55.66) v5(148.56,54.77) v5(148.56,52.99) v5(149.45,55.66) v5(149.45,54.01) v5(150.46,54.77) v5(150.46,52.99) v5(151.35,55.66) v5(151.35,54.01) v5(152.37,54.64) v5(152.37,52.99) v5(154.4,54.01) v5(154.91,53.12) v5(155.41,54.01) v5(155.54,52.23) v5(156.05,53.12) v5(156.56,54.01) v5(156.68,52.23) v5(157.19,53.12) v5(157.7,54.01) v5(157.7,52.23) v5(158.34,53.12) v5(159.1,53.88) v5(159.99,53.88) v5(161,53.88) v5(162.15,53.88) v5(163.16,52.99) v5(163.16,52.1) v5(163.16,51.21) v5(163.16,50.33) v5(163.92,53.88) v5(165.07,53.88) v5(166.21,53.88) v5(167.35,53.88) v5(169.64,51.09) v5(170.02,49.56) v5(170.65,52.1) v5(171.04,50.58) v5(171.8,53.12) v5(172.05,51.6) v5(172.81,54.14) v5(173.07,52.61)
+VCCMPHYAON_1P0: length 37.9
  TOP w0.254: 109.73,46.03 110.09,46.03 110.43,46.38 112.26,46.38 114.03,48.14 114.03,50.99 113.41,51.61 v3(113.29,51.61)
  TOP w0.508: RPM3285.1 100.28,39.41 v1(99.65,40.04) 99.55,40.14 99.55,40.35 99.18,40.72 99.18,42.2 101.29,44.31 101.29,45.6 101.72,46.03 v1(101.73,46.03) 109.73,46.03
  IN1 w0.508: v1(101.73,46.03) 101.73,49.22 103.04,50.53 v3(103.04,50.73)
  BOTTOM w0.203: CAP1262.1 100.32,51.18 103.74,51.18 U80.L1
  BOTTOM w0.254: v3(103.04,50.73) 102.97,50.8 100.67,50.8 CAP1262.1 ; v3(113.29,51.61) 112.94,51.26 U80.K17
+VCCMPHYGTAON_1P0:
  vias: v1(93.03,51.19) v3(111.96,53.37) v3(111.97,52.43) v3(112.61,53.37)
+VCCPAZIO: length 111.7
  TOP w0.254: RPM3309.1 RPM3310.2 98.79,84.43 v1(99.17,84.43) 99.17,83.99 100.04,83.12 100.83,83.12 101.03,83.32 101.49,83.32 102.22,82.59 102.22,82.35 103.51,81.06 107.8,81.06 108.42,80.44 110.01,78.84 111.41,78.84 113.65,76.6 113.65,72.74 114.28,72.11 CAP1268.1
  TOP w0.381: PR87.1 52.81,53.09 51.95,53.95 51.95,60.4 52.57,61.02 52.57,62.75 v1(52.65,62.82)
  IN1 w0.381: v1(89.83,85.15) 94.76,85.15 96.06,86.44 97.53,86.44 99.17,84.8 v1(99.17,84.43)
  BOTTOM w0.254: v3(114.57,60.86) 114.57,60.76 U80.AJ19
  BOTTOM w0.381: v1(89.83,85.15) 89.45,84.77 89.45,78.44 89.65,78.24 89.65,71.15 89.9,70.91 89.9,64.38 85.99,60.47 83.9,60.47 83.57,60.8 83.57,61.25 82.42,62.4 80.66,62.4 79.7,63.37 78.73,63.37 78.43,63.68 60.52,63.68 60.24,63.39 53.22,63.39 v1(52.65,62.82) ; v1(99.17,84.43) 99.14,84.4 99.14,83.66 Q105.1
+VCCPDSW_3P3: length 4.2
  IN2 w0.508: v3(113.27,60.86) 113.26,60.85 v3(113.26,58.34)
  BOTTOM w0.254: U80.AD18 113.6,58.01 v3(113.26,58.34) 112.94,58.03 U80.AD17 ; v3(113.27,60.86) U80.AJ17
  vias: v1(104.13,71.97)
+VCCPGPPA: length 20.2
  TOP w0.254: v3(111.13,61.74) 110.35,61.74 109.85,62.23 109.85,62.77 109.88,62.8 109.88,62.84 109.9,62.86 109.9,62.96 109.91,62.97 109.91,63.23 109.85,63.3 109.85,64.4 109.44,64.8
  TOP w0.381: RPM3326.1 99.19,73.07 99.19,70.98 99.71,70.46 99.89,70.46 104.28,66.07 107.13,66.07 107.26,66.2 108.04,66.2 109.44,64.8
  BOTTOM w0.254: U80.AK15 111.43,61.49 111.38,61.49 v3(111.13,61.74)
+VCCPGPPB: length 29.6
  IN2 w0.254: v1(94.2,72.75) 94.61,72.35 95.12,72.35 95.22,72.45 95.52,72.45 96.08,73.01 97.38,73.01 97.57,72.82 99.29,72.82 99.46,72.98 100.51,72.98 101.43,72.07 102.77,72.07 103.12,71.72 104.64,71.72 107.49,68.87 107.69,68.87 110.23,66.33 110.23,65.7 110.76,65.17 110.76,64.2 110.75,64.19 110.75,62.78 111.62,61.92 111.62,61.56 111.85,61.32 112.11,61.32 112.44,60.99 112.44,60.5 v3(111.96,60.02)
  BOTTOM w0.254: v1(94.2,72.75) 94.06,72.75 RPM3327.1 93.44,73.37 CAP1279.1 ; v3(111.96,60.02) 111.96,59.91 U80.AG15
