# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ<40>: length 30.2
  IN1 w0.114: v3(114.49,77.15) 114.33,76.99 114,76.99 113.82,77.17 113.82,77.46 113.56,77.73 113.56,78.39 111.15,80.8 111.15,81.15 110.92,81.38 109.96,81.38 109.59,81.75 105.7,81.75 105.49,81.97 105.49,82.37 104.14,83.72 104.14,84.58 v3(104.6,85.04)
  BOTTOM w0.076: 116.71,74.18 116.94,73.94 116.94,70.95 117.81,70.08 117.81,69.61 118.17,69.25 118.17,68.67 118.06,68.56 118.06,68.31 118.1,68.22 118.1,68.2 118.1,67.95 118.06,67.87 118.06,67.66 118.13,67.47 118.13,67.21 U80.AY27
  BOTTOM w0.152: 116.71,74.18 114.94,75.95 114.94,76.7 v3(114.49,77.15) ; v3(104.6,85.04) 105,85.44 106.78,85.44 USM2003.C10
M_B_DQ<41>: length 29.9
  IN1 w0.114: v3(106.81,84.69) 106.81,84.66 107.08,84.4 107.08,83.57 107.24,83.42 108.31,83.42 108.53,83.63 108.53,84.23 108.62,84.32 108.8,84.32 108.88,84.24 108.88,83.61 109,83.49 109.22,83.49 109.33,83.61 109.33,84.14 109.44,84.25 109.61,84.25 109.72,84.14 109.72,83.61 109.83,83.49 110.12,83.49 110.24,83.38 110.24,82.58 110.45,82.37 112.19,82.37 112.37,82.2 112.37,81.56 v3(114.44,79.49)
  BOTTOM w0.076: U80.AW27 118.06,66.63 118.06,66.74 118.14,66.82 118.47,66.82 118.55,66.9 118.55,67.52 118.76,67.73 118.76,67.84 118.68,67.91 118.68,68.02 118.76,68.1 118.76,68.62 118.66,68.72 118.66,69.52 118.46,69.73 118.46,70.34 117.73,71.06 117.73,74.56 117.58,74.71
  BOTTOM w0.152: v3(114.44,79.49) v1(115.77,78.16) 115.77,77.3 115.93,77.14 115.93,76.36 117.58,74.71 ; USM2003.C11 107.11,84.31 107.11,84.53 106.95,84.69 v3(106.81,84.69)
M_B_DQ<42>: length 35.5
  IN1 w0.114: v3(106.89,87.51) 106.57,87.82 104.32,87.82 102.63,86.13 102.63,81.77 104.58,79.82 108.02,79.82 110.54,77.3 110.54,75.12 111.46,74.2 111.46,73 112.6,71.86 113.67,71.86 114.53,72.72 v3(114.82,72.72)
  BOTTOM w0.076: U80.AY25 116.71,67.41 116.71,67.95 116.66,68.05 116.57,68.25 116.57,68.34 116.56,68.35 116.56,68.36 116.56,68.36 116.56,69.52 115.62,70.46 115.62,71.64 114.82,72.44 v3(114.82,72.72)
  BOTTOM w0.152: USM2003.C8 107.14,87.25 v3(106.89,87.51)
M_B_DQ<43>: length 32.2
  IN1 w0.114: v3(114.48,75.88) 114.43,75.93 113.92,75.93 113.51,76.33 113.51,77.34 113.32,77.53 113.32,77.67 113.21,77.78 113.21,78.31 110.57,80.95 109.78,80.95 109.29,81.45 105.48,81.45 105.16,81.77 105.16,82.27 103.74,83.69 103.74,85.68 103.96,85.91 v3(104.45,85.91)
  BOTTOM w0.076: 116.7,73.72 116.7,70.92 117.6,70.02 117.6,69.58 117.99,69.2 117.99,68.72 117.9,68.64 117.9,68.28 117.9,68.27 117.93,68.19 117.93,67.99 117.9,67.9 117.9,67.89 117.9,67.89 117.89,67.88 117.89,67.65 117.93,67.53 117.93,67.28 117.86,67.18 117.86,66.66 117.66,66.46 U80.AW25
  BOTTOM w0.152: v3(114.48,75.88) 114.54,75.88 116.7,73.72 ; v3(104.45,85.91) 104.47,85.91 104.89,86.32 105.3,86.32 105.46,86.17 106.21,86.17 USM2003.B9
M_B_DQ<44>: length 30.2
  IN1 w0.114: v3(104.57,84.13) 104.57,84.49 104.72,84.63 105.37,84.63 105.63,84.37 105.63,83.84 105.41,83.62 105.41,83.16 105.89,82.68 105.89,82.22 106.06,82.06 109.87,82.06 110.17,81.76 111.56,81.76 111.67,81.64 111.67,81.23 112.1,80.8 112.1,80.64 112,80.54 112,80.38 112.16,80.22 112.32,80.22 112.42,80.32 112.58,80.32 112.75,80.16 112.75,79.99 112.65,79.89 112.65,79.73 112.81,79.57 112.97,79.57 113.07,79.67 113.23,79.67 113.39,79.51 113.39,79.35 113.29,79.25 113.29,79.09 113.46,78.93 113.62,78.93 113.72,79.02 113.88,79.02 114.03,78.87 114.03,77.69 114.16,77.56 114.32,77.56 v3(114.48,77.72)
  BOTTOM w0.076: 117.15,74.21 117.15,71.05 118.01,70.18 118.01,69.64 118.33,69.32 U80.BB27
  BOTTOM w0.152: 117.15,74.21 115.27,76.09 115.27,76.84 114.96,77.14 114.96,77.4 114.81,77.55 114.65,77.55 v3(114.48,77.72) ; USM2003.B10 106.09,84.69 105.72,84.69 105.62,84.59 105.04,84.59 v3(104.57,84.13)
M_B_DQ<45>: length 29.4
  IN1 w0.114: v3(114.45,78.9) 112.01,81.34 112.01,81.95 111.89,82.06 110.3,82.06 109.99,82.37 106.82,82.37 106.66,82.54 106.66,84.3 106.4,84.56 106.4,86.04 106.3,86.13 106.12,86.13 106.01,86.02 106.01,84.48 106.17,84.32 v3(106.17,83.9)
  BOTTOM w0.076: 117.32,74.5 117.48,74.34 117.48,71 118.2,70.28 118.2,69.68 118.5,69.39 118.5,68.65 118.6,68.55 118.6,68.25 118.33,67.98 U80.BA27
  BOTTOM w0.152: 117.32,74.5 115.6,76.22 115.6,76.99 115.37,77.22 115.37,77.98 v3(114.45,78.9) ; v3(106.17,83.9) 106.17,83.97 USM2003.B11
M_B_DQ<46>: length 34.2
  IN1 w0.114: v3(106.22,87.43) 106.2,87.45 104.39,87.45 102.94,86 102.94,81.89 104.71,80.13 108.69,80.13 109.34,79.48 109.69,79.48 111.04,78.13 111.04,77.56 111.51,77.09 111.51,75.06 111.76,74.81 111.76,73.15 112.68,72.24 113.38,72.24 114.48,73.33 v3(114.86,73.33)
  BOTTOM w0.076: U80.BA25 116.9,67.86 116.9,68.01 116.85,68.06 116.85,68.06 116.8,68.18 116.73,68.31 116.73,68.41 116.73,68.42 116.73,68.43 116.73,68.43 116.73,69.61 115.83,70.51 115.83,71.72 115.2,72.35 115.2,72.99 v3(114.86,73.33)
  BOTTOM w0.152: USM2003.B8 106.49,87.17 v3(106.22,87.43)
M_B_DQ<47>: length 31.7
  IN1 w0.114: v3(104.52,87.02) 104.45,87.02 103.24,85.82 103.24,82.02 104.83,80.43 108.82,80.43 109.39,79.86 110.19,79.86 111.64,78.41 111.64,77.75 111.99,77.4 111.99,75.22 112.91,74.3 114.48,74.3 v3(114.86,73.92)
  BOTTOM w0.076: U80.BB25 116.91,68.5 116.91,69.71 116.04,70.58 116.04,72.74 115.65,73.12
  BOTTOM w0.152: USM2003.C9 106.62,86.4 105.63,86.4 105.43,86.6 104.94,86.6 v3(104.52,87.02) ; v3(114.86,73.92) 115.65,73.12
M_B_DQ<48>: length 25.2
  IN1 w0.114: v3(114.61,85.55) 114.62,85.57 115.94,85.57 116.31,85.19 116.31,84.05 116.92,83.44 116.92,82.98 116.8,82.87 116.52,82.87 116.41,82.75 116.41,82.52 116.52,82.41 116.8,82.41 116.92,82.29 116.92,75.09 119.15,72.85 119.15,68.61 119.51,68.25 119.51,67.51 119.41,67.41 119.13,67.41 119.01,67.3 119.01,67.16 119.14,67.03 119.32,67.03 119.44,66.91 v3(119.44,65.64)
  BOTTOM w0.076: v3(119.44,65.64) U80.AU27
  BOTTOM w0.152: USM2003.P9 114.29,85.87 v3(114.61,85.55)
M_B_DQ<49>: length 26.3
  IN1 w0.076: 119.83,65.67 119.83,65.51 119.44,65.12 v3(119.44,64.99)
  IN1 w0.114: v3(113.96,85.55) 113.96,85.57 114.35,85.96 116.08,85.96 116.56,85.47 116.97,85.47 117.22,85.22 117.22,75.26 119.46,73.03 119.46,68.84 119.83,68.47 119.83,65.67
  BOTTOM w0.076: v3(119.44,64.99) U80.AT27
  BOTTOM w0.152: USM2003.N9 113.64,85.87 v3(113.96,85.55)
M_B_DQ<50>: length 25.4
  IN1 w0.076: 118.17,67 118.13,66.96 118.13,65.5 118.52,65.1 v3(118.52,64.99)
  IN1 w0.114: 118.17,67 118.17,67.44 118.54,67.82 118.54,70.04 117.76,70.81 117.76,73.35 116.31,74.81 116.31,80.8 115.52,81.59 115.52,82.06 115.72,82.27 115.72,83.5 115.63,83.59 115.63,84.56 115.53,84.67 115.36,84.67 115.27,84.57 115.27,84.18 115.19,84.1 115.02,84.1 114.76,84.36 114.76,84.36 113.71,84.36 113.32,84.75 v3(113.31,84.75)
  BOTTOM w0.076: v3(118.52,64.99) U80.AT25
  BOTTOM w0.152: USM2003.M10 112.99,85.07 v3(113.31,84.75)
M_B_DQ<51>: length 25.8
  IN1 w0.114: v3(118.52,65.63) 118.46,65.69 118.46,66.9 118.55,66.99 118.55,67.37 118.85,67.67 118.85,70.56 118.69,70.72 118.35,70.72 118.24,70.84 118.24,71.06 118.35,71.18 118.66,71.18 118.77,71.29 118.77,71.52 118.66,71.64 118.38,71.64 118.27,71.75 118.27,71.98 118.38,72.09 118.68,72.09 118.8,72.21 118.8,72.44 118.68,72.55 118.22,72.55 118.11,72.66 118.11,73.46 116.61,74.96 116.61,81.77 116.05,82.32 116.05,83.75 115.97,83.83 115.97,84.73 115.54,85.16 114.35,85.16 113.96,84.77 v3(113.96,84.75)
  BOTTOM w0.076: v3(118.52,65.63) U80.AU25
  BOTTOM w0.152: USM2003.N10 113.64,85.07 v3(113.96,84.75)
M_B_DQ<52>: length 30.1
  IN1 w0.076: v3(119.44,63.72) 119.81,64.09 119.81,65.25 120.03,65.47 120.03,65.59
  IN1 w0.114: 120.03,65.59 120.31,65.87 120.31,72.61 117.53,75.39 117.53,85.74 116.51,86.76 113.87,86.76 113.63,86.51 113.63,85.89 113.31,85.57 v3(113.31,85.55)
  BOTTOM w0.076: v3(119.44,63.72) U80.AP27
  BOTTOM w0.152: USM2003.M9 112.99,85.87 v3(113.31,85.55)
M_B_DQ<53>: length 31.2
  IN1 w0.076: 120.33,65.49 120.29,65.49 119.98,65.18 119.98,63.63 v3(119.44,63.09)
  IN1 w0.114: v3(113.23,86.3) 113.23,86.61 113.69,87.07 116.73,87.07 117.83,85.96 117.83,75.52 120.61,72.74 120.61,65.77 120.33,65.49
  BOTTOM w0.076: v3(119.44,63.09) U80.AN27
  BOTTOM w0.152: v3(113.23,86.3) 112.99,86.54 USM2003.M8
M_B_DQ<54>: length 26.3
  IN1 w0.076: 117.62,65.51 117.98,65.16 117.98,63.63 v3(118.52,63.09)
  IN1 w0.114: 117.62,65.51 117.62,66.76 117.5,66.88 117.5,67.96 117.6,68.06 117.74,68.06 117.85,68.17 117.85,68.38 117.73,68.5 117.34,68.5 117.23,68.61 117.23,69.2 117.67,69.65 117.67,69.94 117.15,70.45 117.15,73.02 115.7,74.48 115.7,80.35 115.33,80.71 115.17,80.71 115.12,80.66 114.95,80.66 114.79,80.82 114.79,80.98 114.85,81.04 114.85,81.2 114.17,81.88 114.03,81.88 113.79,81.64 113.65,81.64 113.55,81.74 113.55,81.88 113.79,82.12 113.79,82.26 113.36,82.69 113.36,83.9 v3(113.31,83.95)
  BOTTOM w0.076: v3(118.52,63.09) U80.AN25
  BOTTOM w0.152: v3(113.31,83.95) 112.99,84.27 USM2003.M11
M_B_DQ<55>: length 26.5
  IN1 w0.076: v3(118.52,63.72) 118.25,63.72 118.15,63.82 118.15,65.24 117.89,65.5 117.89,66.76
  IN1 w0.114: 117.89,66.76 117.89,67.66 118.24,68 118.24,69.9 117.46,70.68 117.46,73.17 116,74.63 116,80.57 114.68,81.9 114.68,82.16 114.8,82.28 114.97,82.28 115.04,82.22 115.15,82.22 115.3,82.37 115.3,82.48 115.26,82.52 115.26,82.75 115.33,82.82 115.33,83.75 115.25,83.83 115.05,83.83 114.96,83.74 114.96,83.54 114.84,83.43 114.6,83.43 114.41,83.62 114.23,83.62 114.04,83.43 113.77,83.43 113.69,83.51 113.69,83.68 v3(113.96,83.95)
  BOTTOM w0.076: v3(118.52,63.72) U80.AP25
  BOTTOM w0.152: v3(113.96,83.95) 113.64,84.27 USM2003.N11
M_B_DQ<56>: length 35.8
  IN2 w0.076: 117.06,66.66 117.06,65.49 116.88,65.31 116.88,65.18 v3(116.69,64.99)
  IN2 w0.114: v3(108.77,85.55) 108.77,85.57 108.42,85.92 108.42,86.7 108.8,87.08 116.67,87.08 117.57,86.18 118.8,86.18 119.41,85.58 119.41,83.51 117.4,81.51 117.4,70.54 117.22,70.36 117.22,67.3 117.06,67.14 117.06,66.66
  BOTTOM w0.076: U80.AT22 v3(116.69,64.99)
  BOTTOM w0.152: USM2003.F9 108.77,85.57 v3(108.77,85.55)
M_B_DQ<57>: length 36.1
  IN2 w0.076: v3(116.69,65.64) 116.74,65.68 116.74,67.06
  IN2 w0.114: v3(108.83,86.29) 108.83,86.57 109.02,86.76 115.47,86.76 115.58,86.65 115.58,85.18 115.7,85.07 115.93,85.07 116.04,85.18 116.04,86.65 116.15,86.76 116.56,86.76 117.53,85.8 118.72,85.8 119.06,85.45 119.06,83.65 117,81.58 117,70.75 116.74,70.48 116.74,67.06
  BOTTOM w0.076: U80.AU22 v3(116.69,65.64)
  BOTTOM w0.152: USM2003.F8 108.83,86.42 v3(108.83,86.29)
M_B_DQ<58>: length 35.1
  IN2 w0.114: v3(109.38,84.69) 109.22,84.53 109.22,83.32 109.33,83.21 109.33,82.59 109.75,82.16 109.75,82.02 109.45,81.72 109.45,81.58 109.5,81.53 109.55,81.48 109.7,81.48 109.99,81.78 110.14,81.78 110.24,81.67 110.24,81.53 109.94,81.24 109.94,81.09 110.04,80.99 110.18,80.99 110.48,81.29 110.62,81.29 110.72,81.19 110.72,81.05 110.42,80.75 110.42,80.61 110.53,80.51 110.67,80.51 110.96,80.81 111.11,80.81 111.21,80.7 111.21,80.56 110.91,80.27 110.91,80.12 111.01,80.02 111.15,80.02 111.45,80.32 111.59,80.32 111.69,80.22 111.69,80.08 111.39,79.78 111.39,79.64 111.5,79.54 111.64,79.54 111.92,79.82 112.08,79.82 112.44,79.46 113.9,79.46 114.02,79.35 114.02,74.46 114.13,74.35 115.01,74.35 115.12,74.46 115.12,75.86 115.23,75.98 115.79,75.98 115.9,75.86 115.9,75.43 115.79,75.31 115.69,75.31 115.57,75.2 115.57,74.97 115.69,74.86 115.74,74.86 115.85,74.74 115.85,74.51 115.74,74.4 115.69,74.4 115.5,74.21 115.5,73.99 115.61,73.88 115.84,73.88 115.95,73.76 115.95,73.54 115.84,73.42 115.61,73.42 115.5,73.31 115.5,73.22 116.08,72.63 116.08,71.5 115.09,70.51 115.09,68.99 115.34,68.74 115.34,66.08 v3(115.78,65.64)
  BOTTOM w0.076: U80.AU21 v3(115.78,65.64)
  BOTTOM w0.152: v3(109.38,84.69) 109.38,84.58 USM2003.F11
M_B_DQ<59>: length 34.3
  IN2 w0.114: v3(108.77,84.75) 108.78,84.75 108.91,84.63 108.91,83.2 109.11,82.99 109.11,82.6 109.09,82.57 109.09,81.38 111.55,78.91 111.7,78.91 112.01,79.23 112.15,79.23 112.26,79.13 112.26,78.99 111.94,78.67 111.94,78.53 112.04,78.43 112.18,78.43 112.76,79 113.57,79 113.69,78.89 113.69,78.58 113.57,78.46 113,78.46 112.89,78.35 112.89,78.12 113,78.01 113.57,78.01 113.69,77.89 113.69,77.66 113.57,77.55 113,77.55 112.89,77.44 112.89,77.21 113,77.09 113.57,77.09 113.69,76.98 113.69,76.75 113.57,76.64 113,76.64 112.89,76.52 112.89,76.29 113,76.18 113.57,76.18 113.69,76.06 113.69,75.84 113.57,75.72 113,75.72 112.89,75.61 112.89,75.38 113,75.26 113.57,75.26 113.69,75.15 113.69,74.92 113.57,74.81 113,74.81 112.89,74.69 112.89,74.46 113,74.35 113.57,74.35 113.69,74.24 113.69,74.16 113.98,73.86 114.29,73.86 114.42,73.74 114.42,72.5 114.69,72.22 115.29,72.22 115.54,71.97 115.54,71.48 114.78,70.72 114.78,68.86 115.03,68.61 115.03,65.74 v3(115.78,64.99)
  BOTTOM w0.076: U80.AT21 v3(115.78,64.99)
  BOTTOM w0.152: v3(108.77,84.75) 108.77,84.77 USM2003.F10
M_B_DQ<60>: length 40.4
  IN2 w0.076: 118.08,66.74 117.39,66.05 117.39,65.3 117.24,65.15 117.24,63.63 v3(116.69,63.09)
  IN2 w0.114: 118.08,66.74 118.08,67.62 118.36,67.9 118.36,69.59 118.16,69.79 118.16,81.39 120.02,83.24 120.02,85.86 118.44,87.43 117.29,87.43 117.08,87.65 108.36,87.65 107.31,86.61 107.31,85.72 107.47,85.57 v3(107.47,85.55)
  BOTTOM w0.076: U80.AN22 v3(116.69,63.09)
  BOTTOM w0.152: USM2003.D9 107.47,85.57 v3(107.47,85.55)
M_B_DQ<61>: length 38.7
  IN2 w0.076: 117.31,66.38 117.23,66.3 117.23,65.41 117.07,65.25 117.07,64.1 v3(116.69,63.72)
  IN2 w0.114: v3(108.12,85.55) 108.12,85.57 107.63,86.06 107.63,86.46 108.53,87.37 116.85,87.37 117.1,87.12 118.3,87.12 119.71,85.7 119.71,83.37 117.86,81.52 117.86,69.47 117.97,69.36 118.02,69.31 118.02,68.1 117.71,67.79 117.71,66.78 117.31,66.38
  BOTTOM w0.076: U80.AP22 v3(116.69,63.72)
  BOTTOM w0.152: v3(108.12,85.55) 108.12,85.57 USM2003.E9
M_B_DQ<62>: length 36.7
  IN2 w0.114: v3(115.78,63.72) 115.34,64.16 115.34,65.08 114.69,65.74 114.69,68.1 114.68,68.11 114.68,68.25 114.58,68.35 114.56,68.35 114.41,68.51 114.41,69.52 114.3,69.64 112.73,69.64 112.62,69.75 112.62,69.98 112.73,70.09 114.3,70.09 114.41,70.21 114.41,70.44 114.3,70.55 112.73,70.55 112.62,70.66 112.62,70.89 112.73,71.01 114.3,71.01 114.41,71.12 114.41,71.54 114.3,71.65 112.78,71.65 112.63,71.8 112.63,72.04 112.75,72.15 113.84,72.15 113.96,72.27 113.96,73.43 113.44,73.95 111.98,73.95 111.87,74.06 111.87,74.29 111.97,74.39 112.38,74.39 112.49,74.5 112.49,74.64 112.38,74.74 111.98,74.74 111.87,74.85 111.87,77.02 111.98,77.13 111.98,77.62 111.87,77.73 111.87,78.07 108.96,80.98 108.75,81.19 108.75,82.14 108.34,82.55 108.34,82.6 108.34,82.6 108.34,82.92 108.34,82.92 108.34,83.51 108.58,83.74 108.58,84.31 108.13,84.75 v3(108.12,84.75)
  BOTTOM w0.076: U80.AP21 v3(115.78,63.72)
  BOTTOM w0.152: USM2003.E10 108.12,84.77 v3(108.12,84.75)
M_B_DQ<63>: length 37.7
  IN2 w0.114: v3(108.13,83.93) 108.1,83.9 108.1,83.22 108.13,83.19 108.13,82.87 108.1,82.84 108.1,81.24 107.6,80.74 107.6,80.6 107.7,80.5 107.84,80.5 108.36,81.01 108.5,81.01 108.6,80.91 108.6,80.77 107.9,80.07 107.9,79.93 108,79.82 108.14,79.82 108.84,80.52 108.98,80.52 109.08,80.42 109.08,80.28 108.38,79.58 108.38,79.44 108.49,79.34 108.63,79.34 109.33,80.04 109.47,80.04 109.57,79.94 109.57,79.8 108.87,79.1 108.87,78.96 108.97,78.85 109.11,78.85 109.81,79.55 109.95,79.55 111.52,77.98 111.52,72.42 111.7,72.24 112.1,72.24 112.2,72.14 112.2,71.99 112.1,71.89 111.7,71.89 111.6,71.79 111.6,71.65 111.7,71.55 112.1,71.55 112.2,71.45 112.2,71.31 112.1,71.21 111.7,71.21 111.6,71.11 111.6,70.97 111.7,70.87 112.1,70.87 112.2,70.77 112.2,70.62 112.1,70.52 111.15,70.52 111.05,70.42 111.05,70.2 111.15,70.1 111.6,70.1 114.35,67.36 114.35,65.22 114.45,65.11 114.45,63.4 114.77,63.08 115.77,63.08 v3(115.78,63.09)
  BOTTOM w0.076: U80.AN21 v3(115.78,63.09)
  BOTTOM w0.152: v3(108.13,83.93) 108.14,83.95 108.14,83.99 USM2003.E11
M_B_DQS_DN*<0>: length 30.7
  IN2 w0.102: v3(133.34,83.96) 133.34,84.1 133.48,84.24 133.61,84.24 133.76,84.1 133.76,82.85 133.58,82.68 132.68,82.68 132.35,82.35 132.35,82 132.08,81.73 132.08,81.42 132.3,81.2 133.89,81.2 134.05,81.03 134.05,80.89 133.92,80.75 132.29,80.75 132.03,80.5 132.03,80.12 132.23,79.92 133.29,79.92 133.4,79.81 133.4,79.7 132.08,78.38 131.94,78.38 v3(131.72,78.59)
  BOTTOM w0.076: U80.BA38 124.92,67.26 124.92,67.15 125.06,67.1 125.17,67.13 125.22,67.2 125.27,67.31 125.27,67.54 125.22,67.65 125.22,67.87 125.29,68.03 125.29,68.14 125.29,68.15 125.23,68.27 125.23,68.76 125.37,68.89 125.37,69.25 125.26,69.35 125.26,70.34 125.82,70.9 125.82,71.07 125.83,71.16 125.94,71.35 125.94,71.52 126.08,71.66 126.08,71.73
  BOTTOM w0.147: v3(131.72,78.59) 131.63,78.5 128.13,78.5 126.73,77.1 126.73,75.63 126.08,74.98 126.08,74.59 126.08,74.59 126.08,71.73 ; USM2002.P11 133.02,84.28 v3(133.34,83.96)
M_B_DQS_DN*<1>: length 23
  IN1 w0.102: v3(123.02,81.79) 123.29,82.05 123.29,82.05 123.92,82.05 124.22,82.36 124.22,83.47 125.01,84.25 125.16,84.25 125.27,84.15 125.27,83.68 125.49,83.46 125.8,83.46 126.03,83.68 126.03,84.02 126.31,84.31 126.72,84.31 126.85,84.18 v3(126.85,83.96)
  BOTTOM w0.076: 122.12,72.93 122.12,69.48 122.23,69.37 122.23,69.36 122.24,69.35 122.24,68.56 122.24,68.56 122.24,68.35 122.24,68.26 122.2,68.22 122.2,67.95 122.24,67.91 122.24,67.85 122.24,67.61 122.22,67.59 122.22,67.28 122.24,67.26 122.24,67.09 U80.AY34
  BOTTOM w0.147: v3(123.02,81.79) 123.02,81.34 122.12,80.44 122.12,72.93 ; USM2002.D11 126.52,84.28 126.84,83.96 v3(126.85,83.96)
M_B_DQS_DN*<2>: length 36.4
  IN1 w0.102: v3(125.85,64.99) 125.84,64.82 125.74,64.71 125.59,64.71 125.47,64.84 125.47,65.93 125.48,65.94 125.48,67.51 127.54,69.57 127.69,69.57 130.53,72.42 131.02,72.42 131.75,73.15 131.75,73.6 132.35,74.2 132.35,75.55 132.48,75.68 132.48,79.43 135.26,82.22 135.26,83.12 135.26,83.12 135.26,83.29 135.22,83.33 134.78,83.77 134.15,83.77 133.93,83.55 133.93,82.8 133.77,82.64 132.79,82.64 132.56,82.42 132.56,81 132.46,80.9 131.6,80.9 131.47,81.03 131.47,84.06 130.99,84.54 130.99,84.84 131.32,85.17 131.48,85.17 131.58,85.06 131.58,84.88 131.38,84.68 v3(131.38,84.67)
  BOTTOM w0.076: U80.AT38 v3(125.85,64.99)
  BOTTOM w0.147: USM2002.L11 131.38,84.6 v3(131.38,84.67)
M_B_DQS_DN*<3>: length 29.4
  IN1 w0.102: v3(124.82,81.31) 124.57,81.31 124.47,81.41 124.47,81.69 124.57,81.79 125.17,81.79 125.55,81.41 129.04,81.41 129.29,81.66 129.29,82.22 128.77,82.74 128.49,82.74 128.4,82.83 128.4,83.31 128.68,83.59 128.68,83.67 v3(128.89,83.88)
  IN2 w0.076: 122.29,66.14 122.29,66.06 122.55,65.79 122.55,64.89 122.46,64.8 122.37,64.8 v3(122.18,64.99)
  IN2 w0.102: v3(124.82,81.31) 124.82,81.58 124.95,81.71 125.05,81.71 125.28,81.49 125.28,81.12 122.22,78.06 122.02,77.87 122.02,69.37 122.29,69.11 122.29,66.14
  BOTTOM w0.076: v3(122.18,64.99) U80.AT32
  BOTTOM w0.147: USM2002.G11 128.47,84.28 128.79,83.96 128.81,83.96 v3(128.89,83.88)
M_B_DQS_DN*<4>: length 26.8
  IN2 w0.102: v3(118.54,84.75) 118.43,84.86 118.04,84.86 117.68,84.51 117.68,83.85 117.37,83.54 115.89,83.54 115.17,84.25 114.91,84.25 v3(114.61,83.95)
  BOTTOM w0.076: U80.BA30 119.95,67.36 119.95,67.12 120.01,67.06 120.17,67.06 120.27,67.16 120.27,67.33 120.29,67.35 120.29,67.52 120.27,67.54 120.27,67.92 120.28,67.93 120.28,67.99 120.29,68 120.29,68.17 120.28,68.18 120.28,68.23 120.27,68.24 120.27,68.63 120.28,68.65 120.28,69.21 120.26,69.23 120.26,69.51 120.09,69.67 119.84,69.92 119.84,71.52 119.5,71.86 119.5,71.87 119.47,71.9
  BOTTOM w0.147: v3(118.54,84.75) 118.62,84.67 118.88,84.67 118.99,84.78 118.99,84.91 119.14,85.06 119.36,85.06 119.69,84.73 119.69,83.63 118.61,82.56 118.61,77.56 118.77,77.4 118.77,76.77 119.47,76.08 119.47,71.9 ; v3(114.61,83.95) 114.29,84.27 USM2003.P11
M_B_DQS_DN*<5>: length 34.2
  IN1 w0.102: v3(103.88,82.33) 104,82.45 104.21,82.45 104.52,82.14 104.52,81.38 105.05,80.85 108.99,80.85 109.55,80.29 110.37,80.29 112.12,78.54 112.12,78 112.94,77.18 112.94,75.51 113.48,74.98 114.27,74.98 v3(114.52,74.74)
  IN2 w0.102: v3(103.88,82.33) 103.98,82.43 104.87,82.43 105.15,82.16 105.15,81.33 105.44,81.03 106.47,81.03 106.8,81.36 106.8,83.84 107.33,84.37 107.63,84.37 107.72,84.29 107.72,84.13 107.54,83.95 v3(107.47,83.95)
  BOTTOM w0.076: U80.AY26 117.48,66.69 117.32,66.69 117.24,66.77 117.24,66.93 117.32,67.01 117.32,67.16 117.25,67.23 117.25,67.65 117.26,67.67 117.26,67.85 117.26,67.86 117.26,67.91 117.25,67.92 117.25,67.93 117.24,67.93 117.24,67.95 117.22,67.98 117.22,68.19 117.25,68.22 117.25,68.3 117.29,68.34 117.29,68.54 117.1,68.73 117.1,69.91 116.25,70.76 116.25,73.11 116.06,73.3 116.04,73.3
  BOTTOM w0.147: USM2003.D11 107.47,83.97 v3(107.47,83.95) ; 116.04,73.3 115.21,74.12 115.21,74.31 114.78,74.74 v3(114.52,74.74)
M_B_DQS_DN*<6>: length 30.8
  IN1 w0.076: v3(118.52,64.36) 118.74,64.36 118.81,64.43 118.81,64.77 118.89,64.85 119,64.85 119.08,64.77 119.08,64.25 118.9,64.08 118.9,62.04 118.81,61.95 117.35,61.95 117.24,62.06 117.24,65.32 117.29,65.38 117.29,65.44 117.3,65.45 117.3,65.46
  IN1 w0.102: 117.3,65.46 117.3,66.65 117.12,66.84 117.12,67.05 117.1,67.08 117.1,68.13 116.74,68.48 116.74,68.86 116.84,68.97 116.84,69.74 116.71,69.88 116.71,72.81 116.4,73.13 116.11,73.13 115.66,73.59 115.66,74.03 115.26,74.43 115.26,79.59 112.99,81.86 112.99,83.03 112.54,83.47 112.54,83.74 v3(112.71,83.91)
  BOTTOM w0.076: U80.AR25 v3(118.52,64.36)
  BOTTOM w0.147: v3(112.71,83.91) USM2003.L11
M_B_DQS_DN*<7>: length 39
  IN2 w0.076: v3(116.69,64.36) 116.33,64.72 116.33,65.87 115.94,66.26
  IN2 w0.102: 115.94,66.26 115.75,66.45 115.75,66.91 115.78,66.93 115.78,69.59 116.23,70.05 116.23,70.59 116.62,70.98 116.62,76.46 116.4,76.69 115.59,76.69 115.49,76.79 115.49,76.99 115.59,77.09 116.4,77.09 116.62,77.31 116.62,77.78 116.4,78 115.63,78 115.53,78.11 115.53,78.31 115.63,78.41 116.4,78.41 116.62,78.63 116.62,79 116.4,79.22 115.63,79.22 115.53,79.33 115.53,79.53 115.63,79.63 116.4,79.63 116.62,79.85 116.62,81.09 116.4,81.31 115.94,81.31 115.73,81.09 115.49,81.09 114.88,81.71 114.56,81.71 112.94,80.08 112.8,80.08 112.64,80.24 112.64,80.38 113.28,81.01 113.28,81.41 113.06,81.63 112.74,81.63 112.08,80.97 111.95,80.97 111.82,81.09 111.82,81.29 112.25,81.71 112.25,82.04 112.02,82.26 111.57,82.26 111.19,81.88 111.04,81.88 110.45,82.47 110.33,82.59 110.33,83.14 109.68,83.79 109.68,84.16 109.84,84.32 110.17,84.32 110.25,84.24 110.25,84.06 v3(110.11,83.92)
  BOTTOM w0.076: v3(116.69,64.36) U80.AR22
  BOTTOM w0.147: USM2003.G11 v3(110.11,83.92)
M_B_DQS_DP<0>: length 30.8
  IN2 w0.102: v3(133.34,84.76) 133.65,84.44 133.7,84.44 133.96,84.18 133.96,82.77 133.66,82.48 132.76,82.48 132.55,82.26 132.55,81.92 132.28,81.65 132.28,81.5 132.38,81.4 133.97,81.4 134.26,81.12 134.26,80.8 134,80.55 132.37,80.55 132.24,80.41 132.24,80.21 132.32,80.13 133.38,80.13 133.61,79.9 133.61,79.61 132.17,78.17 131.88,78.17 v3(131.72,78.01)
  BOTTOM w0.076: 126.31,71.73 126.31,71.72 126.28,71.68 126.28,71.65 126.24,71.61 126.24,71.59 126.1,71.45 126.1,71.31 126.06,71.23 126.06,71.22 126.06,71.16 126.06,71.07 126.06,70.91 126.06,70.9 125.43,70.27 125.43,69.42 125.53,69.32 125.53,68.83 125.4,68.69 125.4,68.31 125.45,68.19 125.45,68.17 125.45,68 125.45,67.98 125.4,67.87 125.39,67.84 125.39,67.68 125.44,67.57 125.44,67.27 125.36,67.11 U80.AY38
  BOTTOM w0.147: 126.31,71.73 126.31,74.43 126.36,74.48 126.36,74.86 127.02,75.51 127.02,76.98 128.25,78.21 131.53,78.21 v3(131.72,78.01) ; USM2002.P10 133.02,85.08 v3(133.34,84.76)
M_B_DQS_DP<1>: length 23
  IN1 w0.102: v3(126.85,84.76) 126.6,84.51 126.23,84.51 125.82,84.1 125.82,83.76 125.72,83.66 125.58,83.66 125.48,83.76 125.48,84.23 125.25,84.46 124.92,84.46 124.02,83.56 124.02,82.44 123.84,82.26 123.37,82.26 v3(123.16,82.47)
  BOTTOM w0.076: U80.BA34 122.48,67.43 122.41,67.51 122.41,67.92 122.39,67.93 122.39,68 122.36,68.03 122.36,68.15 122.39,68.18 122.39,68.23 122.4,68.24 122.4,68.28 122.4,68.49 122.41,68.49 122.41,68.61 122.4,68.61 122.4,69.42 122.39,69.43 122.39,69.44 122.29,69.55 122.29,69.7 122.29,72.81 122.32,72.84 122.32,72.88 122.36,72.92 122.36,72.93
  BOTTOM w0.147: 122.36,72.93 122.41,72.98 122.41,80.32 123.31,81.22 123.31,81.4 123.45,81.53 123.45,81.96 123.16,82.25 v3(123.16,82.47) ; v3(126.85,84.76) 126.84,84.76 126.52,85.08 USM2002.D10
M_B_DQS_DP<2>: length 36.4
  IN1 w0.102: v3(125.84,64.36) 125.68,64.51 125.52,64.51 125.28,64.76 125.28,65.93 125.27,65.94 125.27,67.6 127.45,69.78 127.6,69.78 130.45,72.62 130.94,72.62 131.55,73.23 131.55,73.69 132.15,74.28 132.15,75.66 132.27,75.78 132.27,79.52 135.06,82.3 135.06,83.21 134.69,83.57 134.23,83.57 134.13,83.47 134.13,82.71 133.85,82.44 132.87,82.44 132.77,82.33 132.77,80.92 132.55,80.7 131.52,80.7 131.27,80.94 131.27,83.97 130.79,84.46 130.79,84.92 131.11,85.25 131.39,85.52 v3(131.39,85.56)
  BOTTOM w0.076: U80.AR38 v3(125.84,64.36)
  BOTTOM w0.147: USM2002.L10 131.07,85.09 131.39,85.4 v3(131.39,85.56)
M_B_DQS_DP<3>: length 29.5
  IN1 w0.102: v3(124.83,82.18) 124.83,82.09 124.93,81.99 125.26,81.99 125.64,81.61 128.96,81.61 129.09,81.74 129.09,82.13 128.69,82.54 128.58,82.54 128.49,82.54 128.41,82.54 128.2,82.75 128.2,83.39 128.48,83.67 128.48,84.44 128.79,84.76 v3(128.8,84.76)
  IN2 w0.076: v3(122.18,64.36) 122.45,64.62 122.53,64.62 122.73,64.82 122.73,65.87 122.49,66.11 122.49,66.12
  IN2 w0.102: v3(124.83,82.18) 124.92,82.09 124.92,81.99 125,81.92 125.13,81.92 125.48,81.57 125.48,81.04 122.42,77.98 122.23,77.79 122.23,69.45 122.49,69.19 122.49,66.12
  BOTTOM w0.076: v3(122.18,64.36) U80.AR32
  BOTTOM w0.147: v3(128.8,84.76) 128.79,84.76 128.47,85.08 USM2002.G10
M_B_DQS_DP<4>: length 26.8
  IN2 w0.102: v3(118.51,85.34) 118.24,85.07 117.95,85.07 117.48,84.59 117.48,83.93 117.29,83.74 115.97,83.74 115.26,84.46 114.9,84.46 v3(114.61,84.75)
  BOTTOM w0.076: U80.AY30 120.43,67.09 120.43,67.26 120.45,67.28 120.45,67.59 120.43,67.61 120.43,67.86 120.44,67.87 120.44,67.92 120.45,67.93 120.45,68.24 120.44,68.25 120.44,68.3 120.43,68.31 120.43,68.56 120.45,68.58 120.45,69.28 120.42,69.3 120.42,69.57 120.01,69.99 120.01,71.66 119.77,71.89 119.77,71.9
  BOTTOM w0.147: v3(118.51,85.34) 119.48,85.34 119.97,84.85 119.97,83.51 118.9,82.44 118.9,77.68 119.06,77.52 119.06,76.89 119.75,76.19 119.75,72.09 119.77,72.07 119.77,71.9 ; v3(114.61,84.75) 114.29,85.07 USM2003.P10
M_B_DQS_DP<5>: length 34.1
  IN1 w0.102: v3(103.65,82.88) 103.92,82.88 104.14,82.66 104.28,82.66 104.72,82.22 104.72,81.46 105.13,81.05 109.08,81.05 109.64,80.5 110.45,80.5 112.32,78.62 112.32,78.09 113.15,77.26 113.15,75.6 113.56,75.19 114.29,75.19 114.43,75.32 v3(114.52,75.32)
  IN2 w0.102: v3(107.47,84.75) 107.43,84.75 106.59,83.92 106.59,81.45 106.39,81.24 105.52,81.24 105.35,81.41 105.35,82.24 104.96,82.63 104.19,82.63 103.94,82.88 v3(103.65,82.88)
  BOTTOM w0.076: U80.BA26 117.67,67.43 117.67,67.23 117.6,67.16 117.59,67.16 117.51,67.19 117.5,67.19 117.41,67.29 117.41,67.52 117.41,67.52 117.41,67.58 117.43,67.6 117.43,67.92 117.41,67.93 117.41,68 117.41,68 117.41,68.02 117.38,68.05 117.38,68.12 117.41,68.15 117.41,68.23 117.45,68.27 117.45,68.61 117.26,68.8 117.26,69.97 116.41,70.83 116.41,73.18 116.23,73.36 116.23,73.44 116.22,73.45
  BOTTOM w0.147: v3(114.52,75.32) 114.77,75.08 114.83,75.08 115.61,74.3 115.61,74.06 116.22,73.45 ; v3(107.47,84.75) 107.47,84.77 USM2003.D10
M_B_DQS_DP<6>: length 30.9
  IN1 w0.076: v3(119.44,64.36) 119.07,63.99 119.07,61.95 118.88,61.77 117.28,61.77 117.06,61.99 117.06,65.42 117.1,65.46
  IN1 w0.102: v3(112.66,84.75) 112.61,84.39 112.33,84.07 112.33,83.77 112.32,83.76 112.32,83.4 112.78,82.94 112.78,81.78 115.06,79.51 115.06,74.34 115.45,73.94 115.45,73.5 116.03,72.92 116.31,72.92 116.51,72.73 116.51,69.79 116.64,69.66 116.64,69.05 116.54,68.95 116.54,68.4 116.89,68.04 116.89,66.98 116.92,66.96 116.92,66.79 117.13,66.58 117.13,65.49 117.1,65.46
  BOTTOM w0.076: v3(119.44,64.36) U80.AR27
  BOTTOM w0.147: USM2003.L10 112.34,85.07 v3(112.66,84.75)
M_B_DQS_DP<7>: length 38.9
  IN2 w0.076: 115.75,66.19 116.15,65.8 116.15,64.72 v3(115.78,64.36)
  IN2 w0.102: 115.75,66.19 115.57,66.37 115.57,69.67 116.03,70.13 116.03,70.67 116.42,71.06 116.42,76.38 116.31,76.48 115.51,76.48 115.29,76.7 115.29,77.07 115.51,77.29 116.31,77.29 116.42,77.4 116.42,77.7 116.31,77.8 115.55,77.8 115.33,78.02 115.33,78.39 115.55,78.61 116.31,78.61 116.42,78.72 116.42,78.92 116.31,79.02 115.55,79.02 115.33,79.24 115.33,79.61 115.55,79.83 116.31,79.83 116.42,79.94 116.42,81 116.31,81.1 116.03,81.1 115.82,80.89 115.4,80.89 114.79,81.5 114.65,81.5 113.02,79.88 112.71,79.88 112.44,80.15 112.44,80.46 113.07,81.1 113.07,81.33 112.97,81.43 112.83,81.43 112.16,80.76 111.86,80.76 111.62,81.01 111.62,81.37 112.04,81.79 112.04,81.95 111.94,82.05 111.65,82.05 111.27,81.67 110.96,81.67 110.3,82.33 110.13,82.5 110.13,83.08 109.49,83.71 109.49,83.83 109.48,83.84 109.48,84.24 109.76,84.52 110.03,84.52 110.11,84.6 v3(110.11,84.72)
  BOTTOM w0.076: v3(115.78,64.36) U80.AR21
  BOTTOM w0.147: USM2003.G10 v3(110.11,84.72)
M_B_ODT<0>: length 57.7
  IN1 w0.097: v3(128.4,74.38) 128.77,74.01 128.77,73.48 129.11,73.14 129.11,72.92 129.26,72.77 129.67,72.77 130.04,73.14 130.04,73.35 130.38,73.68 130.38,77.09 129.2,78.27 127.7,78.27 127.59,78.38 127.59,78.7 127.47,78.82 127.24,78.82 127.13,78.7 127.13,78.38 127.02,78.27 126.79,78.27 126.67,78.38 126.67,78.7 126.56,78.82 126.33,78.82 126.22,78.7 126.22,78.38 126.1,78.27 125.87,78.27 125.76,78.38 125.76,78.7 125.64,78.82 125.42,78.82 125.3,78.7 125.3,78.38 125.19,78.27 123.59,78.27 121.13,80.72 121.13,83.2 121.52,83.6 121.52,87.38 121.38,87.52 v3(121.38,87.86)
  IN2 w0.097: v3(129.44,87.03) 128.54,87.92 125.32,87.92 125.22,87.82 125.22,87.46 125.12,87.37 124.93,87.37 124.83,87.46 124.83,87.82 124.74,87.92 124.3,87.92 124.2,87.82 124.2,87.48 124.1,87.39 123.91,87.39 123.82,87.48 123.82,87.82 123.72,87.92 123.23,87.92 123.13,87.82 123.13,87.59 123.03,87.5 122.84,87.5 122.74,87.59 122.74,87.82 122.65,87.92 122.09,87.92 122.03,87.86 v3(121.38,87.86)
  BOTTOM w0.076: v3(128.4,74.38) 127.38,73.37 127.38,71.28 127,70.9 127,70.41 126.93,70.33 126.93,69.69 126.74,69.5 126.74,68.7 126.67,68.63 126.67,68.3 126.79,68.05 126.83,68.05 126.94,67.94 U80.BA42
  BOTTOM w0.13: USM2002.J8 129.77,86.7 v3(129.44,87.03)
  BOTTOM w0.132: USM2003.J8 112.28,87.92 116.7,87.92 117.22,88.44 118.3,88.44 118.88,87.86 v1(120.05,87.86) v3(121.38,87.86)
MA_A_ZQ0: length 1.1
  TOP w0.305: RSM2007.2 163.64,77.67 163.66,77.64 v3(163.71,77.64)
  BOTTOM w0.203: USM2000.B3 164.03,77.32 v3(163.71,77.64)
MA_A_ZQ1: length 1.2
  TOP w0.305: RSM2008.2 163.59,76.72 v3(163.71,76.84)
  BOTTOM w0.203: USM2000.B4 164.03,76.52 v3(163.71,76.84)
MA_B_ZQ0: length 1.1
  TOP w0.305: v3(147.46,88.88) 147.39,88.88 147.38,88.89 RSM1012.2
  BOTTOM w0.203: v3(147.46,88.88) 147.78,88.56 USM2001.B3
MA_B_ZQ1: length 1.2
  TOP w0.305: RSM1014.2 147.33,87.95 v3(147.46,88.08)
  BOTTOM w0.203: v3(147.46,88.08) 147.78,87.76 USM2001.B4
MB_A_ZQ0: length 2.5
  TOP w0.254: v3(124.9,91.02) 124.03,90.15 RSM2075.2
  BOTTOM w0.203: USM2002.B3 124.9,91.01 v3(124.9,91.02)
MB_A_ZQ1: length 2.7
  TOP w0.305: RSM2076.2 123.97,89.14 v1(124.12,89.29) 124.41,89.58 124.41,89.73 v3(124.9,90.22)
  BOTTOM w0.203: v3(124.9,90.22) 124.9,90.21 USM2002.B4
MB_B_ZQ0: length 3.3
  TOP w0.305: RSM2112.2 104.5,91.12 106.08,91.12 v3(106.16,91.04)
  BOTTOM w0.203: v3(106.16,91.04) 106.49,90.71 USM2003.B3
MB_B_ZQ1: length 4.1
  TOP w0.305: v3(106.19,90.24) 105.84,90.58 105.72,90.58 105.7,90.6 104.57,90.6 104.55,90.58 104.54,90.58 104.28,90.33 104.28,90 103.68,89.4 RSM2113.2
  BOTTOM w0.203: v3(106.19,90.24) 106.24,90.24 106.49,89.99 USM2003.B4
MECH_PWRBTN*: length 168.3
  TOP w0.102: RCP4216.2 118.92,19.24 v1(118.28,18.6) ; v1(147.69,21.85) 147.86,21.69 U83.5
  IN1 w0.079: v1(118.28,18.6) 118.69,18.19 120.06,18.19 121.46,19.6 140.33,19.6 140.68,19.94 140.68,20.76 141.9,21.98 147.57,21.98 v1(147.69,21.85) ; v1(81.38,71.91) 81.25,72.03 79.68,72.03 79.09,72.63 78.94,72.63 77.77,73.79 77.77,74.3 77.49,74.58 77.49,75.45 76.55,76.39 75.81,76.39 75.49,76.7 v3(75.49,77.02)
  IN2 w0.079: v1(81.38,71.91) 80.86,71.91 78.91,69.96 78.91,68.16 78.33,67.58 76.71,67.58 72.79,63.67 72.11,63.67 69.26,60.82 68.09,60.82 67.49,60.22 67.49,59.2 66.89,58.6 65.67,58.6 64.48,57.4 64.48,53.47 64.15,53.14 64.15,47.57 63.53,46.95 63.53,44.92 65.36,43.1 65.36,40.39 66.19,39.56 66.19,37.29 67.84,35.64 68.49,35.64 70.78,33.35 70.78,32.05 71.24,31.58 v1(71.24,30.49) 71.24,28.56 76.42,23.37 76.72,23.37 79.79,20.31 84.59,20.31 88.25,16.65 90.49,16.65 93.76,13.38 93.96,13.38 94.72,12.61 99.34,12.61 99.77,13.04 102.38,13.04 102.42,13.09 v1(103.06,13.09) 103.29,12.86 104.61,12.86 105.12,12.36 108.53,12.36 109.64,13.47 111.98,13.47 117.11,18.6 v1(118.28,18.6)
  BOTTOM w0.079: 74.28,77.05 74.17,76.93 73.71,76.93 PU3254.L2
  BOTTOM w0.102: CN17.22 103.1,15.9 103.1,13.12 v1(103.06,13.09) ; v3(75.49,77.02) 75.08,77.02 75.05,77.05 74.28,77.05 ; CR9.1 75.51,31.28 74.8,30.56 71.32,30.56 v1(71.24,30.49)
MECH_PWRBTN*_C: length 4.6
  TOP w0.102: v1(117.59,17.58) 117.63,17.62 R5093.2 117.63,18.63 118.68,19.69 RCP4216.1 119.47,20.61 QPM3389.3
MECH_PWRBTN*_R: length 24.7
  TOP w0.102: v1(125.9,20.38) 125.56,20.72 CRCP4043.4 CRCP4043.7 125.56,23.15 125.01,23.71 117.35,23.71 115.28,21.64 v1(115.28,20.96) 116.4,19.85 QPM3389.1 117.19,19.21 116.85,18.87 R5093.1 116.81,18.41 R5094.1
  BOTTOM w0.102: v1(115.28,20.96) 115.63,20.61 SW1.2 ; JCP4056.25 125.9,21.6 v1(125.9,20.38)
MERGE_I2S_PCHRXD_AUDTXD: length 3.4
  TOP w0.102: R3504.1 98.51,80.72 v1(99.03,80.2) 99.03,79.87 R5147.2 R5139.2
MERGE_I2S_PCHTXD_AUDRXD: length 152
  TOP w0.102: R3499.1 91.24,79.01 R3503.1 91.45,79.02 91.62,79.19 91.62,80.07 91.52,80.17 91.1,80.17 91,80.27 91,80.58 91.1,80.68 91.52,80.68 91.62,80.78 91.62,81.66 91.52,81.76 91.06,81.76 90.96,81.66 v1(90.96,81.35) ; U3.1 38.52,22.58 38.65,22.71 38.78,22.71 38.98,22.51 38.98,22.21 v1(39.08,22.11) 39.26,22.28 39.26,23.5 40.58,24.82 40.58,29.65 36.57,33.66 36.57,35.8 37.76,36.99 43.39,36.99 44.11,37.7 48.63,37.7 56.25,30.08 57.48,30.08 60.42,27.14 70.68,27.14 72.57,25.26 78.99,25.26 v1(80.05,24.19) ; v1(34.26,22.26) 33.8,22.72 33.55,22.72 33.39,22.56 U5.1
  IN1 w0.079: v1(34.26,22.26) 34.51,22 38.98,22 v1(39.08,22.11)
  IN2 w0.079: v1(80.05,24.19) 79.33,24.92 78.48,24.92 73.4,29.99 73.4,33.47 72.38,34.49 72.38,37.08 71.62,37.83 71.62,39.39 70.72,40.3 70.72,44.13 69.64,45.21 69.64,51.74 69.51,51.87 69.51,53.31 74.12,57.92 74.12,59.62 77.67,63.18 80.09,63.18 80.89,63.98 80.89,65.05 86.08,70.25 86.08,71.7 86.33,71.95 86.33,75.69 87.2,76.56 87.2,77.43 90.96,81.19 v1(90.96,81.35)
MERGE_I2S_SCL: length 155.6
  TOP w0.102: v1(79.42,24.19) 78.71,24.9 72.42,24.9 70.54,26.78 60.28,26.78 57.33,29.73 56.1,29.73 48.48,37.35 44.25,37.35 43.47,36.56 37.83,36.56 36.92,35.65 36.92,33.81 40.94,29.8 40.94,24.52 v1(39.79,23.38) 39.79,22.39 39.87,22.31 39.87,21.5 39.6,21.22 U3.16 ; v1(93.01,84.32) 93.01,83.9 93.19,83.72 R5138.2 93.76,84.48 R3502.1 ; U5.16 34.9,21.25 34.94,21.29 34.94,22.93 C1107.1 35.6,23.44 v1(35.6,22.54)
  IN1 w0.079: v1(35.6,22.54) 38.68,22.54 39.03,22.89 39.31,22.89 v1(39.79,23.38)
  IN2 w0.079: v1(79.42,24.19) 79.02,24.58 78.34,24.58 73.05,29.88 73.05,33.35 72.04,34.36 72.04,36.94 70.95,38.03 69.61,38.03 69.12,38.52 69.12,39.78 69.56,40.22 69.56,43.65 67.9,45.31 67.9,53.41 70.05,55.56 70.05,56.22 72.84,59.01 72.84,59.97 77.41,64.55 77.41,64.68 77.84,65.11 79.25,65.11 84.93,70.79 84.93,72.18 85.17,72.43 85.17,76.17 85.96,76.96 85.96,78.73 87.28,80.04 87.28,81.04 87.88,81.64 88.87,81.64 91.55,84.32 v1(93.01,84.32)
MERGE_I2S_SFRM: length 154.3
  TOP w0.102: R5137.2 R3501.1 94.52,84.61 v1(94.23,84.31) ; v1(35.17,20.56) 34.86,20.25 U5.14 ; U3.14 39.89,20.22 40.28,20.61 v1(40.28,21.17) 40.28,22.18 41.29,23.2 41.29,29.94 37.28,33.96 37.28,35.51 37.98,36.2 43.61,36.2 44.4,36.99 48.33,36.99 55.95,29.37 57.18,29.37 60.13,26.42 70.39,26.42 72.27,24.54 78.43,24.54 v1(78.78,24.19)
  IN1 w0.079: v1(35.17,20.56) 39.67,20.56 v1(40.28,21.17)
  IN2 w0.079: v1(94.23,84.31) 93.77,84.77 91.25,84.77 88.46,81.97 87.74,81.97 84.75,78.98 84.75,72.47 84.59,72.32 84.59,70.92 79.11,65.44 77.71,65.44 77.08,64.81 77.08,64.69 72.05,59.65 72.05,58.69 69.72,56.36 69.72,55.7 67.57,53.55 67.57,44.52 69.23,42.86 69.23,40.36 68.79,39.92 68.79,38.38 69.47,37.7 70.81,37.7 71.71,36.8 71.71,34.22 72.72,33.21 72.72,29.74 78.27,24.19 v1(78.78,24.19)
MIC_N: length 6.4
  TOP w0.508: C1C47.2 v1(19.24,7.66)
  IN1 w0.508: v1(19.98,12.66) 19.35,12.02 19.35,9.66 19.24,9.55 v1(19.24,7.66)
MIC_P:
  vias: v1(19.09,13.62)
MIC_PWR: length 3.8
  TOP w0.381: v1(45.28,61.88) 44.13,60.74 R11.1
  BOTTOM w0.305: v1(45.28,61.88) 45.94,61.88 46.4,61.42 J8L1.21
MPHY_EXT_PWR_GATE*: length 2
  TOP w0.102: TP22.1 108.37,62.42 v3(108.37,63.02)
  BOTTOM w0.102: U80.AM10 108.92,62.26 108.37,62.82 v3(108.37,63.02)
NAU_MIC_BYP: length 2.4
  TOP w0.254: U1.2 21.96,11.76 21.48,11.29 21.48,10.76 C1C41.1
NAU_VREF: length 3.6
  TOP w0.254: C1C44.2 24.82,10.7 24.5,10.7 24.47,10.73 24.3,10.73 v1(24.15,10.88) 24.12,10.9 23.44,10.9 22.96,11.38 U1.4
NUB_CN_BYP: length 8.7
  TOP w0.254: U1.14 26.95,15.77 27.57,15.15 C1C42.2 28.29,14.65 28.29,13.29 v1(28.64,12.94) 28.64,12.61 28.11,12.07 27.35,12.07 26.15,13.27 U1.9
NUB_CP_BYP: length 4.4
  TOP w0.254: C1C43.1 27.4,11.51 26.95,11.97 v1(26.7,11.97) 26.45,11.97 25.94,11.46 24.89,11.46 24.46,11.9 U1.7
NVDC*: length 12.8
  TOP w0.079: v4(70.47,77.15) 70.47,76.61 70.15,76.29 70.15,75.99 70.4,75.74 70.51,75.74
  TOP w0.102: 70.51,75.74 70.84,75.41 70.84,74.61 71.4,74.05 71.4,72.74 v1(71.8,72.35) 72.05,72.09 72.89,72.09 73.12,72.32 75.91,72.32 76.23,72 77.34,72 PR134.2
  BOTTOM w0.102: v4(70.47,77.15) 70.21,77.15 70.17,77.19 PU3254.K9
PCH_BATLOW*: length 26.8
  IN2 w0.079: v3(111.15,65.68) 111.15,66.54 107.94,69.76 107.94,70.13 108.14,70.34 108.14,70.95 107.72,71.38 106.09,71.38 105,72.47 103.44,72.47 103.08,72.83 101.8,72.83 100.89,73.74 99.17,73.74 98.93,73.98 98.51,73.98 98.29,73.76 95.74,73.76 95.36,73.38 94.75,73.38 94.61,73.24 94.12,73.24 93.74,72.85 93.74,71.94 94,71.69 v1(94.15,71.69)
  BOTTOM w0.102: U80.AU13 110.77,65.29 v3(111.15,65.68) ; RAP1077.2 95.49,72.86 94.32,71.69 v1(94.15,71.69)
PCH_BUZZER: length 16.7
  BOTTOM w0.076: 105.23,66.47 105.23,66.51 104.98,66.77 104.73,66.77 104.46,67.04 104.46,67.24 104.26,67.44 103.9,67.44 103.75,67.6 103.23,67.6 103.05,67.78
  BOTTOM w0.079: U80.AW5 105.69,66.01 105.23,66.47
  BOTTOM w0.102: RAP1046.2 98.34,76 RAP1433.1 98.11,75.95 97.91,75.75 97.91,75.32 98.19,75.04 98.19,74.86 98.29,74.76 98.29,73.41 97.93,73.06 97.93,72.74 v2(98.11,72.56) 98.58,72.09 98.58,70.19 100.98,67.78 103.05,67.78
PCH_EC_SLP_SUS*: length 64.3
  TOP w0.102: v1(86.15,64.83) 86.4,64.57 86.4,62.22 86.61,62.01 86.61,58.02 86.04,57.45 86.04,49.83 88.2,47.68 88.2,46.03 89.37,44.85 89.37,43.06 90.54,41.89 v1(90.54,41.27)
  IN1 w0.079: v3(112.12,63.09) 111.75,63.46 111.75,64.56 109.1,67.22 107.63,67.22 107.04,67.81 104.52,67.81 103.44,68.89 102.62,68.89 99.6,71.91 99.29,71.91 98.61,72.59 97.74,72.59 97.42,72.91 95.33,72.91 95,73.24 93.93,73.24 91.6,70.91 90.99,70.91 90.57,70.49 90.57,70.22 86.15,65.8 v1(86.15,64.83)
  BOTTOM w0.076: v3(112.12,63.09) U80.AN15
  BOTTOM w0.102: EUPM3247.A54 89.25,42.29 89.95,41.59 R5027.1 90.22,41.59 v1(90.54,41.27)
PCH_EDM: length 9
  BOTTOM w0.102: RAP1326.2 98.95,70.1 100.21,68.84 103.57,68.84 103.67,68.74 104.1,68.74 104.32,68.52 104.32,68.19 104.48,68.04 104.48,67.7 104.8,67.38 U80.AY3
PCH_JTAG_TCLK: length 7.7
  TOP w0.102: v3(137.39,40.84) 136.68,40.12 R136.1
  BOTTOM w0.076: U80.B56 135.63,46.22 135.63,46 135.69,45.89 135.69,45.63 135.51,45.44 135.51,44.41 136.72,43.21 136.72,42.79 136.88,42.62 136.88,41.28 137.03,41.13
  BOTTOM w0.102: 137.03,41.13 137.32,40.84 v3(137.39,40.84)
PCH_JTAG_TDI: length 11.5
  TOP w0.102: v3(137.41,42.22) 137.8,41.84 137.8,40.53 137.54,40.27 v1(137.54,40.21) R132.2
  BOTTOM w0.076: RAP1382.1 137.93,40.86 137.93,41.7 v3(137.41,42.22) 137.24,42.4 137.24,42.72 137.05,42.91 137.05,43.38 136.5,43.92 136.5,45.4 136.35,45.56 136.35,45.92 136.38,46.02 136.38,46.21 136.35,46.3 136.35,46.54 136.36,46.59 136.4,46.75 136.49,47.02 136.49,47.14 136.56,47.41 U80.D59
PCH_JTAG_TDO: length 10.1
  TOP w0.102: R133.2 138.04,37.74 RAP1377.1 137.49,38.59 v3(137.74,38.83)
  BOTTOM w0.076: U80.A56 135.33,45.68 135.33,44.36 136.55,43.14 136.55,42.72 136.72,42.55 136.72,40.96 137.38,40.3 137.38,39.23 v3(137.74,38.83)
PCH_JTAG_TMS: length 10.2
  TOP w0.102: RAP1384.1 140.1,39.46 R134.2 138.96,39.81 138.49,39.81 138,40.3 138,42.42 v3(137.69,42.72)
  BOTTOM w0.076: v3(137.69,42.72) 137.57,42.85 137.57,42.9 137.21,43.25 137.21,43.45 136.68,43.98 136.68,45.45 136.51,45.63 136.51,45.89 136.57,46 136.57,46.15 136.51,46.35 136.51,46.52 136.59,46.77 136.76,47.06 U80.C59
PCH_LPC_CLK1: length 7.3
  BOTTOM w0.076: U80.AY9 108.18,67.35 108.18,67.53 108.01,67.69 108.01,68.74 107.64,69.1
  BOTTOM w0.102: TP131.1 104.92,71.46 104.92,70.95 106.64,69.23 107.52,69.23 107.64,69.1
PCH_MEM_CFG0: length 11.1
  BOTTOM w0.079: 102.74,57.99 102.82,57.91 U80.AC1
  BOTTOM w0.102: R1040.1 R1044.2 95.25,60.72 95.5,60.97 95.85,60.97 96.28,60.54 96.28,60.08 96.76,59.61 96.76,59.43 97.16,59.03 97.23,59.03 97.23,59.02 97.52,59.02 v1(97.95,58.6) 98.37,58.18 98.86,58.18 99.05,57.99 102.74,57.99
PCH_MEM_CFG1: length 13.2
  BOTTOM w0.076: 102.96,58.15 102.86,58.25 102.6,58.25 ; 103.66,58.15 103.86,58.2 104.2,58.2 U80.AC2
  BOTTOM w0.079: 103.66,58.15 102.96,58.15
  BOTTOM w0.102: 102.6,58.25 99.14,58.25 98.94,58.46 98.67,58.46 98.65,58.47 98.65,58.47 98.43,58.69 98.43,58.7 97.9,59.23 97.31,59.23 97.24,59.23 96.96,59.51 96.96,59.7 96.59,60.07 96.59,60.11 96.57,60.14 96.57,60.66 96.39,60.83 95.95,61.28 R1045.2 94.99,61.28 94.94,61.22 94.45,61.22 R1041.1 94.17,62.31 v1(94.2,62.34)
PCH_MEM_CFG2: length 11.7
  BOTTOM w0.076: 103.59,57.71 103.74,57.64 103.94,57.64 103.95,57.65 104.06,57.69 104.24,57.69 104.42,57.64 104.58,57.64 104.69,57.68 104.93,57.91 U80.AC3
  BOTTOM w0.079: 102.63,57.8 102.72,57.71 103.59,57.71
  BOTTOM w0.102: 102.63,57.8 98.95,57.8 98.77,57.98 97.19,57.98 95.72,59.44 95.47,59.44 95.25,59.67 R1046.2 R1042.1
PCH_MEM_CFG3: length 11.9
  BOTTOM w0.076: 103.59,57.52 103.71,57.48 103.98,57.48 104.01,57.49 104.1,57.53 104.22,57.53 104.4,57.47 104.61,57.47 104.85,57.56 105.16,57.56 U80.AB4
  BOTTOM w0.079: 103.59,57.52 102.54,57.52 102.46,57.61
  BOTTOM w0.102: R1043.1 94.91,58.74 95.36,59.19 R1047.2 95.63,59.19 96.54,58.28 96.54,58.05 v1(96.55,58.04) 96.82,57.77 98.69,57.77 98.85,57.61 102.46,57.61
PCH_PLT_RST*: length 50
  TOP w0.102: U135.1 95.94,88.92 95.7,89.16 95.7,89.47 95.8,89.57 U135.2 97.75,89.57 RAP3048.1 98.01,89.01 97.58,88.58 95.42,88.58 v1(95.14,88.3)
  IN2 w0.079: v1(97.63,71.3) 97.78,71.15 99.35,71.15 100.07,70.42 104.18,70.42 106.89,67.71 107.14,67.71 108.66,66.18 108.66,65.57 108.99,65.24 108.99,63.38 v3(109.33,63.04)
  BOTTOM w0.102: v1(97.63,71.3) 97.35,71.57 97.35,73.52 96.39,74.49 96.39,74.64 94.71,76.31 94.71,77.46 93.18,78.99 93.18,80.4 92.5,81.08 92.5,81.73 91.74,82.49 91.74,83.65 92.22,84.13 92.22,85.35 92.68,85.81 92.68,86.57 v1(94.23,88.12) 94.4,88.3 v1(95.14,88.3) 95.63,88.78 RAP3051.2 95.63,90.1 QPM3390.1 95.21,90.32 C6004.2 ; U80.AN10 108.98,62.69 v3(109.33,63.04)
PCH_POPIRCOMP: length 18.2
  IN1 w0.152: v3(113.04,65.63) 113.04,65.8 112,66.84
  IN1 w0.305: 112,66.84 112,67.07 111.44,67.62 110.43,67.62 109.98,68.07 107.99,68.07 107.4,68.66 105.43,68.66 103.38,70.71 102.16,70.71 101.03,71.84 v3(100.45,71.84)
  BOTTOM w0.254: R46.1 99.18,72.95 99.18,72.37 99.55,72.01 100.28,72.01 v3(100.45,71.84) ; U80.AU16 v3(113.04,65.63)
PCH_PWROK: length 267.9
  TOP w0.079: v4(67.44,78.15) 67.3,78.29 66.57,78.29 66.13,78.72 TP110.1
  TOP w0.102: PU5.39 198.94,38.45 199.15,38.67 199.15,38.82 200.2,39.86 201.48,39.86 201.84,40.22 201.84,41.61 201.57,41.89 201.57,44.1 195.39,50.27 195.39,58.3 192.27,61.42 192.27,64.56 189.67,67.17 188.33,67.17 187.22,68.28 187.22,77.12 189.98,79.89 189.98,89.29 187.83,91.45 181.25,91.45 180.94,91.75 v1(180.43,91.75) ; v1(88.76,90.85) 88.03,90.12 88.03,81.99 C6003.2 87.48,81.19 87.72,80.95 v1(87.72,80.7) 87.72,78.51 v1(87.71,78.51)
  IN1 w0.079: v1(102.33,80.63) 102.33,80.73 101.77,81.29 100.93,81.29 100.5,81.72 100.5,82.28 99.94,82.84 98.16,82.84 97.71,83.29 94.05,83.29 93.89,83.45 90.46,83.45 v1(87.72,80.7) ; v1(87.71,78.51) 86.95,77.75 86.95,76.48 83,72.52 83,70.54 80.87,68.42 77.35,68.42 75.59,70.18 67.42,70.18 66.76,70.83 65.03,70.83 64.71,71.15 62.93,71.15 61.81,72.27 61.81,74.45 v1(62.92,75.57)
  IN2 w0.079: v1(88.76,90.85) 91.7,93.79 95.28,93.79 97.92,96.43 138.14,96.43 139.67,94.9 156.08,94.9 156.92,94.06 156.92,93.05 159.71,90.25 164.71,90.25 166.22,91.75 v1(180.43,91.75) ; v1(62.92,75.57) 63,75.65 65.09,75.65 65.6,76.16 65.6,76.64 65.86,76.9 66.2,76.9 v4(67.44,78.15)
  BOTTOM w0.076: U80.BA20 114.75,68.03 114.75,68.61 114.61,68.74 114.61,69.29 114.04,69.86 114.04,70.94 112.88,72.1 112.88,72.21
  BOTTOM w0.102: v1(102.33,80.63) 102.48,80.78 102.48,81.19 RAP1061.2 102.77,81.21 103.29,80.69 107.3,80.69 110.08,77.91 110.08,76.19 110.37,75.9 111.41,75.9 111.86,75.44 111.86,74.48 112.88,73.46 112.88,72.21 ; PU3254.G14 67.47,78.19 67.44,78.16 v4(67.44,78.15)
PCH_RSMRST*: length 95.2
  TOP w0.102: v1(84.45,44.34) 83.91,44.87 R1109.1 ; RAP1067.1 112.78,72.9 111.97,73.72 110.93,73.72 110.92,73.73 v3(110.92,73.73)
  IN1 w0.079: v1(73.64,44.51) 73.64,44.51 73.73,44.43 78.08,44.43 78.44,44.06 79.55,44.06 79.67,43.94 84.05,43.94 v1(84.45,44.34)
  IN2 w0.079: v3(110.92,73.73) 110.92,73.73 108.41,76.24 108.41,78.46 107.13,79.74 104.42,79.74 102.61,81.55 100.88,81.55 100.04,82.38 99.72,82.38 98.97,81.64 92.1,81.64 87.69,77.22 87.69,76.36 86.82,75.49 86.82,71.75 86.57,71.5 86.57,70.04 81.4,64.87 81.4,62.74 80.99,62.34 80.38,62.34 80.13,62.59 79.04,62.59 78.79,62.34 78.79,62.01 78.99,61.82 78.99,61.6 78.35,60.97 77.49,60.97 76.18,59.66 76.18,55.77 74.65,54.23 73.94,54.23 73.14,53.43 73.14,51.26 73.41,50.98 73.59,50.98 73.83,50.75 73.83,50.42 73.64,50.23 v1(73.64,44.51)
  BOTTOM w0.076: U80.AY17 113.26,67.27 113.36,67.37 113.48,67.51 113.53,67.67 113.53,67.81 113.47,68.04 113.47,68.18 113.53,68.3 113.53,68.57 113.33,68.77 113.33,70.2 112.04,71.49 112.04,71.65
  BOTTOM w0.102: v3(110.92,73.73) 110.92,73.73 110.92,73.71 112.04,72.59 112.04,71.65
PCH_RSMRST*_R: length 2.3
  TOP w0.102: R1109.2 83.72,46.11 83.57,45.96 83.57,45.08 v1(83.43,44.94)
  BOTTOM w0.102: v1(83.43,44.94) 83.43,45.04 83.71,45.32 EUPM3247.B45
PCH_SLP_LAN*: length 7
  BOTTOM w0.076: 109.86,71.45 110.75,70.56 110.84,70.56 111.91,69.5 111.91,68.68 111.8,68.57 111.8,67.09 111.95,66.76 111.95,66.61 U80.AW15
  BOTTOM w0.102: 109.86,71.45 109.86,71.45 109.23,72.08 TP79.1
PCH_SLP_S5*: length 8.8
  BOTTOM w0.076: U80.AY16 112.69,66.98 112.99,67.28 112.99,67.7 112.83,67.87 112.83,69.83 110.43,72.23
  BOTTOM w0.102: TP75.1 110.43,74.05 110.43,72.23
PCH_SLP_SA*: length 18.5
  IN1 w0.079: v3(113.04,63.09) 112.5,63.62 112.5,65.77 112.18,66.09 110.63,66.09 109.32,67.4 107.71,67.4 107.12,67.99 104.6,67.99 102.98,69.6 v1(102.62,69.6)
  BOTTOM w0.076: U80.AN16 v3(113.04,63.09)
  BOTTOM w0.102: v1(102.62,69.6) 101.39,69.6 TP78.1
PCH_SLP_WLAN*: length 4.4
  BOTTOM w0.076: U80.BB17 113.16,68.51 113.16,70.12 111.58,71.7 TP20.1
PCH_SUSACK*: length 23.1
  IN2 w0.079: v1(95.39,71.81) 95.73,71.47 97.14,71.47 97.35,71.69 97.79,71.69 98,71.48 99.48,71.48 100.21,70.75 104.4,70.75 107.12,68.04 107.27,68.04 108.84,66.47 108.84,65.64 109.38,65.1 v3(109.38,63.7)
  BOTTOM w0.076: v3(109.38,63.7) 109.73,63.34 U80.AP11
  BOTTOM w0.102: v1(95.39,71.81) 95.39,71.55 94.96,71.13 93.74,71.13 RAP1002.2 93.37,71.63 92.89,72.11 RAP1459.2
PCH_SUSPWRACK*: length 24.3
  IN2 w0.079: v1(94.84,72.85) 94.86,72.87 95.35,72.87 95.91,73.43 97.9,73.43 98.09,73.24 99.12,73.24 99.29,73.4 100.68,73.4 101.03,73.06 101.59,72.5 102.94,72.5 103.3,72.14 104.86,72.14 106.02,70.98 106.88,70.98 107.23,70.62 107.23,69.99 110.65,66.58 110.65,65.66 111.21,65.1 v3(111.21,64.36)
  BOTTOM w0.102: v1(94.84,72.85) 94.84,72.71 94.37,72.24 94.07,72.24 94,72.31 RAP1459.1 ; U80.AR13 110.84,63.99 v3(111.21,64.36)
PCH_SYSRST*: length 135.8
  TOP w0.102: R1071.1 74.13,44.16 74.13,44.76 73.83,45.07 73.83,46.39 v1(73.5,46.72) 73.32,46.9 72.54,46.9 69.12,43.47 68.01,43.47 67.73,43.75 67.73,47.28 66.21,48.8 63.92,48.8 63.16,48.04 63.16,47.3 62.04,46.18 55.68,46.18 55.14,46.72 v1(51.55,46.72) ; v1(102.11,43.39) 101.06,42.34 101.06,39.99 C6001.2
  IN1 w0.079: v1(102.11,43.39) 102.07,43.35 102.07,41.3 98.04,37.27 96.92,37.27 96.41,36.76 v1(96.41,35.8) 95.66,35.05 93.81,35.05 89.03,30.27 88.2,30.27 87.81,29.88 84.66,29.88 84.41,30.13 83.68,30.13 83.38,29.83 82.09,29.83 81.24,30.67 73.19,30.67 70.28,33.58 69.65,33.58 69.17,34.06 68.06,34.06 62.11,40.01 59.91,40.01 57.22,42.69 53.51,42.69 51.9,44.3 51.9,46.37 v1(51.55,46.72)
  IN2 w0.079: v1(96.41,35.8) 96.41,35.35 98.32,33.44 98.32,32.53 100.36,30.48 100.83,30.48 103.06,28.26 v1(103.06,27.8)
  BOTTOM w0.076: 104.83,45.66 104.83,45.91 105.01,46.09 105.44,46.09 U80.B5
  BOTTOM w0.102: v1(103.06,27.8) 103.06,27.13 101.92,25.99 101.92,20.25 102.84,19.34 102.84,18.83 101.93,17.92 CN17.28 ; 104.83,45.66 104.83,44.67 104.56,44.4 102.58,44.4 102.11,43.94 102.11,43.39 v1(102.11,43.39) RAP1003.2
PCH_SYSRST*_R: length 6.8
  TOP w0.102: v1(79.49,43.29) 79.49,43.57 79.21,43.85 78.97,43.85 78.96,43.86 78.58,43.86 78.24,43.52 v1(77.79,43.52) 77.59,43.72 76.34,43.72 75.96,43.34 75.62,43.34 75.54,43.42 R1071.2
  BOTTOM w0.102: v1(79.49,43.29) 79.5,43.3 79.5,43.51 78.97,44.04 EUPM3247.B32
PCHRXD_SERVOTXD: length 67.4
  IN2 w0.079: v1(106.65,29.73) 106.65,29.83 104.2,32.28 104.2,33.35 102.87,34.68 102.87,36.65 99.81,39.71 98.75,39.71 97.68,40.77 96.12,40.77 92.76,44.13 92.76,46.63 92.44,46.95 92.44,47.82 92.06,48.2 90.91,48.2 90.07,49.04 90.07,50.64 90.47,51.04 90.47,53.99 89.85,54.61 89.85,54.97 90.14,55.26 90.14,56.19 90.96,57.01 91.42,57.01 92.38,57.97 94.19,57.97 94.4,58.18 95.38,58.18 95.76,57.79 96.06,57.79 96.75,58.48 99.06,58.48 v3(99.38,58.8)
  BOTTOM w0.076: U80.AD1 103.41,58.68 102.73,58.68
  BOTTOM w0.102: v1(106.65,29.73) 106.27,29.34 106.27,27.93 102.33,24 v1(102.33,22.65) 102.33,21.29 103.55,20.07 103.55,17.81 104.33,17.03 CN17.16 ; v3(99.38,58.8) 99.5,58.68 102.73,58.68
PCHTXD_SERVORXD: length 74.1
  IN2 w0.079: v3(98.81,58.85) 98.74,58.78 95.8,58.78 95.73,58.85 94.67,58.85 94.07,58.25 93.24,58.25 92.82,58.67 91.75,58.67 91.22,58.14 91.22,57.67 89.86,56.31 89.86,55.38 89.57,55.09 89.57,54.5 90.19,53.87 90.19,51.16 89.79,50.76 89.79,48.92 92.48,46.23 92.48,44.01 96,40.49 97.56,40.49 98.68,39.38 99.75,39.38 102.59,36.53 102.59,34.56 103.91,33.24 103.91,32.16 106.24,29.83 106.24,29.47 106.55,29.17 v1(106.93,29.17)
  BOTTOM w0.076: 102.73,58.49 103.03,58.49 103.19,58.33 103.67,58.33 103.84,58.37 103.97,58.37 U80.AD2
  BOTTOM w0.102: v1(106.93,29.17) 106.93,28.13 107.59,27.47 107.59,22.13 v1(107.37,21.92) 107.15,21.7 107.15,20.1 107.69,19.57 107.69,15.43 107.31,15.04 106.76,15.04 105.92,14.21 104.64,14.21 104.3,13.86 104.3,12.9 103.93,12.53 CN17.17 ; 102.73,58.49 99.81,58.49 99.76,58.45 99.21,58.45 v3(98.81,58.85)
