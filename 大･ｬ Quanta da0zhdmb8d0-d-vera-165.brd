# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Nets (continued)
M_A_DQS_DP<3>: U80.AG70(DDRDQSP_IL11_NIL03) USM2000.P10(DQS2_T)
M_A_DQS_DP<4>: U80.AY64(DDRDQSP_IL02_NIL04) USM2001.P10(DQS2_T)
M_A_DQS_DP<5>: U80.BA60(DDRDQSP_IL03_NIL05) USM2001.G10(DQS1_T)
M_A_DQS_DP<6>: U80.AR65(DDRDQSP_IL12_NIL06) USM2001.L10(DQS0_T)
M_A_DQS_DP<7>: U80.AR60(DDRDQSP_IL13_NIL07) USM2001.D10(DQS3_T)
M_A_ODT<0>: U80.AT45(DDR0_ODT_0) USM2000.J8(ODT) USM2001.J8(ODT)
M_B_CA_A<0>: U80.AY48(DDR1_MA_5_CAA0) USM2002.R2(CA0)
M_B_CA_A<1>: U80.AP50(DDR1_MA_9_CAA1) USM2002.P2(CA1)
M_B_CA_A<2>: U80.BA48(DDR1_MA_6_CAA2) USM2002.N2(CA2)
M_B_CA_A<3>: U80.BB48(DDR1_MA_8_CAA3) USM2002.N3(CA3)
M_B_CA_A<4>: U80.AP48(DDR1_MA_7_CAA4) USM2002.M3(CA4)
M_B_CA_A<5>: U80.AP52(DDR1_BA_2_CAA5_BG0) USM2002.F3(CA5)
M_B_CA_A<6>: U80.AN50(DDR1_MA_12_CAA6) USM2002.E3(CA6)
M_B_CA_A<7>: U80.AN48(DDR1_MA_11_CAA7) USM2002.E2(CA7)
M_B_CA_A<8>: U80.AN53(DDR1_MA_15_CAA8_ACT_N) USM2002.D2(CA8)
M_B_CA_A<9>: U80.AN52(DDR1_MA_14_CAA9_BG1) USM2002.C2(CA9)
M_B_CA_B<0>: U80.BA43(DDR1_MA_13_CAB0) USM2003.R2(CA0)
M_B_CA_B<1>: U80.AY43(DDR1_CAS_N_CAB1_MA15) USM2003.P2(CA1)
M_B_CA_B<2>: U80.AY44(DDR1_WE_N_CAB2_MA14) USM2003.N2(CA2)
M_B_CA_B<3>: U80.AW44(DDR1_RAS_N_CAB3_MA16) USM2003.N3(CA3)
M_B_CA_B<4>: U80.BB44(DDR1_BA_0_CAB4) USM2003.M3(CA4)
M_B_CA_B<5>: U80.AY47(DDR1_MA_2_CAB5) USM2003.F3(CA5)
M_B_CA_B<6>: U80.BA44(DDR1_BA_1_CAB6) USM2003.E3(CA6)
M_B_CA_B<7>: U80.AW46(DDR1_MA_10_CAB7) USM2003.E2(CA7)
M_B_CA_B<8>: U80.AY46(DDR1_MA_1_CAB8) USM2003.D2(CA8)
M_B_CA_B<9>: U80.BA46(DDR1_MA_0_CAB9) USM2003.C2(CA9)
M_B_CKE<0>: U80.AN56(DDR1_CKE_0) USM2002.K3(CKE0)
M_B_CKE<1>: U80.AP55(DDR1_CKE_1) USM2002.K4(CKE1/NC)
M_B_CKE<2>: U80.AN55(DDR1_CKE_2) USM2003.K3(CKE0)
M_B_CKE<3>: U80.AP53(DDR1_CKE_3) USM2003.K4(CKE1/NC)
M_B_CLK_DDR_DN*<0>: U80.AN45(DDR1_CLK_N_0) USM2002.J2(CK_C)
M_B_CLK_DDR_DN*<1>: U80.AN46(DDR1_CLK_N_1) USM2003.J2(CK_C)
M_B_CLK_DDR_DP<0>: U80.AP45(DDR1_CLK_P_0) USM2002.J3(CK_T)
M_B_CLK_DDR_DP<1>: U80.AP46(DDR1_CLK_P_1) USM2003.J3(CK_T)
M_B_CS*<0>: U80.BB42(DDR1_CS_N_0) USM2002.L3(CS0_N) USM2003.L3(CS0_N)
M_B_CS*<1>: U80.AY42(DDR1_CS_N_1) USM2002.L4(CS1_N/NC) USM2003.L4(CS1_N/NC)
M_B_DQ<0>: U80.AY39(DDRDQ_IL04_NIL10_0) USM2002.R8(DQ20)
M_B_DQ<1>: U80.AW39(DDRDQ_IL04_NIL10_1) USM2002.T9(DQ17)
M_B_DQ<2>: U80.AY37(DDRDQ_IL04_NIL10_2) USM2002.R10(DQ22)
M_B_DQ<3>: U80.AW37(DDRDQ_IL04_NIL10_3) USM2002.R11(DQ23)
M_B_DQ<4>: U80.BB39(DDRDQ_IL04_NIL10_4) USM2002.T8(DQ16)
M_B_DQ<5>: U80.BA39(DDRDQ_IL04_NIL10_5) USM2002.R9(DQ21)
M_B_DQ<6>: U80.BA37(DDRDQ_IL04_NIL10_6) USM2002.T11(DQ19)
M_B_DQ<7>: U80.BB37(DDRDQ_IL04_NIL10_7) USM2002.T10(DQ18)
M_B_DQ<8>: U80.AY35(DDRDQ_IL05_NIL11_0) USM2002.B10(DQ29)
M_B_DQ<9>: U80.AW35(DDRDQ_IL05_NIL11_1) USM2002.C10(DQ25)
M_B_DQ<10>: U80.AY33(DDRDQ_IL05_NIL11_2) USM2002.C8(DQ27)
M_B_DQ<11>: U80.AW33(DDRDQ_IL05_NIL11_3) USM2002.C9(DQ26)
M_B_DQ<12>: U80.BB35(DDRDQ_IL05_NIL11_4) USM2002.B11(DQ28)
M_B_DQ<13>: U80.BA35(DDRDQ_IL05_NIL11_5) USM2002.C11(DQ24)
M_B_DQ<14>: U80.BA33(DDRDQ_IL05_NIL11_6) USM2002.B8(DQ31)
M_B_DQ<15>: U80.BB33(DDRDQ_IL05_NIL11_7) USM2002.B9(DQ30)
M_B_DQ<16>: U80.AU40(DDRDQ_IL14_NIL12_0) USM2002.P9(DQ0)
M_B_DQ<17>: U80.AT40(DDRDQ_IL14_NIL12_1) USM2002.N9(DQ1)
M_B_DQ<18>: U80.AT37(DDRDQ_IL14_NIL12_2) USM2002.M10(DQ6)
M_B_DQ<19>: U80.AU37(DDRDQ_IL14_NIL12_3) USM2002.N10(DQ2)
M_B_DQ<20>: U80.AR40(DDRDQ_IL14_NIL12_4) USM2002.M8(DQ4)
M_B_DQ<21>: U80.AP40(DDRDQ_IL14_NIL12_5) USM2002.M9(DQ5)
M_B_DQ<22>: U80.AP37(DDRDQ_IL14_NIL12_6) USM2002.M11(DQ7)
M_B_DQ<23>: U80.AR37(DDRDQ_IL14_NIL12_7) USM2002.N11(DQ3)
M_B_DQ<24>: U80.AT33(DDRDQ_IL15_NIL13_0) USM2002.E11(DQ12)
M_B_DQ<25>: U80.AU33(DDRDQ_IL15_NIL13_1) USM2002.E10(DQ13)
M_B_DQ<26>: U80.AU30(DDRDQ_IL15_NIL13_2) USM2002.D9(DQ15)
M_B_DQ<27>: U80.AT30(DDRDQ_IL15_NIL13_3) USM2002.E9(DQ14)
M_B_DQ<28>: U80.AR33(DDRDQ_IL15_NIL13_4) USM2002.F11(DQ8)
M_B_DQ<29>: U80.AP33(DDRDQ_IL15_NIL13_5) USM2002.F10(DQ9)
M_B_DQ<30>: U80.AR30(DDRDQ_IL15_NIL13_6) USM2002.F8(DQ11)
M_B_DQ<31>: U80.AP30(DDRDQ_IL15_NIL13_7) USM2002.F9(DQ10)
M_B_DQ<32>: U80.AY31(DDRDQ_IL06_NIL14_0) USM2003.R8(DQ20)
M_B_DQ<33>: U80.AW31(DDRDQ_IL06_NIL14_1) USM2003.T9(DQ17)
M_B_DQ<34>: U80.AY29(DDRDQ_IL06_NIL14_2) USM2003.R10(DQ22)
M_B_DQ<35>: U80.AW29(DDRDQ_IL06_NIL14_3) USM2003.R11(DQ23)
M_B_DQ<36>: U80.BB31(DDRDQ_IL06_NIL14_4) USM2003.R9(DQ21)
M_B_DQ<37>: U80.BA31(DDRDQ_IL06_NIL14_5) USM2003.T8(DQ16)
M_B_DQ<38>: U80.BA29(DDRDQ_IL06_NIL14_6) USM2003.T11(DQ19)
M_B_DQ<39>: U80.BB29(DDRDQ_IL06_NIL14_7) USM2003.T10(DQ18)
M_B_DQ<40>: U80.AY27(DDRDQ_IL07_NIL15_0) USM2003.C10(DQ25)
M_B_DQ<41>: U80.AW27(DDRDQ_IL07_NIL15_1) USM2003.C11(DQ24)
M_B_DQ<42>: U80.AY25(DDRDQ_IL07_NIL15_2) USM2003.C8(DQ27)
M_B_DQ<43>: U80.AW25(DDRDQ_IL07_NIL15_3) USM2003.B9(DQ30)
M_B_DQ<44>: U80.BB27(DDRDQ_IL07_NIL15_4) USM2003.B10(DQ29)
M_B_DQ<45>: U80.BA27(DDRDQ_IL07_NIL15_5) USM2003.B11(DQ28)
M_B_DQ<46>: U80.BA25(DDRDQ_IL07_NIL15_6) USM2003.B8(DQ31)
M_B_DQ<47>: U80.BB25(DDRDQ_IL07_NIL15_7) USM2003.C9(DQ26)
M_B_DQ<48>: U80.AU27(DDRDQ_IL16_NIL16_0) USM2003.P9(DQ0)
M_B_DQ<49>: U80.AT27(DDRDQ_IL16_NIL16_1) USM2003.N9(DQ1)
M_B_DQ<50>: U80.AT25(DDRDQ_IL16_NIL16_2) USM2003.M10(DQ6)
M_B_DQ<51>: U80.AU25(DDRDQ_IL16_NIL16_3) USM2003.N10(DQ2)
M_B_DQ<52>: U80.AP27(DDRDQ_IL16_NIL16_4) USM2003.M9(DQ5)
M_B_DQ<53>: U80.AN27(DDRDQ_IL16_NIL16_5) USM2003.M8(DQ4)
M_B_DQ<54>: U80.AN25(DDRDQ_IL16_NIL16_6) USM2003.M11(DQ7)
M_B_DQ<55>: U80.AP25(DDRDQ_IL16_NIL16_7) USM2003.N11(DQ3)
M_B_DQ<56>: U80.AT22(DDRDQ_IL17_NIL17_0) USM2003.F9(DQ10)
M_B_DQ<57>: U80.AU22(DDRDQ_IL17_NIL17_1) USM2003.F8(DQ11)
M_B_DQ<58>: U80.AU21(DDRDQ_IL17_NIL17_2) USM2003.F11(DQ8)
M_B_DQ<59>: U80.AT21(DDRDQ_IL17_NIL17_3) USM2003.F10(DQ9)
M_B_DQ<60>: U80.AN22(DDRDQ_IL17_NIL17_4) USM2003.D9(DQ15)
M_B_DQ<61>: U80.AP22(DDRDQ_IL17_NIL17_5) USM2003.E9(DQ14)
M_B_DQ<62>: U80.AP21(DDRDQ_IL17_NIL17_6) USM2003.E10(DQ13)
M_B_DQ<63>: U80.AN21(DDRDQ_IL17_NIL17_7) USM2003.E11(DQ12)
M_B_DQS_DN*<0>: U80.BA38(DDRDQSN_IL04_NIL10) USM2002.P11(DQS2_C)
M_B_DQS_DN*<1>: U80.AY34(DDRDQSN_IL05_NIL11) USM2002.D11(DQS3_C)
M_B_DQS_DN*<2>: U80.AT38(DDRDQSN_IL14_NIL12) USM2002.L11(DQS0_C)
M_B_DQS_DN*<3>: U80.AT32(DDRDQSN_IL15_NIL13) USM2002.G11(DQS1_C)
M_B_DQS_DN*<4>: U80.BA30(DDRDQSN_IL06_NIL14) USM2003.P11(DQS2_C)
M_B_DQS_DN*<5>: U80.AY26(DDRDQSN_IL07_NIL15) USM2003.D11(DQS3_C)
M_B_DQS_DN*<6>: U80.AR25(DDRDQSN_IL16_NIL16) USM2003.L11(DQS0_C)
M_B_DQS_DN*<7>: U80.AR22(DDRDQSN_IL17_NIL17) USM2003.G11(DQS1_C)
M_B_DQS_DP<0>: U80.AY38(DDRDQSP_IL04_NIL10) USM2002.P10(DQS2_T)
M_B_DQS_DP<1>: U80.BA34(DDRDQSP_IL05_NIL11) USM2002.D10(DQS3_T)
M_B_DQS_DP<2>: U80.AR38(DDRDQSP_IL14_NIL12) USM2002.L10(DQS0_T)
M_B_DQS_DP<3>: U80.AR32(DDRDQSP_IL15_NIL13) USM2002.G10(DQS1_T)
M_B_DQS_DP<4>: U80.AY30(DDRDQSP_IL06_NIL14) USM2003.P10(DQS2_T)
M_B_DQS_DP<5>: U80.BA26(DDRDQSP_IL07_NIL15) USM2003.D10(DQS3_T)
M_B_DQS_DP<6>: U80.AR27(DDRDQSP_IL16_NIL16) USM2003.L10(DQS0_T)
M_B_DQS_DP<7>: U80.AR21(DDRDQSP_IL17_NIL17) USM2003.G10(DQS1_T)
M_B_ODT<0>: U80.BA42(DDR1_ODT_0) USM2002.J8(ODT) USM2003.J8(ODT)
MA_A_ZQ0: RSM2007.2 USM2000.B3(ZQ0)
MA_A_ZQ1: RSM2008.2 USM2000.B4(ZQ1/NC)
MA_B_ZQ0: RSM1012.2 USM2001.B3(ZQ0)
MA_B_ZQ1: RSM1014.2 USM2001.B4(ZQ1/NC)
MB_A_ZQ0: RSM2075.2 USM2002.B3(ZQ0)
MB_A_ZQ1: RSM2076.2 USM2002.B4(ZQ1/NC)
MB_B_ZQ0: RSM2112.2 USM2003.B3(ZQ0)
MB_B_ZQ1: RSM2113.2 USM2003.B4(ZQ1/NC)
MECH_PWRBTN*: CN17.22 CR9.1(CATHODE) PU3254.L2(PWRBTNIN) RCP4216.2 U83.5(PWR_BTIN_L)
MECH_PWRBTN*_C: QPM3389.3(D) R5093.2 RCP4216.1
MECH_PWRBTN*_R: CRCP4043.4(D2+) CRCP4043.7(NC#2) JCP4056.25 QPM3389.1(S) R5093.1 R5094.1 SW1.2
MERGE_I2S_PCHRXD_AUDTXD: R3504.1 R5139.2 R5147.2
MERGE_I2S_PCHTXD_AUDRXD: R3499.1 R3503.1 U3.1(DIN) U5.1(DIN)
MERGE_I2S_SCL: C1107.1 R3502.1 R5138.2 U3.16(BCLK) U5.16(BCLK)
MERGE_I2S_SFRM: R3501.1 R5137.2 U3.14(LRCLK) U5.14(LRCLK)
MIC_N: C1C47.2 U1.32(MIC-)
MIC_P: C1C48.2 U1.31(MIC+)
MIC_PWR: J8L1.21 R11.1
MPHY_EXT_PWR_GATE*: TP22.1 U80.AM10(GPP_B_11_EXT_PWR_GATEB)
NAU_MIC_BYP: C1C41.1 U1.2(MICBIAS)
NAU_VREF: C1C44.2 U1.4(VREF)
NUB_CN_BYP: C1C42.2 U1.9(CPOUTN#1) U1.14(CPOUTN#2)
NUB_CP_BYP: C1C43.1 U1.7(CPOUTP)
NVDC*: PR134.2 PU3254.K9(NVDC*)
PCH_BATLOW*: RAP1077.2 U80.AU13(GPD_0_BATLOWB)
PCH_BUZZER: RAP1046.2 RAP1433.1 U80.AW5(GPP_B_14_SPKR)
PCH_EC_SLP_SUS*: EUPM3247.A54(GPIO012/KSO17) R5027.1 U80.AN15(SLP_SUSB)
PCH_EDM: RAP1326.2 U80.AY3(PCH_EDM)
PCH_JTAG_TCLK: R136.1 U80.B56(PCH_JTAG_TCK)
PCH_JTAG_TDI: R132.2 RAP1382.1 U80.D59(PCH_JTAG_TDI)
PCH_JTAG_TDO: R133.2 RAP1377.1 U80.A56(PCH_JTAG_TDO)
PCH_JTAG_TMS: R134.2 RAP1384.1 U80.C59(PCH_JTAG_TMS)
PCH_LPC_CLK1: TP131.1 U80.AY9(GPP_A_10_CLKOUT_LPC_1)
PCH_MEM_CFG0: R1040.1 R1044.2 U80.AC1(GP_C12_UART1_RXD_ISH_URT1_RXD)
PCH_MEM_CFG1: R1041.1 R1045.2 U80.AC2(GP_C13_UART1_TXD_ISH_URT1_TXD)
PCH_MEM_CFG2: R1042.1 R1046.2 U80.AC3(GP_C14_UART1_RTSB_ISH_URT1_RTB)
PCH_MEM_CFG3: R1043.1 R1047.2 U80.AB4(GP_C15_UART1_CTSB_ISH_URT1_CTB)
PCH_PLT_RST*: C6004.2 QPM3390.1(S) RAP3048.1 RAP3051.2 U80.AN10(GPP_B_13_PLTRSTB) U135.1(INB) U135.2(INA)
PCH_POPIRCOMP: R46.1 U80.AU16(PCH_POPIRCOMP)
PCH_PWROK: C6003.2 PU5.39(VR_READY) PU3254.G14(PCH_PWROK) RAP1061.2 TP110.1 U80.BA20(PCH_PWROK)
PCH_RSMRST*: R1109.1 RAP1067.1 U80.AY17(RSMRSTB)
PCH_RSMRST*_R: EUPM3247.B45(GPIO143/RSMRST#) R1109.2
PCH_SLP_LAN*: TP79.1 U80.AW15(SLP_LANB)
PCH_SLP_S5*: TP75.1 U80.AY16(GPD_10_SLP_S5B)
PCH_SLP_SA*: TP78.1 U80.AN16(GPD_6_SLP_AB)
PCH_SLP_WLAN*: TP20.1 U80.BB17(GPD_9_SLP_WLANB)
PCH_SUSACK*: RAP1002.2 RAP1459.2 U80.AP11(GPP_A_15_SUSACKB)
PCH_SUSPWRACK*: RAP1459.1 U80.AR13(GPP_A_13_SUSWARNB_SUSPWRDNACK)
PCH_SYSRST*: C6001.2 CN17.28 R1071.1 RAP1003.2 U80.B5(SYS_RESETB)
PCH_SYSRST*_R: EUPM3247.B32(NRESET_OUT/GPIO121) R1071.2
PCHRXD_SERVOTXD: CN17.16 U80.AD1(GPP_C_20_UART2_RXD)
PCHTXD_SERVORXD: CN17.17 U80.AD2(GPP_C_21_UART2_TXD)
PCIE_RCOMPN: RAP1053.2 U80.F5(PCIE_RCOMPN)
PCIE_RCOMPP: RAP1053.1 U80.E5(PCIE_RCOMPP)
PCIE_RX_DN*<1>: CN8.43 U80.H13(PCIE_1_USB3_5_RXN)
PCIE_RX_DP<1>: CN8.41 U80.G13(PCIE_1_USB3_5_RXP)
PCIE_TX_C_DN*<1>: C827.2 U80.B17(PCIE_1_USB3_5_TXN)
PCIE_TX_C_DP<1>: C828.2 U80.A17(PCIE_1_USB3_5_TXP)
PCIE_TX_DN*<1>: C827.1 CN8.37
PCIE_TX_DP<1>: C828.1 CN8.35
PCIE_WAKE*: R1138.1 RAP1011.2 U80.BB15(WAKEB)
PD_WP*: R5153.2 U95.34(PA13)
PE_RST*: CN8.52 Q127.1(S) R5020.2
PECI: R5037.1 R5079.2 U80.A54(PECI)
PGVR2: PU3254.H13(PGVR2) TP160.1
PM_CPUPWRGD: TP39.1 U80.A68(CPUPWRGD)
PM_LANPHY_ENABLE: TP17.1 U80.AW17(GPD_11_LANPHYPC)
PM_SLP_S0*: EUPM3247.A39(GPIO141/PWM3/LED3) PU3254.C10(STANDBY*) TP100.1 U80.AT11(GPP_B_12_SLP_S0B)
PM_SLP_S3*: EUPM3247.A21(GPIO206) PC1280.1 PR73.2 PR80.2 PU20.9(ON) PU23.2(ON) PU50.2(INA) PU51.5(ON2) PU3254.C14(ENG) PU3254.L14(ENF) TP101.1 U80.AP15(GPD_4_SLP_S3B)
PM_SLP_S4*: EUPM3247.A24(GPIO200) PR55.1 PU3254.B2(ENVR4) PU3254.D13(ENB) TP102.1 U80.BA16(GPD_5_SLP_S4B)
PM_SUS_STAT*: TP77.1 U80.BA11(GPP_A_14_SUS_STATB_ESPI_RESETB)
PMON_PSYS: EUPM3247.B21(ADC4/GPIO062) PR42.2 PR43.1
PP3300_USB_PD_EN: PR97.1 PU22.2(ON) U95.38(PA15) U124.2(G1) U124.5(G2) U126.2(G1) U126.5(G2)
PRE: R687.2 U26.15(PRE)
PWRLED#: EUPM3247.A60(GPIO133/PWM0) Q109.2(BASE)
RCOMP: RAP1323.1 U80.E60(NOA_RCOMP)
ROP_ACSWON*: PU3254.M3(ACSWON*) TP116.1
ROP_BAT1SWON*: PU3254.J2(BAT1SWON*) TP117.1
ROP_BAT2SWON*: PU3254.K3(BAT2SWON*) TP118.1
ROP_BC_ACOK: PR100.2 PU3254.N14(LVA) RPM3455.2
ROP_DSW_PWROK: CAP14472.2 PR75.2 PU3254.M15(DPWROK) R3587.1 RAP1005.2 TP106.1 U80.BB20(DSW_PWROK)
ROP_EC_INT*: EUPM3247.A31(PS2_CLK1/GPIO050) PR102.2 PU3254.E14(PMIC_INT*)
ROP_EC_PWRBTN*: PR101.2 PU3254.M5(EC_ONOFF*) R1179.2
ROP_I2C_SLAVEADDR: PR74.2 PR90.1 PU3254.N4(SLAVEADDR)
ROP_PCH_PWRBTN*: PU3254.N2(PCH_PWRBTN*) RAP1458.2
ROP_RESET*: PU3254.D9(RESET*) TP115.1
ROP_RSMRST_PWRGD*: EUPM3247.A36(VCC_PWRGD/GPIO063) PR104.2 PU3254.F16(RSMRST/PWRGD*) TP107.1
ROP_SHUTDWN*: PR21.2 PR111.2 PU3254.C8(SHUTDOWN*)
ROP_SYS_PWROK: PU3254.K13(SYS_PWROK) RAP1004.2 TP111.1 U80.B6(SYS_PWROK)
ROP_VCCST_PWRGD: PU3254.C1(VCCST_PWRGD) RAP1062.2 RAP1064.1 TP108.1
RTC_RST*: CAP1073.2 R1048.1 RAP1072.2 RAP3052.2 U80.AM16(RTESTB)
RTC_X1: C291.1 RAP1088.1 U80.AM18(RTCX1) X6.1
RTC_X2: C289.1 RAP1088.2 U80.AM20(RTCX2) X6.2
SA_BOOT_DRV: PR70.1 PU9.2(BOOT)
SA_CSN: PC24.1 PC1282.2 PC9107.1 PR12.1 PR33.1 PR141.1 PR144.1 PR173.2
SA_CSP: PC24.2 PC9107.2 PR120.1 PR144.2 PR155.1 PU5.27(ISUMP_C)
SA_FCCM: PU5.29(FCCM_C) PU9.7(FCCM)
SA_HG_DRV: PU9.1(UGATE) PU10.1(G1)
SA_LG_DRV: PU9.5(LGATE) PU10.8(G2)
SA_PWM: PU5.30(PWM_C) PU9.3(PWM)
SA_SW_DRV: PC1187.1 PL7.1 PR120.2 PR190.1 PU9.8(PHASE) PU10.9(S1/D2)
SCREW_SPI_WP*: QAP1009.2(G) R895.2 R896.2 R5153.1 RAP1407.2 RPM3457.2 UAP1008.1(INB) UAP1008.2(INA) UPM3253.3(W\P\(IO2))
SCREW_SPI_WP_STATUS: QAP1009.3(D) R1178.2 U80.AD4(GPP_C_23_UART2_CTSB)
SD_CD*_R_R: CN17.19 RAP1360.2
SD_CDZ: CN2.30 R4434.1 R5009.2 R5107.2 RAP1360.1
SD_RCOMP: RAP1050.1 U80.AB7(SD_RCOMP)
SERVO_EC_RST*: CN17.14 CR15.1(CATHODE)
SERVO_EC_SPI_CLK: CN17.9 RPM3462.1 RPM3579.1
SERVO_EC_SPI_CS*: CN17.10 RPM3463.1 RPM3468.2 RPM3578.1
SERVO_EC_SPI_MISO: CN17.12 RPM3461.1 RPM3581.1
SERVO_EC_SPI_MOSI: CN17.11 RPM3460.1 RPM3580.1
SERVO_PCH_SPI_CLK: CN17.2 RAP1406.2
SERVO_PCH_SPI_CLK_R: R866.2 RAP1406.1 UAP1012.6(CLK)
SERVO_PCH_SPI_CS*: CN17.3 RAP1405.2
SERVO_PCH_SPI_CS*_R: R865.2 RAP1405.1 RAP1412.1 UAP1012.1(C\S\)
SERVO_PCH_SPI_HOLD*: CN17.7 RAP1408.1
SERVO_PCH_SPI_MISO: CN17.5 RAP1409.2
SERVO_PCH_SPI_MOSI: CN17.4 RAP1410.2
SERVO_SPI_WP*: CN17.40 RAP1407.1
SKL_CNL*: RAP1324.1 U80.C64(SKL_CNL_N)
SM_INTRUDER*: RAP1075.2 U80.AP16(INTRUDERB)
SM_RCOMP_0: RAP1019.1 U80.AR18(DDR_COMP_0)
SM_RCOMP_1: RAP1018.1 U80.AT18(DDR_COMP_1)
SM_RCOMP_2: RAP1017.1 U80.AU18(DDR_COMP_2)
SMB_CLK: RAP1051.1 U80.R7(GPP_C_0_SMBCLK)
SMB_DATA: RAP1052.1 U80.R8(GPP_C_1_SMBDATA)
SOC_CATERR*: R49.2 U80.D63(CATERR_N)
SOC_PROCHOT*: QPM3251.3(D) R66.2 R1076.1 R1180.1
SOC_THRMTRIP*: C6005.2 R88.2 U80.C63(THRMTRIPB)
SOURCE_EC_PROCHOT*: EUPM3247.B19(GPIO151) R1074.2 R1075.2
SPI_TPM_IRQ*: RAP1424.2 U80.H2(GPP_E_0_SATAXPCIE_0_SATAGP_0) U82.18(PIRQ#)
SPK_OUT_L_N: R1A3.1 U5.10(OUTN)
SPK_OUT_L_P: R1A4.1 U5.9(OUTP)
SPK_OUT_R_N: R1A5.2 U3.10(OUTN)
SPK_OUT_R_P: R1A6.2 U3.9(OUTP)
SRTCRST*: C6002.2 CAP1079.2 QPM3391.3(D) RAP1078.2 RAP3052.1 U80.AN18(SRTCRSTB)
SUS_CLK: CN8.50 TP120.1 U80.BA17(GPD_8_SUSCLK)
SUSLED#: EUPM3247.B17(GPIO127/PECI_RDY) Q110.2(BASE)
SW1: PL1.1 PR69.2 PU3045.5(VSW) PU3254.T13(SWVR1)
SW2: PL2.1 PU3254.K15(SWVR2_K15) PU3254.K16(SWVR2_K16)
SW3: PL8.2 PR68.2 PU3044.5(VSW) PU3254.A13(SWVR3)
SW4: PL9.2 PR67.2 PU3047.5(VSW) PU3254.A4(SWVR4)
SWVR5: PL10.2 PR66.2 PU3048.5(VSW) PU3254.T4(SWVR5)
SYS_SHDN#: PR9.2 PR21.1 PR76.2
TABLET_MODE: QPM3389.2(G) TP252.1
TCH_I2C_SCL: J8L1.32 Q137.1(S) R346.2 R5155.2
TCH_I2C_SDA: J8L1.33 Q137.4(S) R338.2 R5154.2
TCH_INTR*: J8L1.29 Q139.1(S) R5158.1 R6006.2
TCH_PNL_INTR*: Q139.3(D) R5159.1 R6006.1 RAP1453.2 U80.A7(GPP_E_7_CPU_GP_1)
TCH_PNL_RST*: CR16.1(CATHODE) R1064.2 R6007.1 U80.N12(GPP_E_23_DDPD_CTRLDATA)
TCH_RST*: CR16.2(ANODE) J8L1.30 R6007.2
TLS_CONFIDENTIALITY: R892.2 R1097.2 U80.R10(GPP_C_2_SMBALERTB)
TP_DDR0_ALERT*: R1117.1 U80.AW50(DDR0_ALERT_N)
TP_DDR1_ALERT*: R1120.1 U80.AN43(DDR1_ALERT_N)
TP_DDR1_PARITY: TP33.1 U80.AP43(DDR1_PARITY)
TP_DDR3_DRAMRST*: TP34.1 U80.AT13(DRAM_RESETB)
TP_M_A_A<3>: R1115.1 U80.BA50(DDR0_MA_3)
TP_M_A_A<4>: R1116.1 U80.BB52(DDR0_MA_4)
TP_M_B_A<3>: R1118.1 U80.BB46(DDR1_MA_3)
TP_M_B_A<4>: R1119.1 U80.BA47(DDR1_MA_4)
TPCLK_CN: CN3.2 TP171.1
TPDATA_CN: CN3.3 TP170.1
TPM_PLTRST#: QPM3390.3(D) R1105.2 RAP3049.2 RAP3051.1
TPM_PLTRST#_R: R1105.1 U82.17(RST#)
TPM_PP: RAP1422.2 RAP1423.2 U82.7(PP)
TPM_SPI_CS*: R5125.2 RAP3021.1 U80.AU1(SPI0_TPM_CSB)
TPM_SPI_CS*_R: R5125.1 U82.20(CS#)
TRACKPAD_INT*: C785.1 R790.2 R5084.2 RAP1452.2 U80.AR10(GPP_B_5_SRCCLKREQB_0) U80.BA5(GPP_B_3_CPU_GP_2)
TRACKPAD_PWR_EN: EUPM3247.B55(GPIO053/PS2_CLK3) RCP4021.1 U86.3(ON)
TS_EN_R: J8L1.28 R5157.2
U86_6: C842.2 U86.6(CT)
USB1_BC_DN: CN2.12 EU1B2.11(DM_IN)
USB1_BC_DP: CN2.13 EU1B2.10(DP_IN)
USB2_1_DN*: LCP4022.4 U90.18(D-)
USB2_1_DP: LCP4022.1 U90.19(D+)
USB2_A_DN*: EUCP4040.11(DM_IN) LCP4041.1
USB2_A_DN_CONN*: J2.2(D-) LCP4041.2 U6.4(I/O-2)
USB2_A_DP: EUCP4040.10(DP_IN) LCP4041.4
USB2_A_DP_CONN: J2.3(D+) LCP4041.3 U6.7(I/O-5)
USB2_COMP: R1056.2 U80.AB6(USB2_COMP)
USB2_DN*<1>: U80.AB9(USB2N_1) U90.4(DNH)
USB2_DN*<2>: J8L1.35 U80.AD6(USB2N_2)
USB2_DN*<3>: CN8.5 U80.AH3(USB2N_3)
USB2_DN*<5>: EU1B2.2(DM_OUT) U80.AJ1(USB2N_5)
USB2_DN*<6>: CN2.21 U80.AF6(USB2N_6)
USB2_DN*<9>: EUCP4040.2(DM_OUT) U80.AG1(USB2N_9)
USB2_DP<1>: U80.AB10(USB2P_1) U90.3(DPH)
USB2_DP<2>: J8L1.36 U80.AD7(USB2P_2)
USB2_DP<3>: CN8.3 U80.AJ3(USB2P_3)
USB2_DP<5>: EU1B2.3(DP_OUT) U80.AJ2(USB2P_5)
USB2_DP<6>: CN2.22 U80.AF7(USB2P_6)
USB2_DP<9>: EUCP4040.3(DP_OUT) U80.AG2(USB2P_9)
USB2_OC*<0>: PU2.C1(OCFLAGB) RAP1434.2 U80.A9(GPP_E_9_USB2_OCB_0)
USB2_OC*<1>: RAP1438.2 TP253.1 U80.C9(GPP_E_10_USB2_OCB_1)
USB2_OC*<2>: EU1B2.13(F\A\U\L\T\) RAP1436.2 U80.D9(GPP_E_11_USB2_OCB_2)
USB2_OC*<3>: EUCP4040.13(F\A\U\L\T\) RAP1440.2 U80.B9(GPP_E_12_USB2_OCB_3)
USB2_OTG_ID: EUPM3247.B40(32KHZ_OUT/GPIO013) U80.AG3(USB2_ID)
USB2_OTG_VBUS_SNS: EUPM3247.A46(GPIO105/TACH1) U80.AG4(USB2_VBUSSENSE)
USB3_A_TX_DN*: J2.8(STDA_SSTX-) LCP4042.3 U6.10(I/O-6)
USB3_A_TX_DP: J2.9(STDA_SSTX+) LCP4042.2 U6.1(I/O-1)
USB3_RX_DN*<1>: U80.H8(USB3_1_RXN) U96.17(RX-)
USB3_RX_DN*<2>: CN2.28 U80.J6(USB3_2_SSIC_1_RXN)
USB3_RX_DN*<3>: CN2.18 U80.J10(USB3_3_SSIC_2_RXN)
USB3_RX_DN*<4>: J2.5(STDA_SSRX-) U6.6(I/O-4) U80.E10(USB3_4_RXN)
USB3_RX_DP<1>: U80.G8(USB3_1_RXP) U96.16(RX+)
USB3_RX_DP<2>: CN2.27 U80.H6(USB3_2_SSIC_1_RXP)
USB3_RX_DP<3>: CN2.19 U80.H10(USB3_3_SSIC_2_RXP)
USB3_RX_DP<4>: J2.6(STDA_SSRX+) U6.5(I/O-3) U80.F10(USB3_4_RXP)
USB3_TX_DN*<1>: U80.C13(USB3_1_TXN) U96.12(TX-)
USB3_TX_DN*<2>: CN2.25 U80.B13(USB3_2_SSIC_1_TXN)
USB3_TX_DN*<3>: CN2.15 U80.B15(USB3_3_SSIC_2_TXN)
USB3_TX_DN*<4>: CCP4195.2 U80.C15(USB3_4_TXN)
USB3_TX_DN*<4>_C: CCP4195.1 LCP4042.4
USB3_TX_DP<1>: U80.D13(USB3_1_TXP) U96.11(TX+)
USB3_TX_DP<2>: CN2.24 U80.A13(USB3_2_SSIC_1_TXP)
USB3_TX_DP<3>: CN2.16 U80.A15(USB3_3_SSIC_2_TXP)
USB3_TX_DP<4>: CCP4196.2 U80.D15(USB3_4_TXP)
USB3_TX_DP<4>_C: CCP4196.1 LCP4042.1
USB_A0_ILIM_SEL: R5099.2 U80.P3(GPP_D_10_ISH_SPI_CLK)
USB_A0_PWR_EN: EU1B2.5(EN) EUPM3247.B68(GPIO036) RCP4221.1
USB_A0_STATUS*: CPM4192.2 EU1B2.9(S\T\A\T\U\S\) EUCP4040.4(ILIM_SEL) QCP4112.3(D)
USB_A1_ILIM_SEL: R5098.2 U80.P4(GPP_D_11_ISH_SPI_MISO)
USB_A1_PWR_EN: EUCP4040.5(EN) EUPM3247.B8(GPIO067) RCP4029.1
USB_A1_STATUS*: CPM4189.2 EUCP4040.9(S\T\A\T\U\S\) QCP4007.3(D) R5103.2
USB_C0_BC12_INT*: EUPM3247.B50(GPIO124/SHD_MISO) U90.12(INTB)
USB_C0_CC1_CONN: C947.1 JCP4038.A5(CC1) U97.5(OUT#1) U97.6(OUT#2) U124.4(S2) U124.6(D1) U133.1
USB_C0_CC1_DEVICE_ODL: R980.2 R981.1 R5039.1 U95.32(PA11)
USB_C0_CC1_MCU: C887.2 R982.2 U95.12(PA2)
USB_C0_CC1_TX_DATA: R983.2 U95.40(PB4)
USB_C0_CC1_VCONN_EN: R3614.1 U95.19(PB1) U97.3(EN)
USB_C0_CC2_CONN: C948.1 JCP4038.B5(CC2) U98.5(OUT#1) U98.6(OUT#2) U126.4(S2) U126.6(D1) U133.2
USB_C0_CC2_DEVICE_ODL: R985.2 R986.1 R5043.1 U95.33(PA12)
USB_C0_CC2_MCU: C888.2 R987.2 U95.14(PA4)
USB_C0_CC2_TX_DATA: R988.2 U95.16(PA6)
USB_C0_CC2_VCONN_EN: R3611.1 U95.20(PB2) U98.3(EN)
USB_C0_HOST_HIGH: R980.1 R985.1 R5038.2 R5042.2 U95.13(PA3)
USB_C0_TX_CLKIN: R977.2 U95.39(PB3)
USB_C0_TX_CLKOUT: R977.1 U95.45(PB8)
USB_C0_VBUS_WAKE*: EUPM3247.B56(GPIO152/PS2_DAT3) PQ129.3(D) PR8.1 R1163.2 U95.3(PC14-OSC32_IN)
USB_C1_TX_CLK: U95.26(PB13) U95.28(PB15)
USB_C_REF: C946.1 R999.1 R1000.2 U95.11(PA1)
USB_MCU_EC_INT*: EUPM3247.A1(GPIO122/SHD_SCLK) RPM3123.2 U95.37(PA14)
USB_WAKEOUT_INTRUDET*: TP18.1 U80.AT15(GPD_7_USB2_WAKEOUTB)
USBA_PO_ILIMSEL: EU1B2.4(ILIM_SEL) R5103.1
USBC1_DN*: JCP4038.A7(DN1) JCP4038.B7(DN2) LCP4022.3 U4.3
USBC1_DP: JCP4038.A6(DP1) JCP4038.B6(DP2) LCP4022.2 U4.4
USBC1_R_SSRXN*<1>: L11.2 U96.24(RX1-)
USBC1_R_SSRXN*<2>: L13.3 U96.33(RX2-)
USBC1_R_SSRXP<1>: L11.3 U96.25(RX1+)
USBC1_R_SSRXP<2>: L13.2 U96.34(RX2+)
USBC1_R_SSTXN*<1>: CCP4167.1 L10.2
USBC1_R_SSTXN*<1>_C: CCP4167.2 U96.27(TX1-)
USBC1_R_SSTXN*<2>: CCP4169.1 L12.3
USBC1_R_SSTXN*<2>_C: CCP4169.2 U96.30(TX2-)
USBC1_R_SSTXP<1>: CCP4166.1 L10.3
USBC1_R_SSTXP<1>_C: CCP4166.2 U96.28(TX1+)
USBC1_R_SSTXP<2>: CCP4168.1 L12.2
USBC1_R_SSTXP<2>_C: CCP4168.2 U96.31(TX2+)
USBC1_SSRXN*<1>: JCP4038.B10(SSRXN1) L11.1 UCP4034.4(D2+) UCP4034.7(NC#2)
USBC1_SSRXN<2>: JCP4038.A10(SSRXN2) L13.4 UCP4036.2(D1-) UCP4036.9(NC#3)
USBC1_SSRXP<1>: JCP4038.B11(SSRXP1) L11.4 UCP4034.5(D2-) UCP4034.6(NC#1)
USBC1_SSRXP<2>: JCP4038.A11(SSRXP2) L13.1 UCP4036.1(D1+) UCP4036.10(NC#4)
USBC1_SSTXN*<1>: JCP4038.A3(SSTXN1) L10.1 UCP4034.1(D1+) UCP4034.10(NC#4)
USBC1_SSTXN*<2>: JCP4038.B3(SSTXN2) L12.4 UCP4036.5(D2-) UCP4036.6(NC#1)
USBC1_SSTXP<1>: JCP4038.A2(SSTXP1) L10.4 UCP4034.2(D1-) UCP4034.9(NC#3)
USBC1_SSTXP<2>: JCP4038.B2(SSTXP2) L12.1 UCP4036.4(D2+) UCP4036.7(NC#2)
USBC1_SSUSBC1_AUX_RFU1: JCP4038.A8(SBU1) R1C11.1 RCP4186.2 U133.4
USBC1_SSUSBC1_AUX_RFU1_C: R1C11.2 U96.22(SBU1)
USBC1_SSUSBC1_AUX_RFU2: JCP4038.B8(SBU2) R1C12.1 RCP4184.2 U133.3
USBC1_SSUSBC1_AUX_RFU2_C: R1C12.2 U96.21(SBU2)
USBPD_BOOT0: CN17.43 R3609.1 U130.2(G1)
USBPD_WAKE: EUPM3247.B23(ADC2/GPIO060) U95.2(PC13)
USBPDRXD_SERVOTXD: CN17.21 U95.31(PA10)
USBPDTXD_SERVORXD: CN17.25 U95.30(PA9)
V_BOOSTIN_SENSE: C968.1 EUPM3247.A22(ADC1/GPIO057) R1022.2 R1023.1
VBSTVR1: PC1264.1 PU3254.R14(VBSTVR1)
VBSTVR3: PC3.1 PU3254.B13(VBSTVR3)
VBSTVR4: PC1265.1 PU3254.C4(VBSTVR4)
VBSTVR5: PC1266.1 PU3254.R4(VBSTVR5)
VDCSNS: PR135.1 PR180.1 PU3254.G1(VDCSNS)
VREF1.25V: PC9111.1 PU3254.D1(VREF1V25)
VREFDQ_CHA: CSM1017.1 CSM2029.1 RAP1027.2 RAP1031.2 RAP1032.1 USM2000.J11(VREF_DQ) USM2001.J11(VREF_DQ)
VREFDQ_CHB: CSM2097.1 CSM2129.1 RAP1028.2 RAP1033.2 RAP1034.1 USM2002.J11(VREF_DQ) USM2003.J11(VREF_DQ)
WAKE_EVENT: QPM3374.3(D) R3597.2 U123.1(CP)
WAKE_L*: CR9.2(ANODE) QPM3372.3(D) QPM3373.3(D) QPM3374.2(G) R3596.1
WIFI_CLK_REQ*: Q113.3(D) R1113.2 U80.AT7(GPP_B_6_SRCCLKREQB_1)
WIFI_PCIE_CLK_DN: CN8.49 U80.B42(CLKOUT_SRC_N_1)
WIFI_PCIE_CLK_DP: CN8.47 U80.A42(CLKOUT_SRC_P_1)
WLAN_OFF*: C1105.1 R5078.2 R5117.1
WLAN_PCIE_WAKE*: R1139.2 R1144.1 U80.AP7(GPP_B_16_GSPI0_CLK)
XCLK_BIASREF: RAP1091.1 U80.E42(XCLK_BIASREF)
XDP_BPM<2>: TP23.1 U80.B54(MBP_N_2)
XDP_BPM<3>: TP24.1 U80.C56(MBP_N_3)
XDP_JTAG_TRST*: TP271.1 U80.B59(CPU_JTAG_TRST_N) U80.C61(PCH_TRSTB)
XDP_OVERRIDE*: PU11.6(C) PU15.6(C) RAP1386.1
XDP_SPI0_IO2: RAP1044.1 RAP1385.1
XDP_TCLK0: RAP1351.1 RAP1352.1
XDP_TCLK_JTAGX: RAP1352.2 U80.A59(JTAGX)
XDP_TDI: RAP1381.2 RAP1382.2
XDP_TDO: RAP1376.2 RAP1377.2
XDP_TMS: RAP1383.2 RAP1384.2
XTAL24_IN: RAP1087.1 RAP1089.2 U80.E37(XTAL_IN)
XTAL24_IN_R: C186.2 RAP1089.1 X5.3
XTAL24_OUT: RAP1087.2 RAP1090.2 U80.E35(XTAL_OUT)
XTAL24_OUT_R: C187.2 RAP1090.1 X5.1
N621143: TP254.1 U80.AD12(GPP_F_11_I2C5_SCL_ISH_I2C2_SCL)
N826528: Q5.2(BASE) R873.2
N2450832: TP223.1 U80.BA7(GPP_A_21_ISH_GP_3)
N2450844: TP224.1 U80.AY7(GPP_A_22_ISH_GP_4)
N2523339: TP225.1 U80.AP13(GPP_A_12_BM_BUSYB_ISH_GP_6)
N3058945: CN3.8 TP169.1
N3058949: CN3.7 QPM3362.1(S) RCP4037.2
N3652181: TP172.1 U90.20(ID)
N5008121: CPM3436.2 CRPM3518.1(CATHODE) CRPM3519.1(CATHODE) EUPM3247.A34(VBAT)
N5041796: R5050.1 U123.5(Q)
N5043216: C1025.1 QPM3371.3(D) R3591.1 U123.6(R\D)
N5044582: C1026.1 R3592.1 U123.7(S\D)
N5046702: C1027.1 QPM3372.2(G) R3593.1
N5047139: C1028.1 QPM3373.2(G) R3594.1
N5279525: R979.1 U124.3(D2)
N5880717: R3604.2 U130.5(G2) U130.6(D1)
N5880753: R3608.1 U95.44(BOOT0) U130.3(D2)
N16755433: PR141.2 PR155.2
N16801182: R1A1.2 R1A2.1 U1.16(GPIO1)
N16801272: C1C45.1 U1.11(CPCA)
N16801274: C1C45.2 U1.10(CPCB)
N16801326: TP275.1 U80.AH9(GPP_F_4_I2C2_SDA)
N16801328: TP276.1 U80.AH10(GPP_F_5_I2C2_SCL)
N16820602: R1B27.1 R1D11.1 U3.2(GAIN_SLOT)
N16823303: C1P4.1 J1P2.1 R1A6.1
N16823308: C1P5.1 J1P2.2 R1A5.1
N16823317: C1P6.2 J1P2.3 R1A3.2
N16823326: C1P7.2 J1P2.4 R1A4.2
N16913701: TP277.1 U80.W4(GPP_C_10_UART0_RTSB)
N16916260: PC9105.1 PR159.2 PU5.4(COMP_B)
N16918204: PC9096.2 PR56.2 PR117.1 PR172.2
N16918510: PR149.1 PR151.1 PR172.1 PU5.5(FB_B)
N16919684: PR143.1 PR162.2 PR177.2
N16924869: PC1295.1 PR57.2 PR116.2 PU5.6(RTN_B)
N16926106: PC9091.2 PR156.2
N16926742: PR150.1 PR156.1 PR168.1 PU5.25(FB_C)
N16929406: PC9093.2 PR60.2 PR115.1 PR168.2
N16931159: PC1297.1 PR61.2 PR114.2 PU5.26(RTN_C)
N16935900: PR131.1 PR186.1 PU5.20(ISUMN_A)
N16938871: PC9115.1 PR183.1
N16939091: PC9104.1 PR183.2 PU5.16(COMP_A)
N16939409: PC9121.1 PR153.1
N16939413: PR130.1 PR153.2 PR184.2 PU5.17(FB_A)
N16939441: PC9095.1 PR58.1 PR112.1 PR184.1
N16939455: PC9095.2 PR130.2
N16949411: PC9106.1 PR169.1 PU5.24(COMP_C)
N17027313: PU3254.L12(TRIP*) TP114.1
N17027315: PU3254.M16(DS3_VREN) TP112.1
N17027317: PU3254.N12(LVB) TP113.1
N17027335: PR41.1 PU3254.P3(TEMP_ALERT*)
N17027643: PU3254.M13(1HZ) TP71.1
N17032291: PR148.1 PU3254.M11(ILIMVR1)
N17032349: PR54.2 PR136.1 PU3254.D11(ENVR3)
N17032386: PR187.1 PU3254.F3(ILIMVR4)
N17032403: PR53.2 PR75.1 PR76.1 PU3254.J14(ENVR2)
N17032485: PC1266.2 PR66.1
N17032524: PR23.1 PU3254.G12(FBVR2N)
N17032530: PR36.2 PR77.1 PU3254.R15(ENVR1)
N17032584: PC1264.2 PR69.1
N17032600: PC1265.2 PR67.1
N17032831: PR189.1 PU3254.G10(FBVR2P)
N17032859: JP3571.2 PU3254.H15(VINVR2_H15) PU3254.H16(VINVR2_H16)
N17034135: JP3545.1 PC1178.1 PC1179.1 PC1290.2 PU10.2(D1#4) PU10.3(D1#1) PU10.4(D1#2) PU10.10(D1#3)
N17034237: PC1187.2 PR70.2
N17035157: PC1183.2 PR84.1
N17035494: JP949.2 PC1270.1 PC1299.1 PC1300.1 PU14.5(S#1) PU14.7(S#2) PU16.5(S#1) PU16.7(S#2)
N17035762: PR55.2 PR72.2 PR73.1 PU11.3(A)
N17037951: PR40.2 PR83.1 PU19.9(ON)
N17037965: JP948.2 PC1275.1 PU21.5(S)
N17037990: JP952.2 PC1271.1 PU18.5(S)
N17038224: PR37.2 PU18.2(ON)
N17042523: PC9116.1 PR159.1
N17042671: PC9098.2 PR131.2
N17042817: PC9120.2 PR151.2
N17042887: PR140.2 PR154.2
N17043312: PC9097.1 PR181.2 PU5.8(ISUMN_B)
N17043331: PR142.2 PR163.2 PR175.2
N17043387: PC25.1 PR173.1 PU5.28(ISUMN_C)
N17043416: PC9117.1 PR185.2 PU5.14(IMON_A)
N17043440: PC9119.1 PR182.2 PU5.2(IMON_B)
N17043480: PC9096.1 PR149.2
N17043520: PC9093.1 PR150.2
N17043522: PC9118.1 PR166.2 PU5.23(IMON_C)
N17043589: PR167.2 PU5.32(PROG1)
N17043595: PR157.1 PU5.31(PROG2)
N17043625: PC1296.1 PR59.1 PR113.2 PU5.18(RTN_A)
N17043865: PC9099.2 PR169.2
N17043953: PR139.2 PR152.2
N17044003: PC9097.2 PR129.2
N17044099: PR143.2 PU5.3(NTC_B)
N17058418: PR171.1 PU2.C2(ISET)
N17135957: JP3507.2 PC1276.1 PU22.5(S)
N17145676: PC3.2 PR68.1
N17298006: LED1.2(BLU) R1085.2
N17298012: LED1.3(ORA) R1086.1
N17298024: Q109.3(COLLECTOR) R1085.1
N17298033: Q110.3(COLLECTOR) R1086.2
N17298607: RCP4074.2 UCP4007.6(A\L\E\R\T\/T\H\E\R\M\2\)
N17298609: CCP4093.1 QCP4010.1(EMITTER) UCP4006.5(DXN2)
N17298611: CCP4093.2 QCP4010.2(BASE) QCP4010.3(COLLECTOR) UCP4006.4(DXP2)
N17298615: CCP4092.1 QCP4009.1(EMITTER) UCP4006.3(DXN1)
N17298617: CCP4092.2 QCP4009.2(BASE) QCP4009.3(COLLECTOR) UCP4006.2(DXP1)
N17298639: CCP4094.1 QCP4011.1(EMITTER) UCP4007.3(DXN)
N17298643: CCP4094.2 QCP4011.2(BASE) QCP4011.3(COLLECTOR) UCP4007.2(DXP)
N17298741: RCP4072.1 UCP4006.8(A\L\E\R\T\/T\H\E\R\M\2\)
N17306009: TP279.1 U80.A45(EDP_TXN_2)
N17306011: TP281.1 U80.A47(EDP_TXN_3)
N17306013: TP280.1 U80.B45(EDP_TXP_2)
N17306015: TP282.1 U80.B47(EDP_TXP_3)
N17307145: TP233.1 U80.AD3(GPP_C_22_UART2_RTSB)
N17343677: TP274.1 U80.AB2(GPP_C_9_UART0_TXD)
N17344720: TP278.1 U80.AB1(GPP_C_8_UART0_RXD)
N17578279: PC12.1 PR190.2
N17586894: JP3546.1 PC1151.1 PC1152.1 PC1294.2 PU8.6(VIN)
N17603103: PR84.2 PU8.4(BOOT)
N17603106: PC1183.1 PU8.5(PHASE)
N17609123: PC17.2 PU8.19(GL)
N17618076: JP3547.1 PC1180.1 PC1181.1 PC1291.2 PU7.6(VIN)
N17619692: PC1184.2 PR65.2
N17619721: PR65.1 PU7.4(BOOT)
N17619724: PC1184.1 PU7.5(PHASE)
N17621976: PC14.2 PR3.2
N17622303: PC15.2 PR4.2
N17647625: PC19.2 PU7.19(GL)
N17647893: PC21.2 PU6.19(GL)
N17648742: JP3539.1 PC1176.1 PC1177.1 PC1289.2 PU6.6(VIN)
N17649316: PC1186.2 PR35.2
N17649331: PC1186.1 PU6.5(PHASE)
N17649342: PR35.1 PU6.4(BOOT)
N17675286: PC22.2 PR5.1
N17682231: PC25.2 PR12.2
N17700132: PC1314.1 PR161.1 PU4.18(VDD)
N17700177: PU4.13(ASGATE) TP168.1
N17700263: PU4.26(OTGPG/CMOUT) TP167.1
N17700277: PC1326.2 PR133.1
N17700362: PC1154.1 PC1155.1 PC1156.1 PC1157.1 PC1158.1 PQ3.1(VIN) PR2.2 PR124.2
N17700446: PL3.1 PQ2.6(VSW1) PQ2.7(VSW2) PQ2.8(VSW3)
N17700456: PL3.2 PQ3.6(VSW1) PQ3.7(VSW2) PQ3.8(VSW3) PR13.2
N17700505: PR45.2 PU4.21(SDA)
N17700521: PR44.2 PU4.22(SCL)
N17702601: PD4.3(COMMON ANODE) PR128.2
N17714367: PC27.1 PR13.1
N17724245: PC1167.1 PC1292.2 PQ1.1(S1) PQ1.2(S2) PQ1.3(S3) PR1.2 PR126.2
N17733184: PJ2.5 PR119.1
N18047939: CN8.56 R5117.2
N18050341: QPM3382.3(D) R5051.2
N18054146: QPM3383.3(D) R5038.1
N18054148: QPM3383.1(S) R5039.2
N18054178: QPM3384.3(D) R5042.1
N18054180: QPM3384.1(S) R5043.2
N18054762: R5041.1 U95.21(PB10)
N18057554: EUPM3247.A49(GPIO157/BC_CLK) R5040.2
N18061734: QPM3387.3(D) R1074.1
N18066115: EUPM3247.B51(GPIO201) R5026.1
N18074160: EUPM3247.A59(GPIO136/PWM1) TP285.1
N18133793: HOLE2.3 HOLE2.4 R896.1
N18165504: C1089.2 EUPM3247.B42(VREF_PECI) R5080.1 R5081.2
N18167653: CCP4019.1 RPM3589.2 RPM3590.2 U86.1(VIN#1) U86.2(VIN#2)
N18168197: CCP4216.1 R5090.1 R5091.1 U108.5(VCC)
N18169543: EUPM3247.A40(GPIO132/PECI_DAT) R5078.1 R5079.1
N18180469: R41.2 R5092.2 U132.5(SET)
N18329473: R5063.1 R5073.2 U83.3(KSI)
N18329506: C590.2 R5144.1 R5145.1 U83.1(VDD)
N18329561: R5066.1 U83.4(KSO_INV)
N18329587: R5068.1 U83.6(KSI_SW)
N18329644: Q135.1(S) R5106.2 U83.12(BATTERY_DISABLE)
N18329650: R5072.2 R5152.2 U83.11(KSO_SW)
N18365336: PQ129.2(G) PR98.1 PR160.1
N18366094: PC1196.2 PC1197.2 PQ130.3(D) PR137.1
N18377771: EU1B2.6(CTL1) R5095.2
N18377774: EU1B2.7(CTL2) R5096.2
N18377783: EU1B2.8(CTL3) R5097.2
N18381748: QCP4007.2(G) R1082.1 R5099.1 R5101.1
N18388802: EUPM3247.B2(GPIO011/KSO16) R5104.1
N18401065: JP5100.1 PC1279.1 PU13.5(S#1) PU13.7(S#2)
N18408850: PR78.1 PU17.2(ON)
N18408888: JP5076.1 PC1278.1 PU17.5(S)
N18408896: PC1312.1 PU17.7(CAP)
N18423443: CPM4431.2 RAP3045.1 RAP3046.1 U135.5(VCC)
N18483788: EUPM3247.A17(GPIO147) R5084.1
N18760372: R5107.1 U80.BB11(GPP_A_7_PIRQAB)
N18781214: R679.2 U26.16(REXT)
N18801748: D41.1(CATHODE) R680.1 R5116.1
N18910683: R899.1 R5142.2
N18942554: PR8.2 PU3.A2(ACK)
N19425416: R5137.1 U138.3(1Y)
N19426006: R5138.1 U138.6(2Y)
N19431978: PC309.2 PU51.12(CT1)
N19431980: PC310.2 PU51.10(CT2)
N19465433: R3499.2 U138.8(3Y)
N19466265: R5146.2 U138.13(4O\E\)
N19743292: R5139.1 U138.12(4A)
N19797876: R1181.2 U95.36(PF7)
N19797932: R1182.2 U95.35(PF6)
N20576888: PC46.1 PR14.2 PU1.5(VCC)
N20576892: PR15.1 PU1.1(SET)
N20576900: PR9.1 PU1.3(O\T\)
N20656100: R870.1 UAP1008.4(OUT Y)
N21137008: C1104.2 U26.17(CEXT)
N21153040: R1D4.1 U3.4(S\D\_\M\O\D\E\)
N21154824: R1D13.1 U5.4(S\D\_\M\O\D\E\)
N21155644: R1B28.1 R1D12.1 U5.2(GAIN_SLOT)
N21157615: EUCP4040.15(ILIM_LO) RCP4194.1
N21157617: EUCP4040.16(ILIM_HI) RCP4193.1
N21158850: EUCP4040.6(CTL1) R1157.2
N21158856: EUCP4040.7(CTL2) RCP4190.2
N21158858: EUCP4040.8(CTL3) RCP4191.2
N21160290: QCP4112.2(G) R5098.1 R5100.2 R5102.1
N21357334: EUPM3247.B20(PS2_CLK2/GPIO051) TP189.1
N21357342: EUPM3247.B36(PS2_DAT0/GPIO047) TP190.1
N21357344: EUPM3247.B49(GPIO145) TP202.1
N21533023: R870.2 RAP1413.1 UAP1012.3(W\P\(IO2))
N21533075: RAP1408.2 RAP1414.1 UAP1012.7(H\O\L\D\(IO3))
N21758250: TP250.1 USM2006.E9(VSF#1/NC)
N21758257: TP251.1 USM2006.E10(VSF#2/NC)
N22199236: TP143.1 U97.4(NC)
N22281245: RAP1432.2 U80.AR7(GPP_B_18_GSPI0_MOSI)
N22353822: R5159.2 U80.H1(GPP_E_8_SATA_LEDB)
N22390889: QPM3360.3(D) R1048.2
N22574114: PR142.1 PU5.15(NTC_A)
N22721118: C437.1 D4.2 MR1.2(VCC) R5160.1
N22721124: MR1.1(OUTPUT) R5118.2
N22725849: EUPM3247.B48(GPIO020/I2C2_CLK0) TP286.1
N22725878: EUPM3247.A45(GPIO021/I2C2_DAT0) TP287.1
N22748003: Q125.3(COLLECTOR) R5004.1
N22748005: LED2.2(BLU) R5004.2
N22748034: LED2.3(ORA) R3550.1
N22748061: Q121.3(COLLECTOR) R3550.2
N22804113: C6002.1 R6002.2
N22891221: J8L1.25 R788.1
N22969897: R217.2 RAP1044.2 U80.AW2(SPI0_IO_2)
N22970777: RAP1385.2 RAP1386.2 RAP1387.1
N23269888: C6003.1 R6003.2
N23269899: C6001.1 R6001.2
N26714628: TP273.1 U80.F43(CLKOUT_ITPXDP_N)
N26714631: TP272.1 U80.E43(CLKOUT_ITPXDP_P)
N26714753: RAP1457.1 RAP1458.1 RAP3020.2 U80.BA15(GPD_3_PWRBTNB)
N26719512: CAP1024.1 RAP1025.1
N26719514: CAP1022.1 RAP1023.1
N26719516: CAP1020.1 RAP1021.1
N26723495: TP256.1 U80.D56(PRDY_N)
N26723498: TP255.1 U80.D61(PREQ_N)
N26726690: R900.1 R5140.2
N26726693: R5143.2 U80.D7(GPP_D_20_DMIC_DATA_0)
N26726696: R5141.2 U80.C8(GPP_D_18_DMIC_DATA_1)
N26727015: R5009.1 U80.W10(GPP_G_5_SD_CDB)
N26779690: Q111.1(S) R1129.1 USM2006.K5(RSTN)
N26904437: CN8.55 R1138.2 R1139.1
N26904440: CN8.53 Q113.1(S) R3491.2
N28249672: R899.2 U80.H5(GPP_D_19_DMIC_CLK_0)
N28980903: R1162.2 TP245.1 U95.4(PC15-OSC32_OUT)
N28980950: TP61.1 U95.22(PB11)
N28980961: TP57.1 U95.6(PF1-OSC_OUT)
N29007898: C887.1 R981.2 R982.1 R983.1 U124.1(S1)
N29008264: C888.1 R986.2 R987.1 R988.1 U126.1(S1)
N29176585: RCP4219.2 U96.14(A0)
N29176590: RCP4220.2 U96.35(CONF0/A1)
N29248528: R984.1 U126.3(D2)
N29442582: R936.2 U90.9(ENB)
N30351738: TP242.1 U80.AY5(GPP_B_4_CPU_GP_3)
N30351897: TP268.1 U80.C55(MBP_N_0)
N30351899: TP269.1 U80.D55(MBP_N_1)
N30362779: TP213.1 U80.N1(GPP_D_7_ISH_I2C1_SDA)
N30362781: TP212.1 U80.N2(GPP_D_8_ISH_I2C1_SCL)
N30362883: TP179.1 U80.AP5(GPP_B_21_GSPI1_MISO)
N30362885: TP178.1 U80.AN7(GPP_B_20_GSPI1_CLK)
N30362887: TP177.1 U80.AM5(GPP_B_19_GSPI1_CSB)
N30362896: RAP1035.1 TP180.1 U80.AN5(GPP_B_22_GSPI1_MOSI)
N30363404: TP221.1 U80.AY8(GPP_A_18_ISH_GP_0)
N30363406: TP222.1 U80.BB7(GPP_A_20_ISH_GP_2)
N30363918: R891.1 U80.AU4(SPI0_IO_3)
N30475256: TP48.1 U80.AM23(VCCIO_SENSE)
N30475258: TP49.1 U80.AM22(VSSIO_SENSE)
N30480410: TP51.1 U80.AN11(GPP_B_0_CORE_VID_0_AN11)
N30480412: TP52.1 U80.AN13(GPP_B_1_CORE_VID_1_AN13)
N30494257: CN17.41 RAP1364.2
N30904684: TP257.1 U80.B67(NOA_N_1)
N30904810: TP258.1 U80.C67(NOA_N_7)
N30904937: TP259.1 U80.G68(NOA_N_11)
N30904939: TP260.1 U80.H70(NOA_N_12)
N30904941: TP261.1 U80.G71(NOA_N_13)
N30905052: TP262.1 U80.H69(NOA_N_14)
N30905054: TP263.1 U80.G70(NOA_N_15)
N30905112: TP264.1 U80.E63(NOA_STBN_0)
N30905114: TP265.1 U80.F63(NOA_STBP_0)
N30905174: TP266.1 U80.E66(NOA_STBN_1)
N30905176: TP267.1 U80.F66(NOA_STBP_1)
N30905354: RAP1322.2 U80.E8(ITP_PMODE)
N31079742: TP76.1 U80.BB5(PGDMON)
N32035570: CN17.39 TP83.1
N32035571: CN17.23 TP81.1
N32035572: CN17.47 TP84.1
N32035573: CN17.49 TP85.1
N32035574: CN17.27 TP82.1
N32035627: CN17.26 TP90.1
N32035628: CN17.46 TP88.1
N32035629: CN17.50 TP86.1
N32035630: CN17.24 TP91.1
N32035631: CN17.30 TP89.1
N32035632: CN17.48 TP87.1
N32755302: TP238.1 U80.AT52(DDR0_PARITY)
N32759666: TP98.1 U80.A65(SKTOCC_N)
N33306658: TP146.1 U98.4(NC)
N33307497: TP147.1 U95.41(PB5)
N33438171: TP191.1 U80.AB3(GPP_C_11_UART0_CTSB)
N33482633: TP159.1 U90.16(VBUSDET)
N34031444: EUPM3247.A8(GPIO055) R1158.1
N34032189: EUPM3247.B35(GPIO033) R895.1
N34033106: EUPM3247.B9(GPIO210) TP249.1
N34033220: EUPM3247.B30(GPIO123) TP246.1
N34033282: EUPM3247.A50(GPIO161/BC_INT#) TP211.1
N34033404: EUPM3247.A32(GPIO035) R1179.1
N34033440: EUPM3247.A16(GPIO031) TP232.1
N34033647: EUPM3247.B62(GPIO204) TP204.1
N34176799: R1180.2 U80.C65(PROCHOT_N)
N34797635: TP148.1 U80.B52(EDP_DISP_UTIL)
N34797754: TP230.1 U80.E48(DDI2_AUXN)
N34797764: TP231.1 U80.F48(DDI2_AUXP)
N35698555: QPM3362.3(D) R790.1
N176432920: SW1.4 TP243.1
N176432980: SW1.1 TP244.1
N232682640: C6004.1 R6008.2
N232686630: C6005.1 R6009.2

Pads without a net: CN2 4 10; CN8 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 54 58 59 60 61 62 64 65 66 67 68 70 71 73; CN12 13 14; CRCP4042 1 2 9 10; CRCP4043 1 2 9 10; J8L1 4 5 20 24; JCP4056 6 7 10 26 28 29 30; NOREF#2 1; NOREF#4 1; NOREF#6 1; NOREF#8 1; NOREF#9 1; NOREF#11 1; NOREF#12 1; NOREF#14 1; NOREF#15 1; NOREF#16 1; NOREF#17 1; NOREF#18 1; PU6 3; PU7 3; PU8 3; PU3254 A1 A2 A9 A15 A16 B1 B9 B16 D7 G8 K5 L8 R1 R8 R16 T1 T2 T15 T16; U3 5 6 12 13; U4 1 6; U5 5 6 12 13; U6 3 8; U26 20; U80 A3 A4 A6 A11 A19 A21 A23 A25 A26 A27 A29 A31 A33 A36 A38 A40 A52 A69 AB11 AB12 AB13 AB62 AC63 AD9 AD10 AE62 AE63 AF8 AF9 AG62 AH1 AH2 AH7 AH8 AH11 AH12 AJ62 AK12 AK13 AK32 AK42 AK43 AK45 AK46 AK48 AK50 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL25 AL27 AL43 AL46 AL50 AL53 AL56 AL60 AL61 AL63 AM48 AM50 AM52 AM53 AM56 AM58 AN8 AP8 AP56 AR56 AT5 AT8 AT43 AU2 AU5 AU7 AU8 AU56 AU58 AU63 AW1 AW7 AW42 AW48 AW68 AW69 AW70 AW71 AY1 AY2 AY4 B2 B3 B7 B11 B19 B21 B23 B25 B26 B27 B29 B31 B33 B36 B38 B40 B69 B70 BA3 BA4 BA8 BA9 BA68 BA70 BB2 BB3 BB4 BB9 BB57 BB66 BB68 BB69 C2 C4 C7 C11 C12 C16 C17 C19 C20 C21 C23 C24 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C41 C42 C54 C70 C71 D1 D3 D4 D5 D12 D16 D17 D19 D20 D21 D23 D24 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D41 D42 D54 D71 E1 E2 E3 E16 E20 E22 E23 E25 E27 E28 E30 E38 E40 E61 F6 F11 F15 F16 F18 F20 F21 F25 F30 F46 F52 F60 F61 F65 G1 G2 G3 G4 G11 G15 G16 G18 G21 G46 G61 G65 H3 H11 H16 H63 J1 J2 J3 J68 J71 K32 K45 K46 L13 N11 P1 P2 P62 R9 U2 U3 U4 U11 U12 V3 V62 W1 W2 W7 W8 W11 W12; U82 3 4 5 6 10 11 12 13 15 25 26 27 28 29 30 31; U90 2 5 6 7 10 15; U95 5 10 15 17 18 25 27 29 46; U123 3; UCP4006 7; UCP4007 4; USM2000 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; USM2001 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; USM2002 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; USM2003 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; USM2006 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 3005 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 7 vias
v3: diameter 0.457, hole 0.254, TOP to BOTTOM, 1360 vias
v4: diameter 0.45, hole 0.25, TOP to BOTTOM, 77 vias
v5: diameter 0.61, hole 0.356, TOP to BOTTOM, 731 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
+3V3DSW_PG: length 1.3
  TOP w0.079: TP136.1 70.03,81.23 v4(69.49,81.23)
  BOTTOM w0.102: v4(69.49,81.23) 69.01,81.23 PU3254.B11
+V1P00A: length 1.2
  BOTTOM w0.508: RPM3298.2 v1(106.77,39.61)
  vias: v1(78.1,59.01) v1(78.48,59.55) v1(78.71,58.99) v1(79.72,60.85) v1(80.41,60.64) v1(87.98,55.91) v1(88.01,51.56) v1(88.42,52.05) v1(88.61,51.47) v1(88.61,50.83) v1(88.63,50.22) v1(88.7,52.58) v1(89.03,53.1) v1(89.03,52.04) v1(89.25,51.47) v1(89.33,52.57) v1(106.34,31.5) v1(106.52,32.24) v5(73.53,69.43) v5(74.19,68.13) v5(74.19,67.37) v5(74.29,69.65) v5(74.24,68.89) v5(74.57,66.76) v5(75.07,69.65) v5(75.02,68.87) v5(75.02,68.11) v5(75.02,67.37)
+V1P00A_GND: length 19
  TOP w0.102: v1(76.42,71.51) 75.81,72.12 73.78,72.12 73.55,71.89 73.55,71.36 73.36,71.17 73.02,71.17 72.86,71.33 v1(72.59,71.33) 72.31,71.05 PR31.1
  IN1 w0.079: v4(69,77.66) 69.41,77.66 70.07,78.32 70.07,78.32 70.3,78.55 70.6,78.55 70.83,78.32 70.83,78.17 71.14,77.86 72.92,77.86 73.9,76.88 73.9,76.44 75.02,75.32 75.67,75.32 76.46,74.53 76.46,71.55 v1(76.42,71.51)
  BOTTOM w0.102: PU3254.K11 68.97,77.64 v4(69,77.66)
+V1P00S_VCCST: length 252.4
  TOP w0.508: 113.76,29.62 118.2,29.62 118.69,30.11 v1(134.23,30.11) ; PR118.1 v1(202.91,33.72) ; v1(205.58,33.74) 205.58,35.6 PR174.2 ; R5081.1 75.15,46.46 v1(73.51,48.1) 71.87,49.74 v1(71.87,50.66)
  IN1 w0.254: v1(75.81,71.51) 75.81,72.8 76.19,73.19 76.19,74.42 75.57,75.04 74.83,75.04 73.45,76.42 73.45,76.9 72.77,77.58 71.06,77.58 v4(70.44,78.19) ; v1(71.87,50.66) 71.25,50.66 69.4,52.51 67.96,52.51 66.57,53.91 66.57,54.45 65.52,55.49 64.94,55.49 64.51,55.91 64.51,57.94 63.92,58.53 63.92,60.15 63.33,60.75 v1(62.46,60.75)
  IN1 w0.381: v1(134.23,30.11) 138.75,34.63 138.75,35.85 140.57,37.66 144.37,37.66 v1(144.81,38.11)
  IN2 w0.254: v1(67.3,61.3) 64.89,63.71 64.89,65.23 65.38,65.73 66.17,65.73 67.89,67.44 67.89,69.53 68.47,70.11 71.89,70.11 71.99,70.21 74.96,70.21 75.81,71.07 v1(75.81,71.51)
  IN2 w0.508: v1(71.87,50.66) 71.66,50.44 71.66,46.52 72.56,45.62 72.56,45.15 72.88,44.83 72.88,44.34 73.34,43.88 73.34,41.49 73.83,40.99 73.83,40.38 74.87,39.34 74.87,36.33 75.61,35.59 75.61,34.37 76.29,33.69 76.29,33.07 76.64,32.72 76.64,31.91 78.62,29.93 78.62,28.66 80.16,27.12 80.7,27.12 84.4,23.43 86.12,23.43 90.06,19.49 91.67,19.49 94.66,16.51 94.66,16.51 94.95,16.22 95.19,16.22 95.39,16.03 v1(96.36,16.03) ; v1(199.79,28.79) 192.24,28.79 190.57,30.46 188.18,30.46 187.18,29.46 184.46,29.46 183.46,30.46 170.6,30.46 167.68,27.54 159.74,27.54 159.18,28.1 153.05,28.1 151.32,29.83 138.12,29.83 137.51,30.44 134.87,30.44 134.54,30.11 v1(134.23,30.11)
  BOTTOM w0.254: RAP1450.2 146.39,40.69 RAP1451.2 ; v1(67.3,61.3) 67.17,61.43 63.14,61.43 v1(62.46,60.75) ; v4(70.44,78.19) 70.47,78.19 70.97,77.7 PU3254.K7 ; v3(115.86,51.63) 115.86,51.53 U80.K21 115.46,51.13 114.98,51.13 U80.K20 ; U80.A18 v3(113.8,44.44)
  BOTTOM w0.381: RAP1324.2 148.14,40.09 RAP1062.1 147.34,40.09 RAP1451.2 147.59,39.49 147.59,38.54 147.16,38.11 v1(144.81,38.11) R88.1 143.71,38.7 R49.1
  BOTTOM w0.508: v1(205.58,33.74) 202.94,33.74 v1(202.91,33.72) 202.38,33.19 202.38,31.38 v1(199.79,28.79) ; v1(96.36,16.03) 96.36,16.86 96.23,16.98 96.23,17.82 96.39,17.97 100.63,22.21 100.63,25.28 100.4,25.51 100.4,26.71 101.82,28.13 v1(102.41,28.13)
+V1P00S_VCCSTG: length 118.7
  TOP w0.254: v1(77.92,75.57) 78.25,75.57 79.32,74.51 79.32,73.85 79.72,73.44 79.82,73.44 80.56,72.7 v1(80.56,72.55)
  TOP w0.508: 139.39,37.4 139.39,38.53 R134.1 ; 139.39,37.4 138.95,36.96 R133.1 ; 139.39,37.4 139.82,36.96 141.44,36.96 141.7,37.22 141.7,38.44 v1(141.57,38.56) ; v1(141.57,38.56) 141.44,38.69 141.44,39.06 R130.1 ; v1(141.57,38.56) 142.38,38.56 142.54,38.72 147.08,38.72 v1(148.24,39.88) 149.14,40.77 149.14,41.47 v1(150.3,42.63)
  IN1 w0.254: v1(84.7,61.48) 85.19,61.48 87.29,63.58 87.52,63.58 88.41,64.48 v1(88.41,64.8)
  IN1 w0.381: v3(114.87,49.37) 115.78,49.37 117.08,50.67 117.08,52.17 117.26,52.36 117.26,53.83 v1(116.82,54.28)
  IN1 w0.508: v1(150.3,42.63) 148.94,44 148.94,47.43 147.97,48.39 145.2,48.39 144.06,49.54 144.06,52.25 144.49,52.69 144.49,56.29 ; 138.83,57.64 138.47,57.64 137.69,56.85 129.02,56.85 126.17,59.71 124.62,59.71
  IN2 w0.254: v4(69.41,76.13) 69.92,75.61 69.92,75.11 70.29,74.75 71.3,74.75 71.76,74.28 72.85,74.28 72.89,74.25 73.21,74.25 74.05,75.08 74.05,76.77 74.3,77.03 74.84,77.03 75.66,76.21 77.28,76.21 v1(77.92,75.57)
  IN2 w0.381: v1(116.28,45.51) 114.87,46.92 v3(114.87,49.37)
  BOTTOM w0.254: PU3254.L10 69.41,76.63 v4(69.41,76.13) ; 120.81,61.08 U80.AK30 U80.AM30 ; 120.81,61.08 v3(120.35,60.85) ; 120.81,61.08 120.81,60.72 ; 120.42,62.43 v3(120.39,62.43) 120.29,62.43 U80.AM28 U80.AK28 119.89,61.08 ; v1(88.41,64.8) 87.75,65.46 87.75,71.05 85.37,73.43 82.76,73.43 82.04,72.7 80.71,72.7 v1(80.56,72.55) ; 127.21,61.66 U80.AM42 v3(126.75,62.44) U80.AL42 ; v3(120.35,60.85) U80.AL30 ; v3(120.35,60.85) 119.89,61.08 ; 119.89,60.72 119.89,61.08 ; v3(114.87,49.37) 114.84,49.37 U80.G20
  BOTTOM w0.381: v1(116.82,54.28) 117.14,54.59 117.14,55.27 118.15,56.27 118.15,56.94 117.73,57.36 v1(116.82,57.36)
  BOTTOM w0.508: v1(141.57,38.56) 141.27,38.86 141.27,39.66 R129.1 141.28,40.47 R131.1 141.42,40.66 RAP1013.1 ; R66.1 151.03,42.23 150.63,42.63 v1(150.3,42.63) 150.3,43.48 150.1,43.69 150.07,43.69 RAP1343.2
  vias: v1(84.28,61.02) v1(84.35,59.16) v1(84.75,58.57) v1(84.96,59.16) v1(116.82,59.18) v1(116.82,58.58) v1(116.84,57.97) v3(121.31,62.32) v3(127.69,62.46)
+V1P8_SOC: length 6.1
  TOP w0.102: v1(51.17,48.29) PR88.2 PR86.2 PR89.2 PR87.2 51.75,51.85 JP5076.2
+V1P8A: length 371.9
  TOP w0.203: PR189.2 57.83,83.81 PC1206.1
  TOP w0.381: RAP1047.2 110.57,35.03 v1(110.15,35.03) 109.35,34.23 v1(109.35,32.55) ; RAP1049.2 112.76,35.45 v1(113,35.21) ; v1(90.34,63.1) 90.29,63.15 90.29,65.11 v1(90.44,65.26) 90.44,66.06 R5088.1 90.33,66.34 QPM3388.2 ; v1(91.65,57.81) 91.75,57.71 RPM3305.2
  TOP w0.508: v1(96.54,84.23) 97.68,83.09 RPM3309.2
  TOP w1.016: PC1204.1 v1(57.79,77.98) 57.79,75.95 55.95,74.1 55.95,71.71 56.72,70.94 56.72,70.49
  IN1 w0.635: 99.81,93.71 102.25,91.27 102.25,88.63 100.31,86.68 100.31,84.58 99.49,83.75 98.75,83.75 98.26,84.23 97.4,84.23
  IN1 w1.016: 57.27,68.21 57.27,68.21 62.2,63.28 75.17,63.28 77.32,65.43 81.31,65.43 88.23,72.36 88.23,72.36
  IN2 w0.381: v1(110.15,35.03) 112.82,35.03 v1(113,35.21)
  IN2 w1.016: 37.81,38.62 33.39,34.2 33.39,32.44 32.35,31.4 ; 48.23,50.35 49.47,50.35 50.84,51.72 52.32,51.72 53.31,52.71 53.31,56.5 53.14,56.66 53.14,60.04 51.92,61.26 51.92,62.35 50.11,64.17 50.11,65.75 51.03,66.68 54.01,66.68 55.31,67.98 ; 210.41,17.46 203.12,17.46 201.7,16.04 198.74,16.04 198.16,16.62 192.32,16.62 189.11,13.41 186.14,13.41 183.11,16.44 166.69,16.44 166.01,17.13 159.09,17.13 155.92,13.95 152.32,13.95 150.52,15.76 117.26,15.76 115.61,14.1 115.61,12 114.29,10.68 112.72,10.68 112.4,10.36 v1(108.98,10.36) 88.25,10.36 87.27,11.34 87.27,12.81 84.04,16.04 80.75,16.04 80.29,16.5 70.22,16.5 68.47,18.25 68.47,20.34 67.06,21.75 67.06,24.24 60.36,30.94 53.43,30.94 43.58,40.8 41.07,40.8
  BOTTOM w0.381: v1(109.35,32.55) 109.35,30.99 108.67,30.31 108.67,28.59 109.83,27.42 109.83,15.25 110.1,14.98 110.1,11.48 v1(108.98,10.36) ; RPM3331.2 92.11,57.35 v1(91.65,57.81) 91.25,58.21 91.25,58.73 90.46,59.52 90.46,61.38 90.58,61.5 90.58,62.86 v1(90.34,63.1)
  BOTTOM w0.508: v1(90.44,65.26) 90.44,71.2 90.2,71.45 v1(90.2,71.97) ; R5091.2 26.13,22.77 v1(26.26,22.89)
  BOTTOM w1.016: 224.17,27.16 223.28,27.16 221.48,25.36 218.28,25.36 211.73,18.8 ; 39.64,40.72 39.64,41.42 45.42,47.2 46.12,47.2
  vias: v1(27.02,29.57) v1(27.45,29.09) v1(38.96,39.76) v1(39.63,39.76) v1(42.64,62.52) v1(42.61,61.91) v1(47.49,49.72) v1(47.46,49.11) v1(55.9,68.79) v1(56.53,69.02) v1(88,56.8) v1(96,83.9) v1(96.78,76.63) v1(97.02,76.07) v1(98.85,94.57) v1(99.59,94.52) v1(211.42,17.43) v1(212.18,17.46) v5(57.75,82.23) v5(57.72,81.05)
+V1P8S: length 255
  TOP w0.381: RAP3043.1 v1(112.87,33.55) ; RAP3044.1 110.48,33.55 v1(110.26,33.33)
  TOP w0.508: JP951.1 55.68,70.08 v1(55.66,70.06)
  IN1 w0.508: v1(61.43,74.79) 62.17,75.52 62.17,76.74 62.55,77.12 v1(63.24,77.12) 63.41,77.29 63.41,81.73 63.05,82.1 63.05,83.14 64.06,84.15 64.06,88.56 65.07,89.57 65.07,94.14 66.06,95.13 82.69,95.13 86.1,91.73 96.98,91.73 v1(97.35,91.36)
  IN2 w0.079: 67.18,79.74 67.4,79.74 69.11,78.04 69.59,78.04 v4(69.94,77.69)
  IN2 w0.508: v1(48.91,44.74) 49.24,44.74 49.75,45.25 49.75,47.67 49.07,48.36 47.09,48.36 46.29,49.15 46.29,49.99 47.52,51.21 48.99,51.21 49.88,52.1 49.88,54.14 50.26,54.52 51.61,54.52 52.28,55.19 52.28,59.68 50.42,61.54 50.42,62.64 49.24,63.81 49.24,66.11 50.68,67.54 53.66,67.54 55.66,69.55 v1(55.66,70.06)
  IN2 w1.016: 31.84,28.35 34.51,31.02 34.51,33.36 38.76,37.61 39.06,37.61 v1(40.71,39.26) 41.18,39.26 42.03,38.41 44.26,38.41 48.63,34.04 48.63,32.98 51.79,29.83 59.03,29.83 65.5,23.36 65.5,18.83 68.95,15.38 79.83,15.38 80.29,14.92 83.58,14.92 86.15,12.35 86.15,10.87 87.79,9.24 v1(110.48,9.24)
  BOTTOM w0.254: v4(69.94,77.69) PU3254.J8
  BOTTOM w0.381: v1(110.48,9.24) 110.63,9.39 110.63,15.13 110.32,15.45 110.32,27.62 109.15,28.79 109.15,30.11 110.08,31.03 110.08,33.15 v1(110.26,33.33) 110.48,33.55 v1(112.87,33.55)
  BOTTOM w0.508: v1(40.71,39.26) 40.71,40.11 v1(42.17,41.57) 43.62,43.03 44.11,43.03 45.71,44.64 45.71,45.17 45.61,45.27 45.61,45.98 45.97,46.34 46.8,46.34 46.87,46.27 46.93,46.21 47.58,45.56 R957.1 47.58,44.97 47.82,44.74 v1(48.91,44.74) ; v1(55.66,70.06) 55.66,72.36 56.89,73.59 61,73.59 61.43,74.02 v1(61.43,74.79) ; v1(26.51,23.55) 27.14,22.92 R5090.2 ; v1(97.35,91.36) 97.44,91.26 QPM3390.2
  vias: v1(28.14,25.28) v1(28.82,25.28)
+V1P8S_AUDIO_AVDD: length 17.1
  TOP w0.305: U1.6 23.96,11.86 24.73,11.08 25.27,11.08 25.79,10.56 C1M4.1 ; U1.1 21.46,11.82 21.07,11.44 21.07,11.23 20.62,10.78 C1M9.1
  TOP w0.508: v1(20.42,11.59) 20.41,11.59 20.16,11.34 20.16,10.79 C1M9.1
  IN1 w0.635: 26.74,12.1 26.09,12.75 26.09,17.95 25.52,18.52 25.52,20.28 24.66,21.14 24.66,21.52
  vias: v1(19.63,18.42) v1(20.26,18.42) v1(20.83,12.03) v1(24.05,22.16) v1(24.55,22.56) v1(26.44,11.18) v1(27.1,11.13)
+V1P8S_AUDIO_DVDD: length 18.3
  TOP w0.305: U1.22 22.46,18.32 22.45,18.33 22.45,19.09 ; U1.20 23.46,18.19 23.47,18.2 23.47,19.18
  TOP w0.381: FB1C10.2 v1(25.37,22.41) ; R1A1.1 v1(26.48,18.71)
  IN1 w0.508: v1(26.48,18.71) 26.26,18.94 26.26,21.12 25.37,22 v1(25.37,22.41)
  IN2 w0.508: v1(26.48,18.71) 23.96,18.71 23.49,19.18 v1(20.95,19.18)
  BOTTOM w0.508: Q129.2 19.6,20.68 19.6,20.18 20.26,19.51 v1(20.26,19.21)
+V1P8S_EMMC: length 7.1
  BOTTOM w0.203: RSM2145.1 68.68,51.5 68.32,51.14 v1(68.32,50.87) 68.39,50.8 RSM2149.1 ; RSM2151.1 68.32,53.09 v1(68.29,53.12) ; RSM2144.1 68.83,49.34 68.37,48.88 v1(68.37,48.78) 68.5,48.65 RSM2148.1 ; RSM2155.1 68.7,43.95 v1(68.42,44.23) 68.42,44.36 68.83,44.77 RSM2146.1 ; RSM2143.1 68.83,47.05 v1(68.42,46.64) 68.7,46.36 RSM2147.1
  BOTTOM w0.254: USM2006.C6 61.76,47.58 v1(61.66,47.68)
  vias: v1(55.57,47.25) v1(56.18,47.25)
+V1P8S_R:
  vias: v1(25.57,25.51)
+V1P8S_R951:
  vias: v1(54.83,71.53)
+V1P8U: length 171.7
  TOP w0.381: v3(146.68,82.6) 145.76,83.52 145.76,84.86 v1(146.48,85.58) 146.81,85.9 v3(146.81,86.48) ; v3(116.71,85.02) 117.24,85.55 117.24,86.4 116.56,87.08 v3(116.56,88.62)
  TOP w0.508: v3(161.11,75.36) 161.11,74.18 162.35,72.94 v3(162.35,72.82) ; v3(105.52,89.42) 105.28,89.18 CSM2130.1
  IN1 w0.254: v4(69.99,76.66) 69.99,73.91 70.77,73.12 v3(71.04,73.12)
  IN1 w0.508: v3(135.29,88.62) 135.29,88.09 134.68,87.48 134.68,85.24 v3(135.24,84.68) ; v3(124.25,91.02) v3(124.25,88.62) 124.25,88.16 124.67,87.73 124.67,85.62 124.14,85.09 v3(124.11,85.09) ; v3(158.13,82.75) 159.07,83.68 159.07,85.34 v1(157.9,86.5) ; v3(174.61,71.57) 174.61,76.65 v3(174.32,76.94) ; v1(79.85,74.05) 79.85,73.69 80.31,73.24 81.53,73.24 v1(85.44,77.15) ; v1(86.88,80.55) 86.88,80.73 89.5,83.35 89.5,84.26 88.94,84.82 88.94,86.37 91.28,88.7 92.19,88.7 93.24,89.75 97.3,89.75 98.37,90.81 99.26,90.81 100.38,89.68 v1(100.92,89.68)
  IN1 w0.762: v1(131.07,95.22) 130.38,95.22 130.11,95.48 124.07,95.48
  IN2 w0.381: v3(105.19,85.02) 105.71,85.54 105.71,87.22 105.52,87.41 v3(105.52,89.42)
  IN2 w0.508: v3(71.04,73.12) 72.02,72.14 72.81,72.14 73.11,72.45 73.98,72.45 74.04,72.38 77.64,72.38 78.06,72.8 78.83,72.8 79.85,73.83 v1(79.85,74.05)
  BOTTOM w0.254: v4(69.99,76.66) 69.97,76.64 PU3254.M9 ; v3(135.24,84.68) 134.97,84.95 USM2002.U10 ; USM2003.U10 116.64,85.09 v3(116.71,85.02) ; USM2003.A10 105.26,85.09 v3(105.19,85.02) ; USM2001.U10 157.94,82.94 v3(158.13,82.75) ; USM2001.A10 146.8,82.61 146.7,82.61 v3(146.68,82.6) ; USM2000.A10 163.13,71.96 162.74,71.96 162.35,72.35 v3(162.35,72.82) ; v3(124.11,85.09) USM2002.A10 ; v3(174.61,71.57) 174.61,71.57 174.5,71.68 173.81,71.68 USM2000.U10
  BOTTOM w0.508: 164.66,86.14 167.78,86.14 168.98,87.33 173.17,87.33 174.64,85.86 174.64,82.89 174.07,82.31 CSM2031.1 ; 105.16,93.52 103.78,94.9 JP952.1 ; v1(85.44,77.15) 85.44,79.11 v1(86.88,80.55)
  BOTTOM w0.762: 105.16,91.36 105.16,93.52 106.36,94.71 117.9,94.71 119.1,93.51 121.29,93.51 v1(122.66,94.87) ; v1(131.07,95.22) 132.29,96.44 137.4,96.44 140.04,93.8 ; 140.11,93.8 140.11,93.8 140.39,93.52 142.13,93.52 143.22,94.61 153.48,94.61 155.09,93 155.85,93 158.35,90.5 158.35,88.97
  vias: v1(123.58,95.04)
