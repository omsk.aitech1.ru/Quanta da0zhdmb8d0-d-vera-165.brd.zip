# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1P00S_PG: length 9.5
  TOP w0.079: 74.87,81.67 74.8,81.67 74.15,81.02 74.15,80.08 74.06,79.98 74.06,79.63 v1(73.91,79.48)
  TOP w0.102: 74.87,81.67 75.38,82.18 75.38,82.84 76.06,83.51 PR105.2 76.06,84.07 76.19,84.21 76.19,84.46 76.66,84.93 PR38.1 ; v4(72,78.64) 72.61,79.25 73.68,79.25 73.9,79.48 v1(73.91,79.48)
  BOTTOM w0.102: v4(72,78.64) 72.19,78.64 72.23,78.69 PU3254.G4
V1P8U_LSW: length 41.9
  TOP w0.102: v1(73.78,90.89) 73.5,90.61 71.54,90.61 70.48,89.54 70.48,87.18 71.57,86.09 71.57,85.68 71.09,85.2 PR108.2 71.14,85.06 71.14,83.85 v1(70.91,83.62)
  IN1 w0.079: v1(73.78,90.89) 74.15,91.26 83.34,91.26 86.35,88.25 89.4,88.25 91,89.85 v1(91,90.2)
  BOTTOM w0.102: PR37.1 97.09,93.53 v1(95.01,93.53) 92.93,93.53 91,91.6 v1(91,90.2) ; PU3254.A10 69.78,81.99 69.96,81.99 70.9,82.94 70.9,83.62 v1(70.91,83.62)
V3P3A_PCH_LSW: length 68.2
  TOP w0.079: v4(72.5,80.19) 72.01,80.19 71.65,80.55 71.32,80.55 71.1,80.33 71.09,80.33 71,80.24 71,80.12 70.69,79.81 70.32,79.81 69.99,80.14 69.99,80.19 69.47,80.71 ; 69.47,80.71 69.37,80.81 69.37,80.85 69.11,81.11 69.11,81.49 70.43,82.81 70.43,83.27 ; 69.47,80.71 69.12,80.36 68.84,80.36 68.02,81.18 68.02,81.36 68.02,81.37 68.02,81.4 67.72,81.71 66.35,81.71 v4(66.11,81.95)
  TOP w0.102: 70.43,83.27 70.43,83.93 69.94,84.41 PR109.2 ; PR40.1 48.41,46.77 50.92,44.25 57.19,44.25 v1(57.37,44.43)
  IN2 w0.079: v1(57.37,44.43) 57.14,44.66 57.14,49.99 59.33,52.17 59.33,52.79 58.69,53.42 58.69,54.71 58.13,55.27 58.13,60.1 58.49,60.46 58.49,60.99 60.62,63.13 60.62,64.34 59.1,65.87 59.1,70.72 60.05,71.67 60.05,72.41 62.02,74.38 62.02,75.78 62.19,75.95 62.19,76.63 63.95,78.39 63.95,79.31 66.11,81.47 v4(66.11,81.95)
  BOTTOM w0.102: PU3254.D5 72.5,80.19 v4(72.5,80.19)
V3P3A_PCH_PG: length 10.5
  TOP w0.079: 65.19,79.09 65.24,79.15 v3(65.24,79.51)
  TOP w0.102: v1(64.27,82.91) 63.59,83.59 PR107.2 ; PR36.1 65.19,79.09
  IN1 w0.079: v1(64.27,82.91) 64.65,82.53 64.81,82.53 65.08,82.26 65.08,79.67 v3(65.24,79.51)
  IN2 w0.079: v4(68.49,80.21) 67.97,80.21 67.62,80.56 67.3,80.56 65.99,79.26 65.5,79.26 v3(65.24,79.51)
  BOTTOM w0.102: PU3254.C12 68.49,80.67 v4(68.49,80.21)
V3P3DSW_ENA: length 168.4
  TOP w0.102: v1(67.71,84.37) 68.35,83.73 PR54.1 ; R5151.1 153.73,21.25 v1(153.33,21.65) ; v1(68.3,33.67) 68.98,32.98 71.01,32.98 71.75,32.24 72.46,32.24 73.93,30.77 81.59,30.77 83.38,28.98 85.07,28.98 86.07,27.97 v1(86.81,27.97) 87.55,27.97 v1(89.2,26.32)
  IN1 w0.079: v1(122.4,20.33) 122.95,19.78 140.25,19.78 140.5,20.02 140.5,20.83 141.82,22.16 147.42,22.16 147.61,22.35 152.63,22.35 v1(153.33,21.65)
  IN2 w0.079: v1(122.4,20.33) 121.94,20.78 118.13,20.78 115.23,23.68 112.39,23.68 111.7,23 109.33,23 107.7,24.63 104.25,24.63 v1(104.13,24.52) 102.13,24.52 101.94,24.33 100.26,24.33 99.97,24.03 v1(99.41,24.03) ; v1(67.71,84.37) 67.4,84.06 66.83,84.06 66.14,84.75 64.22,84.75 61,81.54 61,79 61.83,78.17 61.83,74.44 59.83,72.45 59.83,71.71 58.92,70.8 58.92,65.64 60.44,64.12 60.44,63.2 58.31,61.07 58.31,60.53 57.95,60.17 57.95,55.2 58.51,54.63 58.51,53.35 59.07,52.8 59.07,52.17 56.96,50.07 56.96,42.25 60.06,39.15 60.27,39.15 65.85,33.56 68.19,33.56 v1(68.3,33.67)
  BOTTOM w0.102: v1(99.41,24.03) 99.37,24.03 98.7,24.71 98.7,24.91 97.84,25.76 91.99,25.76 90.92,26.83 90.47,26.83 89.96,26.32 R5049.2 v1(89.2,26.32) R5050.2 ; R5051.1 68.64,33.67 v1(68.3,33.67) ; CR15.2 103.98,24.37 v1(104.13,24.52)
V5A_DS3_PG: length 10.8
  TOP w0.079: v4(67.5,81.19) 67.5,80.7 68.34,79.86 68.64,79.86 68.78,80 69.16,80 69.51,79.65 69.51,79.6 70.36,78.76 70.38,78.76 70.87,78.27 v1(70.87,77.67) 70.87,77.29 71.57,76.59 71.57,75.56 71.85,75.28 71.85,74.87 v4(71.98,74.74)
  BOTTOM w0.102: v4(67.5,81.19) PU3254.B15 ; v4(71.98,74.74) 71.98,74.74 71.52,74.74 PU3254.R6 71.36,74.69 70.97,75.08 PU3254.P7
VBATTBKUP: length 4.6
  TOP w0.102: v1(64.69,82.1) 64.28,82.51 63.85,82.51 63.54,82.2 PR132.2
  BOTTOM w0.102: PU3254.C16 65.92,81.24 65.23,81.24 65.03,81.44 65.03,81.75 v1(64.69,82.1)
VCCCORE_SENSE: length 104.9
  TOP w0.305: PR58.2 189.07,36.68 v1(187.9,36.68) 186.72,36.68 185.79,35.75 185.79,25.87 183.99,24.06 182.29,24.06 180.89,25.46 180.89,29.8 180.24,30.45 169.24,30.45 165.29,26.5 160.9,26.5 159.9,27.5 158.94,28.46 152.26,28.46 151.71,29.01 148.13,29.01 147.29,29.86 147.29,32.57 146.32,33.54 145.4,33.54 144.85,32.98 144.85,32.44 v1(144.59,32.18)
  IN2 w0.305: v3(122.18,48.33) 122.16,48.31 122.16,48.3 121.92,48.06 121.92,42.08 126.71,37.29 126.71,33.74 127.95,32.49 141.37,32.49 141.91,33.03 144.57,33.03 144.85,32.75 144.85,32.44 v1(144.59,32.18)
  BOTTOM w0.305: U80.E32 122.01,48.5 v3(122.18,48.33)
VCCGT_SENSE: length 67.4
  TOP w0.305: v1(191.1,47.54) 191.36,47.28 195.32,47.28 v1(196.03,46.57) 196.74,45.86 196.74,44.31 PR56.1
  IN1 w0.305: v1(191.1,47.54) 191.36,47.28 191.71,47.28 191.94,47.51 191.94,50.5 187.09,55.35 171.87,55.35 164.69,48.17 158.82,48.17 156.55,50.43 148.05,50.43 147.57,49.94 145.76,49.94 145.51,50.2 v1(145.51,50.48)
  BOTTOM w0.076: v1(145.51,50.48) 145.21,50.78 144.62,50.78 144.47,50.93 144.04,50.93 143.79,50.81 143.79,50.81 143.79,50.8 143.73,50.74 143.58,50.74 U80.J70
VCCIO_LSW: length 53.5
  TOP w0.102: v1(89.88,86.44) 89.16,85.72 89.16,84.71 89.48,84.39 89.48,83.67 88.74,82.94 88.74,78.64 87.72,77.62 87.72,73.99 85.43,71.7 85.43,69.97 84.14,68.68 84.14,68 83.31,67.17 PR71.2 83.86,65.78 83.86,65.44 83.67,65.25 PU15.3 ; v1(76.47,82.23) 76.47,82.37 PR106.2 75.86,82.79 75.68,82.61 75.68,82.13 74.99,81.43 74.81,81.43 74.33,80.95 74.33,80 74.31,79.98 74.31,79.3 74.07,79.06 72.85,79.06 72.41,78.63 v4(72.41,78.23)
  IN2 w0.079: v1(76.47,82.23) 76.47,82.99 77.59,84.11 77.59,84.59 78.02,85.02 78.02,88.7 78.38,89.06 86.78,89.06 89.4,86.44 v1(89.88,86.44)
  BOTTOM w0.102: PU3254.J4 72.47,77.92 72.41,77.97 v4(72.41,78.23)
VCCIO_PG: length 1.4
  TOP w0.079: TP63.1 69.44,75.65 69.41,75.63 v4(68.97,75.63)
  BOTTOM w0.102: v4(68.97,75.63) PU3254.P11
VCCIO_PG_EN: length 25.6
  TOP w0.102: v1(64.61,84.13) 65.09,83.65 v1(65.14,83.65) ; PR39.2 73.99,83.33 74.38,83.71 74.38,84.37 74.82,84.82 75.48,84.82 75.71,85.05 PR38.2 75.88,84.5 v1(75.46,84.08)
  IN1 w0.079: v3(65.99,76.48) 66.46,76.96 66.46,78.77 66.57,78.87 66.57,80.4 65.63,81.34 65.63,82.48 65.37,82.73 65.37,83.42 v1(65.14,83.65)
  IN2 w0.079: v1(65.14,83.65) 65.32,83.83 66.05,83.83 66.53,83.35 70.16,83.35 70.62,82.89 72.61,82.89 72.9,83.18 74.18,83.18 75.07,84.08 v1(75.46,84.08)
  BOTTOM w0.102: PU3254.L16 66.47,76.68 66.27,76.48 v3(65.99,76.48)
VCCRTCEXT: length 3.8
  TOP w0.381: v3(109.06,69.17) 109.57,69.68 CAP1282.2
  BOTTOM w0.203: v3(109.06,69.17) 109.1,69.14 109.1,68.1 U80.BB10
VCCSA_SENSE: length 113.4
  TOP w0.305: v1(143.65,30.89) 143.39,31.15 143.09,31.15 142.79,30.84 142.79,29.58 144.53,27.84 151.22,27.84 151.78,27.29 158.46,27.29 160.41,25.33 165.78,25.33 169.61,29.17 175.53,29.17 181.98,22.72 184.29,22.72 186.96,25.39 186.96,29.18 187.64,29.85 191.22,29.85 192.13,28.94 v1(193.22,28.94) 194.31,28.94 195.67,30.31 195.67,30.6 PR60.1
  IN2 w0.305: v3(114.87,50.03) 115.06,49.84 115.21,49.84 115.53,49.53 115.53,49.19 116.81,47.91 116.81,46.44 117.2,46.04 117.2,45.2 118.25,44.15 118.25,34.29 122.09,30.46 127.83,30.46 128.52,31.15 143.39,31.15 v1(143.65,30.89)
  BOTTOM w0.305: U80.H20 114.44,50.45 v3(114.87,50.03)
VCCST_PWRGD_MCP: length 12.5
  BOTTOM w0.076: U80.B65 140.08,46.12 140.08,44.71 141.1,43.69 141.3,43.69
  BOTTOM w0.102: 141.3,43.69 144.98,43.69 146.3,42.37 147.76,42.37 RAP1064.2
VCCSTG_EN: length 54
  TOP w0.102: v1(98,88.29) 97.83,88.12 97.07,88.12 v1(96.47,87.52) 95.88,86.93 89.68,86.93 88.96,86.21 88.96,84.62 89.27,84.31 89.27,83.76 88.54,83.02 88.54,78.72 87.52,77.71 87.52,74.08 85.23,71.79 85.23,70.06 83.94,68.77 83.94,68.08 82.81,66.95 82.81,66.6 PR71.1 PR62.2 81.46,66.55 81.28,66.73 80.12,66.73 78.55,65.16 78.55,63.71 78.76,63.51 79.8,63.51 79.89,63.59 81.52,63.59 81.7,63.41 PU16.9 81.15,63.36 80.28,63.36 80.13,63.2 78.73,63.2 78.25,62.72 78.25,62.17 78.09,62.01 78.09,61.56 78.33,61.32 78.63,61.32 79.72,60.23 80.69,60.23 80.82,60.36 81.02,60.36 81.12,60.26 PU14.9
  BOTTOM w0.102: v1(98,88.29) 99.15,89.44 PR81.2
VCCSTG_OVR_EN_R: length 1.2
  TOP w0.102: PR62.1 80.68,65.56 PU15.4
VDDQ_PG: length 3.1
  TOP w0.079: PR39.1 72.78,82.26 72.78,81.03 72.47,80.71 v4(72.02,80.71)
  BOTTOM w0.102: PU3254.C6 71.72,80.69 71.74,80.71 v4(72.02,80.71)
VSSCORE_SENSE: length 103.6
  TOP w0.305: PR59.2 189.07,36.12 186.96,36.12 v1(186.65,35.82) 186.35,35.52 186.35,25.64 184.22,23.5 182.06,23.5 180.33,25.23 180.33,29.57 180.01,29.89 169.47,29.89 165.52,25.94 160.66,25.94 159.5,27.11 158.71,27.9 152.03,27.9 151.47,28.45 147.9,28.45 146.73,29.62 146.73,32.34 146.09,32.98 145.64,32.98 145.41,32.75 145.41,32.44 v1(145.67,32.18)
  IN2 w0.305: v3(122.56,47.91) 122.48,47.83 122.48,42.31 127.27,37.52 127.27,33.97 128.19,33.05 141.14,33.05 141.67,33.59 144.8,33.59 145.41,32.98 145.41,32.44 v1(145.67,32.18)
  BOTTOM w0.305: v3(122.56,47.91) 122.73,48.08 122.73,48.41 U80.E33
VSSGT_SENSE: length 68.7
  TOP w0.305: PR57.1 196.18,44.31 v1(196.18,44.97) 196.18,45.63 195.09,46.72 191.36,46.72 v1(191.1,46.46)
  IN1 w0.305: v1(191.1,46.46) 191.36,46.72 191.94,46.72 192.5,47.27 192.5,50.73 187.32,55.91 171.64,55.91 164.45,48.72 159.05,48.72 156.79,50.99 147.82,50.99 147.33,50.5 v1(146.12,50.5)
  BOTTOM w0.076: v1(146.12,50.5) 145.68,50.94 144.69,50.94 144.54,51.09 144.01,51.09 143.6,50.93 143.11,50.93 U80.J69
VSSSA_SENSE: length 115.3
  TOP w0.305: PR61.1 197,30.84 v1(195.77,29.61) 194.54,28.38 191.9,28.38 190.98,29.29 187.87,29.29 187.52,28.95 187.52,25.15 184.52,22.16 181.75,22.16 175.3,28.61 169.84,28.61 166.01,24.77 160.18,24.77 158.22,26.73 151.54,26.73 150.99,27.28 144.29,27.28 142.23,29.35 142.23,31.07 142.86,31.71 143.39,31.71 v1(143.65,31.97)
  IN2 w0.305: v3(115.83,50.2) 115.83,50.03 116.09,49.78 116.09,49.42 117.37,48.14 117.37,46.67 117.76,46.27 117.76,45.43 118.81,44.38 118.81,34.53 122.32,31.02 127.6,31.02 128.28,31.71 143.39,31.71 v1(143.65,31.97)
  BOTTOM w0.305: v3(115.83,50.2) 115.58,50.45 U80.H21
1A5_EN_C0: length 117.6
  TOP w0.102: v1(26.23,47.38) 26.51,47.66 R5041.2 ; QPM3383.2 20.93,51.45 20.69,51.21 18.23,51.21 17.38,52.07 QPM3384.2 16.99,51.94 v1(16.99,50.99)
  IN1 w0.079: v1(91.01,43.57) 90.94,43.57 89.66,42.29 89.66,40.1 89.51,39.95 89.51,39.17 88.04,37.69 88.04,36.88 86.37,35.21 78.02,35.21 76,37.23 72.52,37.23 71.67,38.09 69.77,38.09 69.15,38.7 67.23,38.7 63.21,42.73 62.89,42.73 61.95,43.67 59.28,43.67 58.03,44.91 57.09,44.91 56.64,44.46 54.24,44.46 53.67,45.03 53.67,48.15 51.66,50.16 51.66,51.86 52.19,52.39 v1(52.19,52.84) ; v1(16.99,50.99) 17.56,51.56 21.66,51.56 22.19,51.04 24.53,51.04 26,49.56 26.51,49.56 27.12,48.95 27.12,48.27 26.36,47.51 v1(26.23,47.38)
  BOTTOM w0.102: v1(91.01,43.57) 91.01,43.72 90.78,43.95 R5040.1 ; v1(52.19,52.84) 52.19,54.33 v1(51.95,54.57) 51.71,54.81 50.95,54.81 49.73,53.59 49.73,53.32 49.47,53.07 48.35,53.07 47.48,53.94 46.59,53.94 45.74,53.08 45.74,52.67 43.82,50.76 43.82,49.58 42.08,47.84 40.48,47.84 40.05,47.4 40.05,46.1 35.99,42.04 29.23,42.04 27.15,44.13 27.15,45.62 26.48,46.28 26.48,47.12 v1(26.23,47.38)
+GT_VRCTL:
  vias: v1(178.1,39.05) v1(178.83,38.75) v1(186.96,37.71) v1(187.6,37.73) v1(188.46,37.95)
+ISL_5VLDO: length 10.7
  TOP w0.203: v1(47.69,24) 47.08,24.6 47.08,26.5 46.58,27 46.58,29.98 v1(47.29,30.7) 48.01,31.41 PR161.2
  TOP w0.305: v1(47.69,24) 47.84,24.15 PC1313.1
  BOTTOM w0.203: v1(47.69,24) 47.84,24.14 48.45,24.14 PU4.8
+PMIC_VRCTL: length 30.6
  TOP w0.203: PR48.2 67.78,72.41 68.58,73.22 PC1324.2 68.58,73.6 68.93,73.95 v4(68.93,74.69)
  TOP w0.254: v1(70.94,80.71) 71.65,81.42 71.65,82.52 PC1323.2
  IN1 w0.254: v4(68.93,74.69) 68.49,74.25 67.24,74.25 66.54,74.95 66.54,75.96 66.76,76.18 66.76,78.48 v4(66.94,78.66)
  IN2 w0.254: v1(70.94,80.71) 70.89,80.71 68.94,82.67 66.32,82.67 66.14,82.49 65.94,82.49 65.58,82.13 65.58,81.34 64.53,80.3 63.31,80.3 62.81,80.8 v1(62.6,80.8)
  BOTTOM w0.254: v1(70.94,80.71) 70.92,80.71 71.06,80.84 71.11,80.84 71.31,81.04 71.31,81.1 71.4,81.19 PU3254.B5 ; v1(62.6,80.8) 62.86,80.8 63.16,80.5 PC1325.2 63.72,79.57 63.72,79.18 64.13,78.77 66.38,78.77 PU3254.G16 66.49,78.66 v4(66.94,78.66) ; v4(68.93,74.69) PU3254.R12
+USB3_P4_VBUS:
  vias: v1(15.56,33.21) v1(15.56,32.44) v1(16.32,33.21) v1(16.32,32.44) v1(19.25,30.08) v1(19.86,30.08)
+USB3_P4_VBUS_FUSE:
  vias: v1(26.41,33.33)
+V_BOOSTIN: length 43.9
  BOTTOM w0.178: PR2.1 42.64,32.63 42.77,32.5 44.67,32.5 PR125.2
  BOTTOM w0.203: 47.06,33.52 47.06,31.73 47.82,30.97 47.82,29.85 47.26,29.29 47.26,28.18 47.87,27.57 PU4.16 ; R1022.1 72.74,38.39 v1(72.05,39.07) 70.71,40.42 65.68,40.42 64.64,41.46 61.46,41.46 60.5,42.43 59.33,42.43 58.72,41.82 54.42,41.82 53,40.4 42.95,40.4 42.26,39.71 v1(42.26,39.53)
  vias: v1(49.06,31.02) v5(29.15,64.04) v5(29.15,63.28) v5(29.15,62.52) v5(29.79,63.66) v5(29.79,62.9) v5(29.79,62.16) v5(37.94,34.35) v5(38.65,35.07) v5(38.69,34.34) v5(39.53,35.06) v5(39.54,34.35) v5(40.38,35.07) v5(40.43,34.35) v5(41.25,35.1) v5(41.28,34.36) v5(42.11,34.35)
+V_USB2PWR:
  vias: v1(227.63,27.03) v1(227.63,26.35) v1(227.65,25.71) v1(227.65,25.05) v1(228.26,27.03) v1(228.26,26.35) v1(228.29,25.71) v1(228.29,25.05)
+VR1_VBATA:
  vias: v1(65.09,71.48)
+VR3_VBATA: length 12.3
  IN1 w0.079: 68.1,81.29 68.1,81.1 68.84,80.36 68.84,80.06 68.65,79.87 68.65,79.5 69,79.16 v4(69,78.66)
  IN1 w0.254: v1(65.04,88.68) 65.19,88.53 65.19,87.23 66.58,85.84 66.58,84.21 68.1,82.68 68.1,81.29
  BOTTOM w0.254: PU3254.H11 68.97,78.64 v4(69,78.66)
+VR4_VBATA:
  vias: v1(76.31,87.9) v1(76.33,86.86) v5(75.69,87.46)
+VR5_VBATA: length 13.5
  IN1 w0.254: v1(72.03,73.16) 72.03,73.62 70.96,74.68 70.96,75.68 v4(70.5,76.14)
  IN2 w0.254: v1(79.77,75.24) 79.32,74.79 79.32,73.98 78.63,73.29 77.86,73.29 77.44,72.87 74.22,72.87 73.82,73.27 72.14,73.27 v1(72.03,73.16)
  BOTTOM w0.254: PU3254.N8 70.47,76.11 v4(70.5,76.14)
  vias: v1(80.41,75.29) v5(80.14,75.9)
+VRTC_EC: length 43.1
  TOP w0.254: v4(70.47,75.19) v1(70.47,73.41) 70.47,72.84 70.99,72.32 PC9112.1 71.03,72.28 71.47,71.84 71.47,71.16 v1(71.65,70.98)
  IN2 w0.254: v1(67.1,59.37) 67.08,59.39 67.08,60.53 63.82,63.79 63.82,65.21 65.08,66.47 65.86,66.47 67.13,67.73 67.13,71.13 67.72,71.72 71,71.72 71.65,71.07 v1(71.65,70.98)
  BOTTOM w0.254: PU3254.P9 v4(70.47,75.19) ; CRPM3518.2 73.75,48.8 75.13,50.17 75.13,52.11 74.93,52.31 74.93,53.27 74.32,53.88 73.81,53.88 73.62,53.69 71.57,53.69 70.66,54.6 69.55,54.6 68.67,55.47 68.67,56.62 67.1,58.2 v1(67.1,59.37)
+VUSBC1_VBUS_CONN: length 5.5
  BOTTOM w0.254: JCP4038.B9 6.15,64.75 JCP4038.A4 8.3,64.75 v5(8.37,64.68) ; v5(8.98,67.55) 8.69,67.25 JCP4038.A9 6.15,67.25 JCP4038.B4
  vias: v1(18.76,69.76) v1(18.76,69.12) v1(19.38,69.64) v1(20.02,69.64) v5(27.75,68.49) v5(28.16,67.85) v5(28.59,68.49) v5(29.02,67.85) v5(29.43,68.49) v5(29.81,67.85)
ALL_SYS_PWRGD: length 226.9
  TOP w0.079: v3(65.81,79.64) 65.65,79.64 65.22,80.07 65.22,80.4 65.19,80.42
  TOP w0.102: v1(62.8,76.51) 62.43,76.88 PR103.2 62.98,77.92 62.98,79.38 63.83,80.24 64.54,80.24 64.85,80.55 TP109.1 65.19,80.42 ; v1(180.43,91.14) 187.7,91.14 189.68,89.17 189.68,80.01 186.91,77.25 186.91,68.16 188.21,66.86 189.54,66.86 191.97,64.44 191.97,61.3 195.09,58.17 195.09,50.15 201.26,43.97 201.26,41.76 201.54,41.49 201.54,40.32 201.38,40.17 200.09,40.17 198.78,38.85 PU5.40 ; v1(89.37,90.81) 88.33,89.77 88.33,79.23 v1(88.13,79.03)
  IN1 w0.079: v1(62.8,76.51) 63.31,76 63.31,75.39 62.09,74.16 62.09,72.39 63.05,71.43 64.82,71.43 65.14,71.11 66.88,71.11 67.52,70.47 70.24,70.47 70.25,70.46 75.71,70.46 77.47,68.7 80.76,68.7 82.62,70.56 82.62,72.54 86.67,76.59 86.67,78.02 87.67,79.03 v1(88.13,79.03)
  IN2 w0.079: v1(89.37,90.81) 89.42,90.81 92.12,93.51 95.4,93.51 98.03,96.14 138.03,96.14 139.55,94.62 155.93,94.62 156.63,93.91 156.63,92.93 159.6,89.97 164.83,89.97 166.01,91.14 v1(180.43,91.14)
  BOTTOM w0.079: v3(65.81,79.64) 66.02,79.43 66.72,79.43 PU3254.F15
AUDIO_I2S_MCLK_R: length 5.6
  TOP w0.102: R851.1 23.59,21.72 v1(23.44,21.88)
  BOTTOM w0.102: U108.4 23.93,21.38 v1(23.44,21.88) 22.93,22.39 22.18,22.39 21.51,21.71 21.51,21.27 21.36,21.12 R1124.2
AUDIO_INT_WAK*: length 23.1
  TOP w0.102: QPM3388.3 91.68,69.68 v1(91.98,69.97) 92.06,70.05 R1131.1 93.18,70.05 93.49,70.36 95.44,70.36 v1(96.06,70.98)
  IN2 w0.079: v3(108.44,65.01) 108.3,65.15 108.3,65.89 106.94,67.24 106.68,67.24 103.97,69.96 103.7,69.96 102.95,69.21 100.63,69.21 99.15,70.68 96.35,70.68 v1(96.06,70.98)
  BOTTOM w0.076: U80.AT10 108.79,64.64 108.44,65 v3(108.44,65.01)
AUDIO_IRQ*: length 161.3
  TOP w0.102: v1(56.17,39.1) 55.86,39.41 49.7,39.41 48.98,38.69 43.69,38.69 43.06,38.06 37.42,38.06 35.58,36.21 35.58,30.24 34.18,28.84 32.15,28.84 30.68,27.37 30.68,24.04 v1(29.43,22.79) 28.18,21.54 28.18,15.8 28.03,15.65 27.5,15.65 26.89,16.27 U1.15 ; v1(96.66,71.08) 96.66,70.87 95.15,69.36 94.9,69.36 91.71,66.17 R5088.2 91.05,66.23 QPM3388.1
  IN1 w0.079: v3(109.16,57.41) 108.71,56.97 108.52,56.97 107.53,55.99 105.35,55.99 105.12,55.75 104.4,55.75 104.16,55.51 98.39,55.51 98.04,55.16 96.56,55.16 96.31,55.41 91.71,55.41 90.72,54.41 87.62,54.41 87.01,53.8 87.01,53.22 84.45,50.66 83.75,50.66 83.06,49.97 82.51,49.97 81.01,48.47 80.92,48.47 80.76,48.32 80.52,48.32 80.17,48.67 76.98,48.67 76.19,47.88 74.68,47.88 74.51,47.71 70.02,47.71 68.54,49.18 65.66,49.18 65.51,49.33 63.63,49.33 61.95,51.01 59.43,51.01 58.1,52.34 58.1,52.71 57.82,52.98 v1(57.27,52.98)
  IN2 w0.079: v3(109.16,57.41) 109.77,57.41 110.28,57.92 112.15,57.92 112.4,58.17 112.4,58.88 111.18,60.09 110.29,60.09 109.81,60.57 109.81,61.41 108.81,62.42 108.81,65.16 108.48,65.49 108.48,65.97 107.02,67.43 106.76,67.43 104.05,70.14 99.95,70.14 99.23,70.86 96.88,70.86 v1(96.66,71.08) ; v1(57.27,52.98) 57.82,52.98 58.1,52.71 58.1,52.39 56.6,50.89 56.6,39.53 v1(56.17,39.1)
  BOTTOM w0.102: U80.AD11 109.5,57.75 v3(109.16,57.41)
AUDIO_JACK_JD: length 4.1
  TOP w0.508: R1C5.1 15.24,18.04 v1(14.75,18.04) 14.59,18.2 J1C1.5
BATT_ENABLE*: length 120.2
  TOP w0.102: v1(159.71,21.72) 159.71,21.82 159.15,22.39 Q135.3 ; v1(60.88,15.86) 61.31,16.29 87.47,16.29 89.23,14.53 91.71,14.53 97.42,8.82 113.84,8.82 114.09,9.08 114.09,11.18 v1(113.68,11.59)
  IN1 w0.079: v1(113.68,11.59) 113.68,15.08 116.54,17.94 120.08,17.94 121.56,19.42 140.4,19.42 140.86,19.87 140.86,20.68 141.9,21.72 146.68,21.72 147.79,20.61 153.33,20.61 154.45,21.72 v1(159.71,21.72)
  BOTTOM w0.102: v1(60.88,15.86) 63.39,18.37 PJ2.6
BC_ACOK: length 204
  TOP w0.079: v4(68.01,79.66) 67.85,79.82 67.33,79.82 67.06,80.09 67.06,80.31 67.3,80.55 67.3,80.85 66.91,81.24 65.98,81.24 65.75,81.47 65.19,81.47
  TOP w0.102: U83.2 150.56,22.85 151.13,23.42 v1(151.3,23.42) ; v1(64.24,81.3) 64.4,81.47 65.19,81.47
  IN1 w0.079: v1(64.24,81.3) 63.99,81.05 63.99,75.55 62.48,74.04 62.48,73.33 v1(63.17,72.64) ; v1(118.94,18.6) 119.85,18.6 122.01,20.76 122.62,20.76 122.98,20.4 122.98,20.18 123.2,19.96 140.18,19.96 140.32,20.09 140.32,20.91 141.75,22.34 147.34,22.34 147.54,22.53 150.42,22.53 v1(151.3,23.42)
  IN2 w0.079: v1(118.94,18.6) 118.53,18.19 116.98,18.19 112.06,13.27 109.75,13.27 108.66,12.18 105.04,12.18 104.53,12.68 102.13,12.68 101.95,12.86 99.84,12.86 99.41,12.43 94.65,12.43 93.89,13.2 93.69,13.2 91.08,15.8 88.84,15.8 84.51,20.13 79.41,20.13 v1(76.65,22.89) 70.81,28.73 v1(70.81,31.45) 70.6,31.67 70.6,33.23 68.41,35.42 67.1,35.42 64.54,37.98 64.54,40.65 61.01,44.18 61.01,47.63 60.74,47.9 60.05,47.9 59.58,48.37 59.58,50.58 59.92,50.92 60.11,50.92 61.02,51.83 61.02,52.79 60.36,53.46 60.36,54.05 60.07,54.34 60.07,55.03 61.11,56.07 61.11,59.57 60.65,60.03 60.65,61.7 61.92,62.97 61.92,66.48 61.05,67.35 61.05,69.63 61.49,70.06 62.22,70.06 62.68,70.52 62.68,71.86 63.17,72.34 v1(63.17,72.64)
  BOTTOM w0.102: v1(76.65,22.89) 76.14,23.4 68.41,23.4 67.78,24.03 67.78,27.5 64.69,30.59 55.77,30.59 54.32,32.04 54.32,32.1 PR20.1 53.95,32.34 PR47.1 ; v4(68.01,79.66) 67.97,79.62 PU3254.F13 ; v1(70.81,31.45) 71.04,31.68 76.11,31.68 77.71,33.28 78.76,33.28 79.21,32.82 C1028.2
BC_IBAT: length 54.2
  TOP w0.203: PC1051.2 53.28,25.76 v1(53.3,25.76)
  IN2 w0.079: v1(44.57,36.58) 47.41,33.74 47.41,31.63 48.91,30.13 50.56,30.13 52.14,28.56 52.14,26.93 v1(53.3,25.76)
  BOTTOM w0.102: R3526.1 72.8,36.22 71.75,37.27 71.02,37.27 69.88,38.41 68.28,38.41 67.61,37.75 67.61,33.62 65.98,31.99 60.47,31.99 56.61,35.85 49.67,35.85 48.84,36.69 44.67,36.69 v1(44.57,36.58)
  BOTTOM w0.203: v1(53.3,25.76) 53.09,25.97 PU4.29
BC_IBAT_C: length 6.2
  BOTTOM w0.102: EUPM3247.A20 76.9,38.79 76.62,38.51 76.62,38.4 75.85,37.63 74.76,37.63 C1116.2 R3526.2 72.65,37 v1(72.08,37.57)
BKUP_BAT: length 0.9
  TOP w0.102: PR132.1 62.19,83.08 TP165.1
BOOT_BEEP: length 38.6
  TOP w0.102: v1(95.45,70.98) 95.04,70.57 93.82,70.57 93.44,70.95 v1(93.44,72.64) 93.44,74.33 93.67,74.56 U138.10 93.67,78.68 94.51,79.52 ; 94.51,79.52 95.71,79.52 96.27,80.08 U138.1 ; 94.51,79.52 94.51,79.99 94.32,80.18 U138.4
  IN2 w0.079: v1(109.89,59.53) 109.37,60.06 109.37,61.38 108,62.74 108,63.77 108.07,63.84 108.07,64.52 107.79,64.8 107.79,65.28 106.97,66.1 106.57,66.1 106.29,66.38 106.29,66.56 105.63,67.22 104.03,67.22 103.42,67.83 101.76,67.83 99.08,70.5 95.92,70.5 v1(95.45,70.98)
  BOTTOM w0.102: v1(109.89,59.53) 110.36,59.53 U80.AF13
BUF_PCH_PLT_RST*: length 246.7
  TOP w0.102: v1(92.9,90.94) RAP3047.1 93.01,90.22 U135.4 94.83,90.22 95.83,91.22 96.55,91.22 97.69,90.08 RAP3048.2 ; Q127.3 185.34,21.45 v1(183.28,21.45) 181.22,21.45 179.14,19.36 179.14,18.5 178.24,17.6 166.48,17.6 164.85,19.24 158.95,19.24 156.77,17.06 156.77,15.9 155.54,14.66 153.41,14.66 152.14,15.93 141.01,15.93 138.88,18.07 122.37,18.07 v1(122.32,18.12)
  IN1 w0.079: v1(68.49,42.29) 68.49,43.09 67.84,43.74 64.53,43.74 62.36,45.91 59.35,45.91 58.38,46.88 57.67,46.88 57.29,47.26 57.29,49.85 56,51.14 v1(55.42,51.14)
  IN2 w0.079: v1(122.32,18.12) 121.68,18.12 120.68,19.12 117.3,19.12 114.21,16.03 113.37,16.03 111.02,13.67 107.82,13.67 107.06,12.92 105.37,12.92 104.84,13.44 103.7,13.44 103.37,13.78 102.16,13.78 101.99,13.61 97.2,13.61 96.98,13.83 94.56,13.83 94.27,14.12 94.07,14.12 90.8,17.39 88.56,17.39 84.62,21.33 83.27,21.33 81.73,22.87 79.19,22.87 72.43,29.62 72.43,33.09 70.22,35.31 70.22,36.15 68.12,38.25 68.12,41.91 v1(68.49,42.29) 68.49,42.8 66.97,44.32 66.97,54.57 68.35,55.95 68.35,57.01 73.53,62.19 73.53,62.47 77.28,66.23 78.81,66.23 82.9,70.32 82.9,72.94 83.94,73.97 83.94,78.82 87.58,82.47 88.24,82.47 93.39,87.61 93.39,90.45 v1(92.9,90.94)
  BOTTOM w0.102: v1(68.49,42.29) 68.66,42.12 70.76,42.12 70.94,41.94 72.59,41.94 73.07,42.43 74.26,42.43 R1104.1 ; v1(55.42,51.14) 54.12,51.14 53.28,50.3 51.4,50.3 51.25,50.45 Q111.3
BUF_PCH_PLT_RST*_R: length 2.5
  BOTTOM w0.102: R1104.2 75.66,42.71 v1(75.89,42.48) 76.09,42.27 76.83,42.27 76.85,42.29 EUPM3247.A27
CA_VREF: length 110.4
  TOP w0.381: v1(148.15,93.32) 148.17,93.34 v1(149.72,93.34) 150.88,93.34 151.09,93.14 151.09,92.45 v1(151.07,92.44) 150.73,92.1 139.26,92.1 138.3,93.06 135.21,93.06 134.49,93.78 129.93,93.78 129.2,94.52 129.2,94.55 v3(129.13,94.62) ; CSM2032.1 168.09,77.32 v3(167.61,76.84) ; CSM2131.1 110.19,90.34 v3(110.07,90.22) ; v3(128.8,90.22) 128.92,90.34 CSM2100.1 ; RAP1026.2 RAP1030.1 RAP1029.2 170.99,86.65 170.63,86.29 v1(170.63,85.63) ; v3(151.34,88.08) 151.51,87.91 CSM1019.1
  IN1 w0.381: v1(110.14,93.26) 110.14,90.3 v3(110.07,90.22) ; v3(128.8,90.22) 128.8,93.64 129.13,93.98 v3(129.13,94.62)
  IN2 w0.381: v3(151.34,88.08) 152.96,88.08 153.34,88.47 153.34,89.84 153.5,90 153.5,90.55 152.53,91.52 149.95,91.52 v1(148.15,93.32) ; v1(149.72,93.34) 154.96,93.34 159.01,89.29 160.49,89.29 163.09,86.69 169.61,86.69 170.63,85.67 v1(170.63,85.63)
  BOTTOM w0.178: 167.61,78.44 167.61,77.97 167.93,77.64 168.08,77.64 168.26,77.46 168.26,77.18 167.93,76.84 v3(167.61,76.84) 167.93,76.52 USM2000.H4
  BOTTOM w0.203: 167.54,78.5 167.61,78.44
  BOTTOM w0.381: v1(170.63,85.63) 170.63,84.46 167.54,81.37 167.54,78.5 ; v3(110.07,90.22) 110.07,90.21 USM2003.H4 ; v3(128.8,90.22) 129.12,89.9 USM2002.H4 ; USM2001.H4 v3(151.34,88.08) ; v3(129.13,94.62) 128.57,95.18 126.64,95.18 123.81,92.35 118.63,92.35 117.42,93.56 112.15,93.56 111.34,92.74 110.51,92.74 110.14,93.11 v1(110.14,93.26)
CAP1_GND:
  vias: v1(101.97,92.06)
CAP2_GND:
  vias: v1(53.08,73.39)
CAP3_GND:
  vias: v1(214.17,30.18)
CCD_PWR:
  vias: v1(46.67,61.91) v1(47.27,61.88)
CFG<0>: length 13.4
  BOTTOM w0.076: 141.45,44.91 141.45,45.26 141.3,45.41 141.3,45.56 141.3,45.56 141.3,45.92 141.3,45.93 141.33,46.02 141.33,46.16 141.32,46.25 141.3,46.32 141.3,46.38 141.3,46.49 141.3,46.51 141.3,46.55 141.32,46.61 141.35,46.69 141.4,46.88 141.44,47.14 141.51,47.41 U80.E68
  BOTTOM w0.102: 141.45,44.91 141.45,44.89 141.8,44.54 145.58,44.54 146.02,44.1 RAP1328.1 147.32,43.77 147.41,43.67 148.46,43.67 148.68,43.9 148.68,44.1 149.14,44.56 149.14,45.07 v1(149.24,45.17) 149.55,45.17 149.6,45.12 RAP1344.2
CFG<2>: length 11
  BOTTOM w0.076: 140.49,44.91 140.49,45.32 140.65,45.48 140.65,45.91 140.59,46.02 140.59,46.22 140.65,46.31 140.65,46.55 140.57,46.69 140.47,46.79 140.22,46.79 140.06,46.95 140.06,47.21 140.38,47.53 U80.D65
  BOTTOM w0.102: 140.49,44.91 140.49,44.85 141.2,44.14 145.22,44.14 146.3,43.06 RAP1330.1
CFG<3>: length 7.1
  BOTTOM w0.076: 142.06,45.89 142,45.95 142,46.81 U80.D67
  BOTTOM w0.102: 142.06,45.89 142.06,45.66 142.25,45.47 142.61,45.47 142.94,45.14 146.12,45.14 146.4,44.86 RAP1331.1
CFG<4>: length 7.4
  BOTTOM w0.102: U80.E70 143.76,48.09 143.95,47.89 144.3,47.89 146.32,45.88 RAP1332.1 147.32,46.09 147.52,46.29 149.62,46.29 v1(149.67,46.39)
CFG<5>: length 13
  IN2 w0.079: v1(151.43,41.1) 151.24,40.91 148.67,40.91 142.86,46.72 v3(142.86,46.9)
  BOTTOM w0.102: v1(151.43,41.1) 151.43,40.75 RAP1327.1 ; v3(142.86,46.9) 142.86,46.91 142.45,47.31 U80.C68
CFG<6>: length 11.4
  IN2 w0.079: v3(143.62,47.59) 145.53,45.67 145.53,44.41 148.64,41.31 v1(150.16,41.31)
  BOTTOM w0.102: U80.D68 143.59,47.56 v3(143.62,47.59) ; RAP1333.1 150.36,41.1 v1(150.16,41.31)
CFG<8>: length 8.6
  BOTTOM w0.102: v1(150.61,48.72) 149.95,48.72 149.17,47.94 148.79,47.94 148.23,47.38 147.49,47.38 147.32,47.2 RAP1335.1 146.88,46.9 145.13,48.65 143.98,48.65 143.92,48.71 U80.F71
CFG<9>: length 5.5
  BOTTOM w0.076: U80.G69 142.95,49.54 143.2,49.54 143.42,49.61 143.55,49.61 143.78,49.55 143.92,49.55 144.04,49.6 144.48,49.6 144.52,49.56
  BOTTOM w0.102: 144.52,49.56 147.04,49.56 147.19,49.41 RAP1336.1 v1(148.18,49.41)
CFG<10>: length 8.3
  BOTTOM w0.076: U80.F70 143.37,48.45 143.98,48.45 143.99,48.46 144.93,48.46 145.26,48.14
  BOTTOM w0.102: 145.26,48.14 146.88,46.52 148.53,46.52 RAP1337.1 149.3,46.98 v1(149.95,47.63)
CHARGE_LED1: length 120.4
  TOP w0.102: Q125.2 12.18,77.99 v1(12.69,77.48) 13.15,77.02 13.33,77.02 13.48,76.87 13.48,76.41 13.72,76.17 14.86,76.17 15.66,75.37 15.66,73.55 16.88,72.33 16.88,71.37 17.59,70.67 18.84,70.67 20.08,71.91 25.75,71.91 26.66,71 26.66,67.06 v1(27.17,66.56)
  IN1 w0.079: v1(89.09,40.61) 88.26,39.78 88.26,38.43 87.67,37.83 87.67,37.02 86.22,35.57 78.17,35.57 76.15,37.59 72.93,37.59 70.69,39.84 66.6,39.84 63.36,43.09 63.04,43.09 62.1,44.03 59.43,44.03 57.62,45.83 56.18,45.83 55.15,46.86 55.15,47.9 55.72,48.47 55.72,48.95 55.39,49.28 55.14,49.28 53.76,50.66 53.76,53.51 51.83,55.44 50.57,55.44 49.11,56.9 48.97,56.9 47.88,57.99 47.88,62.07 47.45,62.5 47.05,62.5 45.72,63.83 44.59,63.83 44.22,63.46 44.22,62.37 43.79,61.94 43.79,59.86 42.74,58.81 41.42,58.81 40.99,59.24 40.99,60.94 40.6,61.32 40.6,65.19 39.05,66.74 31.68,66.74 31.16,66.23 27.5,66.23 v1(27.17,66.56)
  BOTTOM w0.102: v1(89.09,40.61) 88.9,40.79 EUPM3247.A57
CHARGE_LED2: length 117.6
  TOP w0.102: Q121.2 12.44,80.22 12.44,79.41 15.87,75.98 15.87,73.63 17.09,72.41 17.09,71.46 17.67,70.87 18.75,70.87 20,72.12 25.83,72.12 26.87,71.08 26.87,67.5 v1(27.14,67.22)
  IN1 w0.079: v1(85.97,40.04) 85.42,39.48 85.42,38.64 86,38.06 86,37.28 85.29,36.57 78.96,36.57 76.24,39.3 75.84,39.3 73.5,41.64 70.2,41.64 67.91,43.92 64.61,43.92 62.44,46.09 59.43,46.09 58.46,47.06 57.79,47.06 57.47,47.38 57.47,49.92 55.86,51.53 55.05,51.53 54.02,52.56 54.02,53.5 51.9,55.62 50.65,55.62 49.18,57.08 49.04,57.08 48.06,58.06 48.06,62.15 47.52,62.68 47.12,62.68 45.8,64.01 44.51,64.01 44.04,63.53 44.04,62.45 43.6,62.01 43.6,59.93 42.67,58.99 41.49,58.99 41.17,59.32 41.17,61.02 40.78,61.4 40.78,65.26 39.12,66.92 31.6,66.92 31.08,66.41 27.96,66.41 v1(27.14,67.22)
  BOTTOM w0.102: EUPM3247.B61 86.35,40.54 85.97,40.17 v1(85.97,40.04)
CONN_SLEEVE_FET: length 12.7
  BOTTOM w0.102: v1(15.64,17.99) 15.64,17.76 Q136.3 16.48,16.29 17.87,14.89 18.64,14.89 18.76,14.77 18.76,14.38 18.51,14.13 Q112.2 17.67,14.13 17.32,13.77 17.32,12.38 17.19,12.25 17.19,11.84 16.42,11.07 R1B32.2 15.71,10.19 15.97,9.94 Q114.2
CORE_CSN: length 40
  TOP w0.203: v1(191.52,34.97) 191.37,34.97 190.75,34.35 PR34.1 190.54,33.39 PC26.2 190.54,32.43 PC9108.2 190.54,32.42 PR146.1
  IN2 w0.152: v1(191.52,34.97) 190.99,34.44 190.99,33.84 190.32,33.16 181.2,33.16 179.95,31.91 168.22,31.91 167.3,32.82 164.5,32.82 163.11,34.22 162.47,34.22 v1(161.98,34.7)
  BOTTOM w0.203: PC1281.2 191.82,35.27 v1(191.52,34.97) 191.44,34.89 191.14,34.89 190.88,34.63 PR186.2 PC9098.1 ; v1(161.98,34.7) 162.2,34.48 PR140.1
CORE_CSP: length 11.2
  TOP w0.203: PR146.2 189.76,32.42 PC9108.1 PC26.1 189.67,33.48 188.82,33.48 v1(188.66,33.64) 188.66,34.16 189.48,34.98 189.47,34.99 ; 189.47,34.99 189.91,35.43 191.86,35.43 191.95,35.35 192.6,35.35 192.91,35.65 PU5.19 ; 189.47,34.99 v1(189.47,35)
  BOTTOM w0.203: v1(189.47,35) 189.87,35.4 PR154.1 190.33,36.14 PR121.1
CORE_FCCM: length 32
  TOP w0.203: v1(187.97,35.12) 187.97,32.39 189.41,30.95 190.9,30.95 191.2,31.26 191.2,33.31 192.38,34.48 194.14,34.48 PU5.21
  IN2 w0.203: v1(170.98,39.05) 170.98,38.31 172.76,36.53 186.56,36.53 v1(187.97,35.12)
  BOTTOM w0.279: PU6.1 170.84,38.49 170.94,38.59 170.94,39.02 v1(170.98,39.05)
CORE_PWM1: length 34.4
  TOP w0.203: PU5.22 194.6,34.07 194.43,33.9 193.99,33.9 193.77,34.12 192.57,34.12 191.51,33.06 191.51,31.13 190.93,30.56 189.26,30.56 187.59,32.22 187.59,34.76 v1(187.22,35.13)
  IN2 w0.203: v1(187.22,35.13) 186.28,36.07 172.68,36.07 170.49,38.27 170.49,39.54 v1(170.61,39.66)
  BOTTOM w0.279: v1(170.61,39.66) 170.56,39.61 170.13,39.61 170.06,39.53 PU6.22
CORE_SW_DRV: length 36.5
  IN2 w0.152: v1(161.39,38.04) 161.19,37.84 161.19,36.02 161.68,35.53 163.28,35.53 165.11,33.69 172.47,33.69 174.55,35.77 183.79,35.77 185.11,34.45 189.76,34.45 v1(190.27,34.96)
  BOTTOM w0.203: PR121.2 190.65,35.36 190.27,34.99 v1(190.27,34.96)
  BOTTOM w0.254: 163.42,38.04 v1(161.39,38.04)
  vias: v5(165.7,39.08)
CPU_JTAG_TCLK: length 8.2
  TOP w0.102: v3(139.22,43.13) 139.6,43.13 140.57,42.16 R138.1 140.09,40.42 RAP1351.2
  BOTTOM w0.076: 139.22,43.39 139.22,43.69 138,44.92 138,45.45 138.17,45.63 138.17,45.89 138.11,46 138.11,46.22 U80.B61
  BOTTOM w0.102: 139.22,43.39 v3(139.22,43.13)
CPU_JTAG_TDI: length 9.9
  BOTTOM w0.076: 138.1,42.64 138.1,43.23 138.23,43.36 138.23,43.75 137.27,44.71 137.27,46.42 137.16,46.52 137.05,46.64 137.05,46.88 137.34,47.17 U80.D60
  BOTTOM w0.102: R129.2 139.78,40.25 RAP1381.1 139.16,40.25 138.1,41.31 138.1,42.64
CPU_JTAG_TDO: length 15.2
  TOP w0.102: RAP1376.1 v1(138.09,37.27) ; v3(138.82,42) 138.53,42 138.2,41.67 138.2,40.39 138.57,40.01 140.07,40.01 140.14,39.95 R130.2
  IN1 w0.079: v3(138.82,42) 138.14,41.32 138.14,37.33 v1(138.09,37.27)
  BOTTOM w0.076: 138.74,43.39 138.74,43.94 137.82,44.86 137.82,45.7 U80.A61
  BOTTOM w0.102: 138.74,43.39 138.74,42.08 v3(138.82,42)
CPU_JTAG_TMS: length 11.6
  TOP w0.102: v1(140.86,38.44) 140.86,37.79 RAP1383.1
  BOTTOM w0.076: R131.2 140.86,40.11 v1(140.86,38.44) ; U80.C60 137.43,46.66 137.43,44.78 138.38,43.83 138.38,43.28
  BOTTOM w0.102: R131.2 139.92,40.5 139.79,40.62 139.04,40.62 138.28,41.38 138.28,43.17 138.38,43.28
CPU_POPIRCOMP: length 18.4
  IN1 w0.152: v3(113.04,64.99) 113.48,65.44 113.48,65.79 112.5,66.77 112.5,67.35
  IN1 w0.305: v3(100.4,72.45) 102.43,72.45 105.66,69.22 107.63,69.22 108.22,68.63 110.66,68.63 111.11,68.18 111.67,68.18 112.5,67.35
  BOTTOM w0.254: v3(100.4,72.45) 100.3,72.55 R45.1 ; v3(113.04,64.99) U80.AT16
CPU_SVIDALRT*: length 95.5
  TOP w0.102: PU5.36 199.08,37.25 199.54,37.71 200.55,37.71 200.96,37.29 201.8,37.29 202.26,37.75 202.93,37.75 203.47,37.21 203.47,35.62 204.23,34.86 204.23,32.59 201.57,29.93 198.49,29.93 195.52,26.96 191.28,26.96 190.09,28.15 v1(190.09,28.51)
  IN1 w0.079: v1(190.09,28.51) 190.09,28.99 189.25,29.83 187.34,29.83 185.03,27.51 176.45,27.51 175.07,28.89 170.3,28.89 167.96,26.54 148.7,26.54 146.88,28.36 146.88,33.46 150.49,37.07 150.49,39.12 149.1,40.5 147.37,40.5 v3(146.27,41.61)
  BOTTOM w0.102: v3(146.27,41.61) 146.27,41.53 145.41,40.68 RPM3558.2 145.9,39.91 RAP1451.1
CPU_SVIDALRT*_R: length 11.3
  BOTTOM w0.076: U80.B63 139.58,46.11 139.58,44.5 140.35,43.73 140.35,43.58 141.18,42.75 144.88,42.75 145.69,41.94 145.69,41.41 v2(145.53,41.26) 145.05,40.77 145,40.77 RPM3558.1
CPU_SVIDCLK: length 99.7
  TOP w0.102: PR164.2 203.09,38.39 204.05,37.43 PR174.1 204.05,35.84 204.79,35.09 204.79,32.36 201.8,29.37 198.75,29.37 195.78,26.4 190.85,26.4 189.43,27.82 v1(189.43,28.51)
  IN1 w0.079: v1(145.3,41.73) 147.06,39.97 148.88,39.97 149.95,38.9 149.95,37.29 146.34,33.68 146.34,28.14 148.47,26.01 168.18,26.01 170.5,28.33 174.87,28.33 176.22,26.98 185.25,26.98 187.56,29.29 188.89,29.29 189.43,28.76 v1(189.43,28.51)
  BOTTOM w0.076: U80.A63 139.41,45.62 139.41,44.44 140.19,43.66 140.19,43.51 141.14,42.56 141.67,42.56
  BOTTOM w0.132: 141.67,42.56 144.69,42.56 145.3,41.95 v1(145.3,41.73)
CPU_SVIDDAT: length 96.7
  TOP w0.102: v1(190.8,28.51) 191.79,27.52 195.24,27.52 198.21,30.49 201.34,30.49 203.67,32.82 203.67,34.63 203.21,35.09 PR118.2 202.79,35.22 PR158.2
  IN1 w0.079: v1(190.8,28.51) 190.8,29.04 189.47,30.37 187.12,30.37 184.8,28.05 176.7,28.05 175.3,29.45 170.1,29.45 167.73,27.08 148.92,27.08 147.41,28.58 147.41,33.24 151.03,36.85 151.03,39.34 149.32,41.04 147.63,41.04 v3(146.98,41.69)
  BOTTOM w0.076: U80.D64 139.82,47.17 139.53,46.88 139.53,46.56 139.75,46.34 139.75,44.57 140.53,43.79 140.53,43.65
  BOTTOM w0.102: RAP1450.1 147.17,41.5 v3(146.98,41.69) 146.71,41.96 145.97,41.96 145.01,42.93 141.25,42.93 140.53,43.65
CSI2_COMP: length 8.3
  TOP w0.508: RAP1055.1 v1(111.73,41.99)
  IN2 w0.508: v1(111.73,41.99) 110.61,43.11 110.61,45.8 110.71,45.91 110.71,47.48 111.24,48.01 v3(111.24,48.27)
  BOTTOM w0.254: U80.E13 110.99,48.27 v3(111.24,48.27)
DCIN_EN: length 1.7
  TOP w0.102: U26.8 v1(23.39,45.77)
  BOTTOM w0.102: R5108.2 23.47,45.85 v1(23.39,45.77)
DDI1_AUX_DN*: length 154.3
  IN1 w0.076: 132.77,47.91 132.67,47.81
  IN1 w0.079: v3(132.24,49.55) 132.43,49.36 132.59,49.36 132.77,49.18 132.77,47.91 ; 132.67,47.81 132.51,47.65 130.83,47.65 129.77,46.59 129.77,44.18 130.18,43.77 130.18,42.15 128.38,40.36 125.7,40.36 124.07,38.73 121.14,38.73 119.73,37.32 119.73,30.23 116.85,27.36 115.39,27.36 114.58,26.55 104.57,26.55 100.53,22.51 93.57,22.51 92.56,21.51 91.77,21.51 91.63,21.64 76.62,21.64 75.71,22.56 66.28,22.56 61.17,27.67 61.17,29.15 58.46,31.86 57.36,31.86 54.63,34.59 53.45,34.59 51.31,36.72 50.59,36.72 39.56,47.76 39.56,50.78 37.28,53.06 35.95,53.06 34.96,54.06 34.96,54.92 33.69,56.19 30.2,56.19 29.54,56.84 29.35,56.84 v1(29.13,56.62)
  BOTTOM w0.102: CCP4156.2 20.41,55.4 20.41,55.34 20.69,55.05 22.12,55.05 22.96,55.9 22.96,57.24 23.5,57.78 24.32,57.78 24.53,58 27.38,58 28.51,56.87 28.88,56.87 v1(29.13,56.62) ; U80.G50 131.78,49.75 131.98,49.55 v3(132.24,49.55)
DDI1_AUX_DP: length 154.3
  IN1 w0.079: v1(29.13,57.36) 29.13,57.08 29.18,57.03 29.62,57.03 30.27,56.37 33.77,56.37 35.15,55 35.15,54.14 36.03,53.25 37.35,53.25 39.74,50.86 39.74,47.84 50.67,36.91 51.39,36.91 53.52,34.77 54.71,34.77 57.43,32.05 58.54,32.05 61.36,29.23 61.36,27.74 66.35,22.75 75.78,22.75 76.7,21.83 91.71,21.83 91.85,21.69 92.48,21.69 93.49,22.7 100.46,22.7 104.5,26.74 114.5,26.74 115.31,27.54 116.77,27.54 119.54,30.31 119.54,37.4 121.07,38.92 124,38.92 125.62,40.55 128.3,40.55 129.99,42.23 129.99,43.7 129.58,44.1 129.58,46.67 130.75,47.84 132.4,47.84 132.59,48.02 132.59,49.14 132.53,49.2 132.2,49.2 132.12,49.12 132.12,48.96 v3(132.24,48.84)
  BOTTOM w0.102: v1(29.13,57.36) 28.85,57.08 28.59,57.08 27.47,58.21 24.44,58.21 24.23,58 23.42,58 22.75,57.33 22.75,55.98 22.03,55.26 20.78,55.26 20.62,55.42 20.62,55.63 20.76,55.78 CCP4157.2 ; v3(132.24,48.84) 132.1,48.84 U80.F50
DDI1_C_AUX_DN: length 4.5
  BOTTOM w0.102: CCP4156.1 20.42,56.56 20.5,56.63 20.5,57.23 RCP4160.2 20.31,57.69 20.46,57.84 20.46,58.24 21.1,58.89 21.1,59.28 20.98,59.4 U96.20
DDI1_C_AUX_DP: length 4.5
  BOTTOM w0.102: CCP4157.1 20.81,56.56 20.71,56.66 20.71,57.23 RCP4162.2 20.87,57.69 20.67,57.89 20.67,58.15 21.31,58.8 21.31,59.33 21.38,59.4 U96.19
DDI1_CTRL_DATA: length 17
  IN2 w0.079: v3(110.47,52.12) 109.7,52.12 109.32,51.75 106.49,51.75 103.88,49.13 103.88,48.15 v3(103,47.27)
  BOTTOM w0.102: R879.1 v1(99.66,43.34) 99.66,43.34 102.61,46.29 102.61,46.89 v3(103,47.27) ; U80.L12 110.15,51.81 v3(110.47,52.12)
DDI1_HPD: length 54.2
  IN1 w0.079: v1(98.39,41.49) 98.94,41.49 99.48,42.03 99.48,42.66 101.65,44.82 102.02,44.82 104.21,47.01 104.21,49.32 106.44,51.55 107.23,51.55 v3(107.82,52.15) ; v1(82.77,52.87) 82.75,52.84 80.76,52.84 80.45,52.53 79.06,52.53 78.83,52.31 77.13,52.31 v1(75.82,51)
  BOTTOM w0.102: v1(82.77,52.87) 83.13,52.51 83.63,52.51 83.69,52.56 84.39,52.56 88.45,48.49 89.07,48.49 90.17,47.39 90.76,47.39 91.2,46.95 92.37,46.95 93.08,46.23 93.08,44.36 95,42.45 96.11,42.45 96.53,42.03 97.85,42.03 v1(98.39,41.49) R1134.2 ; v1(75.82,51) 75.82,50.59 77.31,49.11 78.12,49.11 78.35,48.88 78.35,48.36 77.84,47.86 77.51,47.86 v1(77.37,47.72) 77.23,47.58 77.23,46.95 77.56,46.62 78.35,46.62 78.48,46.49 EUPM3247.A33 ; v3(107.82,52.15) 108.2,51.78 U80.L9
DDI1_LANE_DN*<0>: length 159.8
  IN1 w0.079: v1(24.74,65.81) 24.68,65.87 24.68,66.05 24.81,66.17 25.06,66.17 25.24,66 25.45,66 26.43,65.02 26.43,60.24 26.58,60.09 26.58,58.44 27.07,57.95 27.32,57.95 27.75,57.52 27.75,55.22 30.13,52.83 30.13,46.49 31.01,45.61 36.18,45.61 37.41,44.37 41.12,44.37 50.06,35.43 50.77,35.43 52.91,33.3 54.27,33.3 56.89,30.68 57.79,30.68 59.57,28.9 59.57,27.09 63.41,23.26 63.41,22.28 64.8,20.89 75.56,20.89 76.5,19.95 93.98,19.95 95.14,21.11 102.05,21.11 104.51,23.57 107.66,23.57 109.31,25.23 115.42,25.23 116.2,26.01 117.59,26.01 128.79,37.21 129.56,37.21 131.5,39.15 131.5,42.96 132.94,44.4 134.3,44.4 135.01,45.11 135.01,47.67 134.74,47.94 134.74,48.24 134.78,48.28 v3(134.98,48.28)
  BOTTOM w0.102: v3(134.98,48.28) 134.75,48.28 U80.E55 ; U96.40 22.98,66.03 22.86,66.15 22.86,66.22 22.94,66.3 23.43,66.3 23.58,66.15 24.73,66.15 24.83,66.05 24.83,65.9 v1(24.74,65.81)
DDI1_LANE_DN*<1>: length 163.5
  IN1 w0.079: v1(24.79,64.41) 24.79,64.53 25,64.74 25.5,64.74 25.77,64.47 25.77,63.81 25.54,63.59 25.16,63.59 24.62,63.05 24.62,58.5 25.89,57.23 25.89,55.25 28.51,52.63 28.51,45.8 29.38,44.93 29.86,44.93 30.97,43.83 35.68,43.83 36.71,42.8 40.86,42.8 49.52,34.14 50.24,34.14 52.37,32.01 53.22,32.01 55.87,29.36 57.25,29.36 58.08,28.53 58.08,25.02 64.27,18.83 68.01,18.83 68.72,19.54 75.01,19.54 75.9,18.65 90.94,18.65 91.27,18.32 98.14,18.32 99,19.18 102.67,19.18 104.77,21.28 107.26,21.28 109.87,23.9 116.17,23.9 116.93,24.66 118.13,24.66 129.36,35.89 130.14,35.89 133.14,38.89 133.14,42.15 134.1,43.11 134.9,43.11 136.72,44.93 136.72,47.46 136.44,47.74 136.44,48.41 136.52,48.49 136.6,48.49 v3(136.81,48.28)
  BOTTOM w0.102: v3(136.81,48.28) 136.58,48.28 U80.E58 ; U96.3 23.75,64.58 23.84,64.68 24.53,64.68 v1(24.79,64.41)
DDI1_LANE_DN*<2>: length 160.6
  IN1 w0.079: v1(27.12,63.29) 27.51,63.68 27.66,63.68 27.8,63.54 27.8,62.62 27.09,61.92 27.09,60.51 27.4,60.21 27.4,59.37 28.41,58.36 28.41,55.47 30.78,53.1 30.78,46.76 31.28,46.26 40.15,46.26 50.32,36.08 51.04,36.08 53.18,33.94 54.54,33.94 57.14,31.34 58.06,31.34 60.34,29.07 60.34,27.26 66.06,21.55 75.81,21.55 76.75,20.61 92.66,20.61 93.9,21.85 100.88,21.85 104.92,25.89 115.01,25.89 115.79,26.67 117.26,26.67 121.51,30.91 121.51,37.19 122.39,38.07 124.38,38.07 125.04,38.73 129.63,38.73 130.84,39.94 130.84,44.38 130.45,44.76 130.45,45.98 131.06,46.58 133.88,46.58 134.21,46.92 134.21,47.5 133.69,48.02 133.69,48.94 133.75,49 133.99,49 v3(134.07,48.92)
  BOTTOM w0.102: U96.6 23.82,63.38 23.91,63.48 26.05,63.48 26.14,63.58 26.83,63.58 v1(27.12,63.29) ; v3(134.07,48.92) 133.81,48.92 133.61,49.12 U80.F53
DDI1_LANE_DN*<3>: length 157.8
  IN1 w0.079: v1(25.3,62.04) 25.3,62.28 25.42,62.39 25.61,62.39 25.77,62.24 25.77,61.17 25.49,60.89 25.49,58.55 26.55,57.49 26.55,55.5 29.15,52.9 29.15,46.56 31.23,44.48 36.04,44.48 36.91,43.61 40.96,43.61 49.79,34.79 50.51,34.79 52.64,32.65 53.52,32.65 56.15,30.02 57.51,30.02 58.73,28.8 58.73,25.29 63.82,20.19 75.34,20.19 76.23,19.3 93.5,19.3 93.67,19.13 95.31,19.13 96.03,19.85 102.25,19.85 104.41,22 107.03,22 109.59,24.56 115.84,24.56 116.61,25.33 117.85,25.33 129.07,36.55 129.84,36.55 132.16,38.86 132.16,42.48 133.44,43.76 134.57,43.76 135.67,44.86 135.67,47.96 135.55,48.09 135.55,48.85 135.61,48.92 v3(135.9,48.92)
  BOTTOM w0.102: U96.9 23.84,62.18 23.94,62.29 25.05,62.29 v1(25.3,62.04) ; U80.F56 135.44,49.12 135.64,48.92 v3(135.9,48.92)
DDI1_LANE_DP<0>: length 159.8
  IN1 w0.079: v3(134.98,48.92) 134.55,48.49 134.55,47.84 134.82,47.56 134.82,45.19 134.22,44.59 132.86,44.59 131.31,43.04 131.31,39.22 129.48,37.4 128.71,37.4 117.51,26.2 116.12,26.2 115.34,25.42 109.24,25.42 107.58,23.76 104.44,23.76 101.97,21.29 95.06,21.29 93.9,20.13 76.57,20.13 75.63,21.07 64.88,21.07 63.59,22.36 63.59,23.33 59.76,27.17 59.76,28.97 57.86,30.87 56.96,30.87 54.35,33.48 52.99,33.48 50.85,35.62 50.13,35.62 41.19,44.56 37.49,44.56 36.25,45.8 31.09,45.8 30.32,46.57 30.32,52.91 27.93,55.3 27.93,57.6 27.4,58.13 27.15,58.13 26.76,58.51 26.76,60.16 26.61,60.32 26.61,65.1 25.53,66.18 25.32,66.18 25.14,66.36 24.96,66.36 v1(24.74,66.58)
  BOTTOM w0.102: v1(24.74,66.58) 24.53,66.36 23.67,66.36 23.52,66.51 22.85,66.51 22.65,66.31 22.65,66.12 22.58,66.05 U96.39 ; U80.F55 134.76,48.92 v3(134.98,48.92)
DDI1_LANE_DP<1>: length 163.5
  IN1 w0.079: v3(136.81,48.92) 136.81,48.74 136.75,48.67 136.44,48.67 136.26,48.49 136.26,47.67 136.54,47.39 136.54,45.01 134.83,43.3 134.02,43.3 132.95,42.23 132.95,38.96 130.07,36.08 129.28,36.08 118.05,24.85 116.86,24.85 116.1,24.09 109.8,24.09 107.18,21.47 104.69,21.47 102.59,19.37 98.92,19.37 98.06,18.51 91.35,18.51 91.02,18.84 75.97,18.84 75.08,19.73 68.65,19.73 67.94,19.01 64.35,19.01 58.27,25.09 58.27,28.61 57.33,29.55 55.95,29.55 53.3,32.19 52.45,32.19 50.31,34.33 49.6,34.33 40.94,42.98 36.79,42.98 35.76,44.02 31.04,44.02 29.94,45.12 29.45,45.12 28.69,45.88 28.69,52.71 26.08,55.32 26.08,57.31 24.81,58.58 24.81,62.97 25.24,63.4 25.62,63.4 25.95,63.73 25.95,64.55 25.57,64.93 25.01,64.93 v1(24.79,65.15)
  BOTTOM w0.102: v3(136.81,48.92) 136.59,48.92 U80.F58 ; v1(24.79,65.15) 24.52,64.89 23.88,64.89 23.79,64.98 U96.2
DDI1_LANE_DP<2>: length 160.5
  IN1 w0.079: v1(27.12,64.03) 27.28,63.86 27.74,63.86 27.98,63.62 27.98,62.54 27.28,61.84 27.28,60.59 27.58,60.28 27.58,59.44 28.59,58.44 28.59,55.55 30.96,53.18 30.96,46.84 31.36,46.44 40.22,46.44 50.4,36.26 51.12,36.26 53.26,34.13 54.62,34.13 57.22,31.53 58.14,31.53 60.53,29.14 60.53,27.34 66.13,21.73 75.89,21.73 76.83,20.79 92.58,20.79 93.83,22.04 100.8,22.04 104.84,26.08 114.94,26.08 115.71,26.86 117.19,26.86 121.32,30.99 121.32,37.27 122.31,38.26 124.3,38.26 124.96,38.92 129.55,38.92 130.65,40.02 130.65,44.3 130.27,44.69 130.27,46.06 130.98,46.77 133.8,46.77 134.03,47 134.03,47.42 133.5,47.95 133.5,48.98 v3(134.07,49.55)
  BOTTOM w0.102: v1(27.12,64.03) 26.88,63.79 26.06,63.79 25.96,63.69 23.94,63.69 23.85,63.78 U96.5 ; v3(134.07,49.55) 133.86,49.55 U80.G53
DDI1_LANE_DP<3>: length 157.8
  IN1 w0.079: v1(25.3,62.77) 25.5,62.58 25.69,62.58 25.95,62.31 25.95,61.09 25.67,60.82 25.67,58.63 26.74,57.56 26.74,55.58 29.34,52.97 29.34,46.63 31.31,44.66 36.12,44.66 36.98,43.8 41.04,43.8 49.87,34.97 50.58,34.97 52.72,32.84 53.6,32.84 56.23,30.21 57.58,30.21 58.91,28.88 58.91,25.36 63.9,20.38 75.41,20.38 76.31,19.48 93.57,19.48 93.74,19.31 95.23,19.31 95.95,20.03 102.18,20.03 104.33,22.19 106.95,22.19 109.51,24.75 115.77,24.75 116.54,25.52 117.77,25.52 128.99,36.74 129.77,36.74 131.97,38.94 131.97,42.55 133.36,43.94 134.49,43.94 135.49,44.94 135.49,47.93 135.39,48.03 135.39,49.05 v3(135.9,49.55)
  BOTTOM w0.102: v1(25.3,62.77) 25.03,62.5 23.95,62.5 23.87,62.58 U96.8 ; U80.G56 135.69,49.55 v3(135.9,49.55)
DDI2_CTRL_CLK: length 132.4
  TOP w0.102: v1(22.47,35.47) 22.17,35.76 21.79,35.76 21.3,36.25 21.3,37.8 22.37,38.86 22.37,39.39 R682.2 22.35,40.44 22.35,40.62 22.2,40.78 21.94,40.78 21.61,41.1 21.61,41.49 21.5,41.59 U26.31
  IN1 w0.079: v3(107.22,53.16) 107.31,53.16 107.48,52.99 107.48,52.84 107.36,52.72 105.45,52.72 104.31,51.58 102.67,51.58 102.25,51.16 102,51.16 101.77,50.93 100.27,50.93 99.94,51.26 98.59,51.26 98.06,50.74 94.62,50.74 93.56,49.68 93.56,49.39 92.95,48.78 92.95,48.45 92.39,47.89 92.39,44.08 91.55,43.24 91.55,40.95 90.26,39.66 90.26,39.26 88.92,37.93 88.92,35.25 87.19,33.52 82.15,33.52 81.98,33.69 79.25,33.69 79,33.93 76.84,33.93 75.65,35.12 73.98,35.12 71.53,37.57 69.63,37.57 68.96,38.24 67,38.24 63.02,42.22 62.74,42.22 61.77,43.19 59.11,43.19 58.29,44 54.05,44 53.21,44.84 53.21,47.95 50.95,50.22 50.95,50.83 50.37,51.41 50.37,52.82 50.84,53.29 51.28,53.29 51.29,53.28 51.4,53.28 51.45,53.22 v1(51.45,52.93)
  BOTTOM w0.102: v1(51.45,52.93) 51.45,53.22 51.41,53.26 51.07,53.26 50.65,53.26 49.74,52.36 49.48,52.36 49.48,52.36 48.08,52.36 47.19,53.25 46.88,53.25 46.43,52.8 46.43,52.37 44.52,50.46 44.52,49.29 36.58,41.35 33.93,41.35 27.5,34.92 24.03,34.92 23.31,35.64 22.65,35.64 v1(22.47,35.47) ; v3(107.22,53.16) 107.22,52.8 107.12,52.7 U80.N7
DDI2_CTRL_DATA: length 133.8
  TOP w0.102: U26.32 21.9,41.57 21.82,41.49 21.82,41.19 22.02,40.99 22.28,40.99 22.56,40.71 22.56,40.46 R681.2 22.67,39.49 22.67,39.48 22.58,39.39 22.58,38.78 21.51,37.71 21.51,36.34 21.88,35.97 22.37,35.97 v1(22.47,36.08)
  IN1 w0.079: v1(51.45,53.67) 51.26,53.47 50.76,53.47 50.18,52.9 50.18,51.33 50.77,50.75 50.77,50.14 53.03,47.88 53.03,44.76 53.98,43.81 58.22,43.81 59.03,43 61.7,43 62.66,42.04 62.94,42.04 66.92,38.06 68.88,38.06 69.55,37.39 71.45,37.39 73.91,34.93 75.58,34.93 76.76,33.75 78.93,33.75 79.17,33.5 81.91,33.5 82.08,33.33 87.27,33.33 89.11,35.18 89.11,37.85 90.44,39.18 90.44,39.58 91.74,40.88 91.74,43.16 92.58,44 92.58,47.81 92.8,48.04 v1(93.13,48.04) 93.13,48.7 93.74,49.31 93.74,49.61 94.69,50.55 98.14,50.55 98.66,51.08 99.86,51.08 100.19,50.75 101.85,50.75 102.08,50.98 102.33,50.98 102.74,51.39 104.39,51.39 105.53,52.53 107.43,52.53 107.66,52.76 107.66,53 v3(107.82,53.15)
  BOTTOM w0.102: R877.1 92.49,48.96 93.13,48.32 v1(93.13,48.04) ; v1(22.47,36.08) 22.69,35.85 23.4,35.85 24.12,35.14 27.41,35.14 33.84,41.56 36.49,41.56 44.31,49.38 44.31,50.55 46.22,52.46 46.22,52.88 46.79,53.46 47.28,53.46 48.17,52.57 49.57,52.57 49.66,52.57 50.56,53.47 50.99,53.47 51.26,53.47 v1(51.45,53.67) ; U80.N8 107.55,52.88 v3(107.82,53.15)
DDI2_HPD: length 101.2
  TOP w0.102: v1(59.47,41.63) 59.4,41.56 56.53,41.56 56.23,41.87 49.58,41.87 49.55,41.89 38.67,41.89 38.19,41.42 33.64,41.42 32.07,42.98 v1(28.16,42.98) 24.25,42.98 24.22,42.96 23.59,43.59 23.25,43.59 23.08,43.77 U26.3
  IN1 w0.079: v3(106.57,52.14) 106.57,52.08 104.26,49.77 103.01,49.77 102.23,48.98 102.23,45.83 101.79,45.39 101.41,45.39 98.27,42.24 97.23,42.24 95.97,40.99 95.48,40.99 91.1,36.61 91.1,35.04 88.07,32 84.05,32 83.72,32.32 76.13,32.32 74.68,33.77 73.59,33.77 72.17,35.19 70.78,35.19 69.32,36.66 69.23,36.66 68.57,37.31 66.61,37.31 62.64,41.29 61.2,41.29 60.6,41.89 59.73,41.89 v1(59.47,41.63)
  BOTTOM w0.102: v3(106.57,52.14) 106.9,51.81 U80.L7
DDI2_LANE_DN*<0>: length 144
  TOP w0.102: C982.1 28.16,45.08 28.43,45.08 28.64,44.86 28.64,44.19 28.75,44.09 29.1,44.09 29.17,44.15 v1(29.17,44.33)
  IN1 w0.079: v1(133.77,40) 133.95,39.82 134.12,39.82 134.36,39.58 134.36,38.59 133.89,38.12 133.89,36.07 128.2,30.39 124.77,30.39 118.38,24 117.32,24 116.54,23.22 112.18,23.22 108.69,19.73 104.38,19.73 103.17,18.52 99.25,18.52 98.41,17.68 91,17.68 90.69,17.99 64.19,17.99 57.44,24.75 57.44,26.88 53,31.32 52.15,31.32 49.97,33.5 49.21,33.5 40.73,41.97 34.38,41.97 33.17,43.18 29.97,43.18 29.66,42.87 28.93,42.87 28.44,43.37 28.44,43.96 28.69,44.21 29.05,44.21 v1(29.17,44.33)
  BOTTOM w0.076: U80.C50 131.97,47.23 132.07,47.23 132.16,47.14 132.16,47.02 132.09,46.96 132.09,46.83 132.01,46.75 131.69,46.75 131.6,46.66 131.55,46.52 131.55,46.33 131.59,46.24 131.59,45.99 131.55,45.89 131.55,45.48 131.68,45.35 131.68,44.64 131.57,44.53 131.57,42.99 131.85,42.71 131.85,42.42 131.85,42.41 131.85,42.4
  BOTTOM w0.102: v1(133.77,40) 133.77,39.78 133.7,39.7 133.39,39.7 133.2,39.89 132.34,39.89 131.85,40.38 131.85,42.4
DDI2_LANE_DN*<1>: length 150.3
  TOP w0.102: v1(25.98,44.46) 25.71,44.19 25.52,44.19 C141.1
  IN1 w0.079: v1(135.49,39.18) 135.49,39.46 135.55,39.52 136.03,39.52 136.38,39.17 136.38,38.59 136.9,38.07 136.9,36.6 128.65,28.35 125.29,28.35 119.35,22.41 119.35,21.8 118.97,21.42 116.6,21.42 115.59,20.4 111.93,20.4 109.09,17.56 108.63,17.56 105.1,14.03 95.39,14.03 93.76,15.66 79.04,15.66 78.61,16.09 63.62,16.09 55.68,24.02 55.68,26.15 52.34,29.5 51.41,29.5 50.56,30.34 48.57,30.34 43.81,35.11 43.81,35.87 42.16,37.52 34.49,37.52 32.22,39.78 30.35,39.78 27.19,42.95 27.19,43.81 26.96,44.03 26.22,44.03 26.14,44.12 26.06,44.12 25.98,44.2 v1(25.98,44.46)
  BOTTOM w0.076: 134.86,43 134.87,43.01 134.87,43.15 133.09,44.94 133.09,45.5 133.22,45.63 133.22,45.89 133.16,46 133.16,46.15 133.22,46.35 133.22,46.52 133.13,46.77 132.96,47.06 U80.C52
  BOTTOM w0.102: v1(135.49,39.18) 135.1,39.57 135.1,39.79 134.86,40.02 134.86,40.86 135.28,41.27 135.28,41.98 134.86,42.39 134.86,43
DDI2_LANE_DN*<2>: length 147.4
  TOP w0.102: v1(30.82,40.8) 31.01,40.8 31.11,40.7 31.11,40.7 31.12,40.68 31.12,40.36 30.9,40.14 30.39,40.14 28.62,41.91 25.46,41.91 C984.1
  IN1 w0.079: v1(30.82,40.8) 31.06,40.8 31.13,40.88 31.13,40.96 31.25,41.08 31.25,41.4 31.6,41.75 33.04,41.75 36.59,38.2 42.4,38.2 44.82,35.78 45.36,35.78 50.13,31 50.82,31 51.64,30.18 52.57,30.18 56.33,26.42 56.33,24.29 63.88,16.74 79.28,16.74 79.69,16.32 87.4,16.32 87.92,16.85 90.27,16.85 90.54,16.57 94.18,16.57 95.42,15.33 98.11,15.33 98.8,16.02 103.38,16.02 105.78,18.42 108.96,18.42 111.66,21.12 112.62,21.12 112.89,21.39 114.83,21.39 115.16,21.72 115.99,21.72 116.35,22.08 117.24,22.08 117.95,22.79 118.79,22.79 125.01,29.01 128.4,29.01 136.2,36.82 136.2,37.73 136.01,37.93 135.81,37.93 135.7,37.82 v1(135.7,37.57)
  BOTTOM w0.076: U80.A50 131.89,45.78 131.92,45.74 131.92,45.68 131.92,45.68 131.92,43.55 131.92,43.54 131.92,43.53
  BOTTOM w0.102: v1(135.7,37.57) 135.7,37.86 135.66,37.9 135.52,37.9 135.43,37.99 135.24,37.99 134.96,38.27 134.96,38.72 134.31,39.36 134.31,40.44 133.7,41.05 133.26,41.05 132.37,41.94 132.37,42.96 131.92,43.41 131.92,43.53
