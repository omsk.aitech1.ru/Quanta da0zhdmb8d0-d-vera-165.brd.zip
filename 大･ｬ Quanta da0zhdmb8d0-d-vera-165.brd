# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TCH_PNL_RST*: length 114.8
  TOP w0.102: R6007.1 43.56,64.2 42,62.64 CR16.1 41.11,62.64 40.55,62.08 v1(40,62.08) ; v1(103.83,43.57) 103.83,42.16 103.35,41.69 R1064.2
  IN1 w0.079: v1(40,62.08) 40,62.08 40,61.32 40.6,60.72 40.6,58.83 41.04,58.4 43.93,58.4 44.74,57.6 44.74,56.52 47.67,53.59 47.67,51.21 48.84,50.05 48.84,48.87 50.44,47.26 50.44,44.27 53.07,41.64 56.79,41.64 59.47,38.96 61.5,38.96 68.13,32.33 69.12,32.33 69.66,31.78 70.1,31.78 70.38,31.5 70.38,30.41 71.16,29.62 78.13,29.62 79.22,28.53 83.54,28.53 84.11,27.96 84.91,27.96 85.22,28.27 87.69,28.27 88.64,29.22 90.04,29.22 94.82,34 98.45,34 104.03,39.58 104.03,40.75 103.51,41.27 103.51,43.26 v1(103.83,43.57) 103.93,43.47 104.49,43.47 104.84,43.82 104.84,45.19 105.29,45.64 105.29,47.47 107.05,49.23 107.05,51.03 107.21,51.19 108.05,51.19 108.83,51.98 108.83,52.38 109.14,52.69 109.36,52.69 v3(109.82,53.14)
  BOTTOM w0.076: v3(109.82,53.14) 110.15,52.82 U80.N12
TCH_RST*: length 11.8
  TOP w0.102: v1(45.66,65.44) 44.56,64.33 R6007.2 44.56,63.7 44.34,63.48 CR16.2
  BOTTOM w0.102: J8L1.30 50.9,61.27 50.51,61.65 50.51,62.58 47.17,65.92 46.14,65.92 v1(45.66,65.44)
TLS_CONFIDENTIALITY: length 19
  IN1 w0.079: v1(95.47,51.6) 95.87,51.2 97.87,51.2 98.42,51.75 100.11,51.75 100.46,51.39 102.18,51.39 102.58,51.79 104.09,51.79 105.85,53.55 107.94,53.55 v3(108.53,54.14)
  BOTTOM w0.102: v3(108.53,54.14) 108.85,53.82 U80.R10 ; v1(95.47,51.6) 95.47,52.07 96.62,53.22 96.62,53.26 R892.2 R1097.2
TP_DDR0_ALERT*: length 10
  BOTTOM w0.076: U80.AW50 131.82,66.55 131.49,66.88 131.49,67.88 131.25,68.12 131.25,70.12 132.68,71.56 132.68,72.82 133.19,73.33 133.19,75.01 133.37,75.2 R1117.1
TP_DDR1_ALERT*: length 1.5
  TOP w0.102: v3(128.58,63.09) 128.62,63.05 R1120.1
  BOTTOM w0.076: U80.AN43 v3(128.58,63.09)
TP_DDR1_PARITY: length 2.9
  TOP w0.102: TP33.1 128.97,62.32 128.97,63.33 v3(128.58,63.72)
  BOTTOM w0.076: v3(128.58,63.72) U80.AP43
TP_DDR3_DRAMRST*: length 15.3
  TOP w0.102: TP34.1 100.07,71.02 100.07,70.77 103.04,67.8 103.75,67.09 106.87,67.09 107.38,66.58 109.28,66.58 110.7,65.16 110.7,64.77 110.3,64.37 v3(110.3,64.24)
  BOTTOM w0.102: U80.AT13 110.65,64.64 110.3,64.3 v3(110.3,64.24)
TP_M_A_A<3>: length 6.6
  BOTTOM w0.076: R1115.1 132.87,72.6 132.87,71.48 131.41,70.02 131.41,68.25 131.75,67.91 U80.BA50
TP_M_A_A<4>: length 4.9
  TOP w0.102: R1116.1 v3(134.61,71.98)
  BOTTOM w0.076: U80.BB52 133.08,70.17 134.61,71.7 v3(134.61,71.98)
TP_M_B_A<3>: length 6.5
  TOP w0.102: v3(131.07,73.32) 130.96,73.43 R1118.1
  BOTTOM w0.076: v3(131.07,73.32) 130.64,73.32 130.46,73.13 130.25,72.65 129.29,71.69 129.29,69.97 129.29,69.48 129.19,69.38 129.19,68.51 U80.BB46
TP_M_B_A<4>: length 4.6
  BOTTOM w0.076: U80.BA47 130.18,67.66 130.18,67.88 130.19,67.89 130.19,67.89 130.19,67.9 130.23,67.99 130.23,68.19 130.19,68.28 130.19,68.68 130.31,68.8 130.31,69.41 130.41,69.51 130.41,69.9 130.52,70.02 130.52,70.95 R1119.1
TPCLK_CN: length 3
  BOTTOM w0.102: CN3.2 178.25,22.72 178.58,23.05 178.58,24.11 TP171.1
TPDATA_CN: length 2.9
  BOTTOM w0.102: TP170.1 177.11,24.19 177.11,22.84 177.25,22.7 CN3.3
TPM_PLTRST#: length 58.9
  TOP w0.102: v1(67.37,54.33) v1(66.09,54.33) 64.81,54.33 R1105.2
  IN2 w0.079: v1(95.78,88.17) 95.38,87.78 93.81,87.78 88.32,82.29 87.66,82.29 84.12,78.75 84.12,73.82 83.08,72.79 83.08,70.25 78.88,66.05 77.35,66.05 73.71,62.4 73.71,62.11 68.53,56.94 68.53,55.47 67.39,54.33 v1(67.37,54.33)
  BOTTOM w0.102: v1(95.78,88.17) 95.78,88.35 96.08,88.65 RAP3051.1 96.08,89.29 96.26,89.47 96.97,89.47 97.22,89.22 RAP3049.2 97.83,89.06 98.16,89.39 98.16,91.24 97.86,91.55 97.86,92.16 97.67,92.35 QPM3390.3
TPM_PLTRST#_R: length 3.7
  TOP w0.102: U82.17 61.32,55.58 v1(61.23,55.49) ; R1105.1 63.31,54.14 v1(63.11,54.33)
  IN1 w0.079: v1(63.11,54.33) 62.96,54.33 61.81,55.49 v1(61.23,55.49)
TPM_PP: length 3.3
  TOP w0.254: v1(55.47,56.19) 55.75,56.19 56.08,56.52 U82.7
  TOP w0.381: v1(55.47,56.19) 55.24,56.19 54.87,56.56 RAP1423.2 54.58,56.93 54.8,57.15 RAP1422.2
TPM_SPI_CS*: length 54
  TOP w0.102: RAP3021.1 64.94,58.58 65.65,57.87 65.65,56.29 65.33,55.97 v1(65.27,55.97) 65.14,55.97 64.68,56.42 R5125.2
  IN1 w0.079: v1(102.31,65.22) 102.31,65.69 101.51,66.49 101.51,67.7 98.99,70.22 95.27,70.22 94.23,69.17 90.89,69.17 87.14,65.42 87.14,64.43 86.41,63.69 85.75,63.69 83.51,61.45 82.42,61.45 81.64,60.68 81.64,60.3 80.93,59.59 80.63,59.59 78.6,57.57 76.64,57.57 75.82,58.38 71.67,58.38 71.16,57.87 70.17,57.87 70.07,57.77 70.07,57.46 69.97,57.36 69.72,57.36 69.61,57.46 69.61,57.77 69.51,57.87 67.04,57.87 65.87,56.71 65.87,56.57 v1(65.27,55.97)
  BOTTOM w0.076: U80.AU1 103.32,65.01 102.53,65.01 v1(102.31,65.22)
TPM_SPI_CS*_R: length 3
  TOP w0.102: R5125.1 63.12,57.14 62.15,57.14 61.77,57.52 U82.20
TRACKPAD_INT*: length 179.3
  TOP w0.102: v1(91.5,36.04) 91.5,34.24 87.85,30.59 84.83,30.59 83.26,32.16 76.58,32.16 75.68,33.06 v1(75.68,33.33)
  IN2 w0.079: v3(104.01,69.4) 104.01,69.3 106.34,66.96 106.83,66.96 107.97,65.82 107.97,64.88 108.44,64.41 v3(108.44,64.4) ; v1(145.97,21.32) 145.38,21.91 124.06,21.91 123.55,22.42 119.21,22.42 115.9,25.73 108.96,25.73 108.39,26.3 101.61,26.3 97.12,30.79 96.91,30.79 91.66,36.04 v1(91.5,36.04) 91.5,36.76 89.76,38.5 89.76,39.28 89.3,39.73 89.19,39.85 88.85,39.85 88.18,40.52 88.18,42.58 87.93,42.84 87.93,43.27 87.75,43.45 87.75,44.78 85.44,47.08 85.44,47.59 85.21,47.82 85.15,47.82 84.92,48.06 84.92,48.12 84.22,48.82 84.22,49.82 84.96,50.55 84.96,58.09 85.37,58.5 85.37,58.81 86.27,59.71 86.27,61.65 91.56,66.94 91.56,67.74 92.01,68.19 92.01,71.53 92.66,72.18 92.66,73.26 93.16,73.76 93.16,74.45 94.1,75.39 97.48,75.39 98.26,76.18 98.26,76.33 98.6,76.66 100,76.66 v3(100.8,75.87)
  BOTTOM w0.076: U80.AR10 108.91,63.99 108.5,64.4 v3(108.44,64.4)
  BOTTOM w0.102: v3(100.8,75.87) 100.95,75.71 RAP1452.2 101.54,74.53 101.82,74.25 101.82,73.85 101.57,73.59 101.09,73.59 100.83,73.34 100.83,71.38 102.07,70.14 103.34,70.14 104.01,69.48 v3(104.01,69.4) 104.23,69.17 104.93,69.17 105.62,68.48 105.62,68.22 U80.BA5 ; v1(75.68,33.33) 76.04,33.68 R5084.2 ; v1(145.97,21.32) 147.03,22.39 149.23,22.39 151.36,20.26 v1(157.32,20.26) 163.29,20.26 164.05,21.02 R790.2 163.27,22.9 C785.1
TRACKPAD_PWR_EN: length 110.2
  TOP w0.102: U86.3 175.22,20.71 RCP4021.1 175.54,20.71 175.63,20.61 175.63,19.35 v1(175.49,19.2)
  IN2 w0.079: v1(175.49,19.2) 175.49,18.89 174.46,17.86 167.78,17.86 167.35,18.3 155.8,18.3 155.37,17.86 148.33,17.86 144.95,21.24 121.91,21.24 121.86,21.19 118.31,21.19 114.69,24.81 108.58,24.81 108,25.38 101.87,25.38 101.56,25.07 100.63,25.07 99.26,26.45 97.91,26.45 96.45,27.91 96.45,28.42 95.49,29.38 95.49,30.51 91.36,34.63 90.87,34.63 90.1,35.4 89.49,35.4 89.03,35.87 89.03,36.96 87.69,38.3 87.69,39.06 86.98,39.77 86.98,42.06 86.76,42.27 86.3,42.27 v1(85.9,42.68)
  BOTTOM w0.102: v1(85.9,42.68) 86.3,43.09 86.67,43.09 87.13,43.54 EUPM3247.B55
TS_EN_R: length 3.3
  BOTTOM w0.102: R5157.2 48.1,58.86 48.68,59.44 49.24,59.44 49.9,60.1 J8L1.28
U86_6: length 2.2
  TOP w0.254: C842.2 175,26.08 v1(175,25.56) 175,25.39 175.22,25.17 U86.6
USB1_BC_DN: length 26.2
  TOP w0.102: v1(209.49,16.27) 209.28,16.06 208.73,16.06 v1(208.2,16.59) 207.66,16.06 207.48,16.06 207.33,16.2 EU1B2.11
  BOTTOM w0.102: v1(209.49,16.27) 209.87,15.89 213.59,15.89 214.39,16.69 214.39,19.57 219.19,24.37 223.13,24.37 224.14,23.36 225.68,23.36 225.78,23.45 CN2.12
USB1_BC_DP: length 26.2
  TOP w0.102: EU1B2.10 207.33,15.7 207.48,15.85 207.67,15.85 v1(208.2,15.32) 208.72,15.85 209.18,15.85 v1(209.49,15.54)
  BOTTOM w0.102: CN2.13 225.78,22.95 225.58,23.15 224.05,23.15 223.04,24.16 219.28,24.16 214.6,19.48 214.6,16.6 213.68,15.68 209.63,15.68 v1(209.49,15.54)
USB2_1_DN*: length 3.4
  TOP w0.102: LCP4022.4 17.35,68.51 17.64,68.21 17.73,68.21 v1(18.25,68.74) 18.78,68.21 18.83,68.21 19.08,68.46 19.25,68.46 19.4,68.61 U90.18
USB2_1_DP: length 3.4
  TOP w0.102: LCP4022.1 17.35,67.7 17.64,68 17.73,68 v1(18.25,67.47) 18.79,68 18.92,68 19.17,68.25 19.25,68.25 19.4,68.11 U90.19
USB2_A_DN*: length 2.4
  BOTTOM w0.102: EUCP4040.11 26.64,31.14 26.49,31 25.69,31 25.4,31.29 LCP4041.1
USB2_A_DN_CONN*: length 11.8
  IN2 w0.079: v1(22.06,31.26) 21.79,30.99 21.5,30.99 20.85,30.34 20.85,29.24 20.19,28.59 19.71,28.59 v1(19.43,28.86)
  BOTTOM w0.102: v1(19.43,28.86) 19.14,28.57 18.59,28.57 U6.4 18.45,28.57 17.39,28.57 17.34,28.52 15.9,28.52 15.82,28.61 14.55,28.61 14.45,28.71 J2.2 ; v1(22.06,31.26) 22.33,31 22.5,31 22.8,31.29 LCP4041.2
USB2_A_DP: length 2.4
  BOTTOM w0.102: LCP4041.4 25.4,30.49 25.69,30.79 26.51,30.79 26.65,30.64 EUCP4040.10
USB2_A_DP_CONN: length 11.7
  IN2 w0.079: v1(22.06,30.53) 21.79,30.8 21.57,30.8 21.03,30.26 21.03,29.17 20.27,28.4 19.71,28.4 v1(19.43,28.13)
  BOTTOM w0.102: v1(19.43,28.13) 19.19,28.36 17.48,28.36 17.43,28.31 16.79,28.31 U6.7 16.65,28.31 15.81,28.31 15.73,28.39 14.55,28.39 14.45,28.29 J2.3 ; LCP4041.3 22.85,30.49 22.55,30.79 22.33,30.79 v1(22.06,30.53)
USB2_COMP: length 11.4
  IN1 w0.203: v3(106.7,57.41) 104.34,57.41 103.18,56.26 97.75,56.26 v3(97.5,56.01)
  BOTTOM w0.203: v3(106.7,57.41) U80.AB6
  BOTTOM w0.381: v3(97.5,56.01) 97.91,55.61 R1056.2
USB2_DN*<1>: length 111.1
  TOP w0.102: U90.4 22.19,65.61 21.9,65.33 20.04,65.33 19.49,65.88 19.49,66.2 v1(19.31,66.38)
  IN1 w0.079: v1(19.31,66.38) 19.4,66.38 19.68,66.1 19.68,65.84 19.88,65.64 20.72,65.64 22.05,66.97 23.36,66.97 23.84,67.44 26.52,67.44 26.82,67.74 27.28,67.74 28.11,66.91 29.91,66.91 30.57,67.56 39.68,67.56 42.39,64.85 46.14,64.85 46.52,64.47 47.76,64.47 52.88,59.35 52.88,57.63 56.62,53.9 57.9,53.9 59.09,52.71 59.09,52.08 59.67,51.49 62.25,51.49 63.77,49.97 65.52,49.97 65.85,49.64 68.73,49.64 70.21,48.17 74.32,48.17 74.49,48.34 75.96,48.34 76.79,49.17 81.06,49.17 82.21,50.33 82.21,51 82.58,51.37 83.28,51.37 83.43,51.21 84.35,51.21 86.54,53.4 86.54,54.06 87.75,55.27 90.28,55.27 91.24,56.23 92.93,56.23 93.32,56.62 94.12,56.62 94.43,56.31 95.49,56.31 95.92,56.74 97.28,56.74 97.85,57.32 101.73,57.32 101.88,57.46 103.78,57.46 104.2,57.89 107.97,57.89 108.07,57.78 108.07,57.59 v3(107.9,57.42)
  BOTTOM w0.102: U80.AB9 108.2,57.12 v3(107.9,57.42)
USB2_DN*<2>: length 69.9
  IN1 w0.079: v1(53.28,62.58) 53.53,62.33 53.53,57.9 55.32,56.11 56.65,56.11 60.12,52.64 61.53,52.64 62.01,52.15 62.55,52.15 64.09,50.62 65.86,50.62 66.18,50.29 69,50.29 70.48,48.81 74.04,48.81 74.23,49 75.63,49 76.48,49.84 80.82,49.84 81.5,50.53 81.5,51.9 81.77,52.17 83.58,52.17 87.34,55.93 90.03,55.93 90.98,56.88 92.42,56.88 92.96,57.41 97,57.41 97.55,57.96 102.84,57.96 103.35,58.48 105.45,58.48 105.88,58.9 106.7,58.9 106.8,58.8 106.8,58.66 106.66,58.52 v3(106.57,58.52)
  BOTTOM w0.102: J8L1.35 53.4,61.42 53.54,61.56 53.54,62.32 v1(53.28,62.58) ; v3(106.57,58.52) 106.57,58.35 U80.AD6
USB2_DN*<3>: length 143.8
  IN1 w0.079: v1(115.14,33.15) 115.29,33 115.44,33 115.54,33.1 115.54,33.76 114.44,34.85 114.44,38.01 119.88,43.44 119.88,50.2 119.78,50.3 119.78,52 119.35,52.43 119.35,55.1 118.11,56.34 116.73,56.34 115.76,57.31 115.36,57.31 114.28,58.39 113.75,58.39 112.76,59.39 111.76,59.39 111.06,60.09 111.06,60.61 110.63,61.04 109.34,61.04 109.13,60.83 108.32,60.83 108.17,60.99 107.41,60.99 107.2,61.19 104.56,61.19 103.97,61.78 102.28,61.78 100.69,60.19 100.69,59.36 100.79,59.26 v3(100.97,59.26)
  BOTTOM w0.076: v3(100.97,59.26) 100.77,59.26 100.7,59.33 100.7,59.54 100.86,59.7 102.37,59.7 102.88,60.2 103.54,60.2 103.71,60.13 103.98,60.13 103.98,60.13 104.1,60.18 104.23,60.18 104.4,60.12 104.62,60.12 104.9,60.25 104.95,60.25 105.02,60.17 105.1,60.17 105.31,60.39 105.31,60.51 105.26,60.56 U80.AH3
  BOTTOM w0.102: v1(115.14,33.15) 115.35,32.94 115.35,32.23 115.83,31.75 115.83,27.83 121.27,22.39 121.27,20.46 122.14,19.59 123.24,19.59 124.34,18.49 149.53,18.49 150.61,19.57 166.05,19.57 167.12,20.63 182.12,20.63 185.41,23.92 185.41,28.16 185.71,28.45 CN8.5
USB2_DN*<5>: length 153.4
  TOP w0.102: EU1B2.2 202.89,16.2 202.75,16.06 200.6,16.06 199.1,17.56 199.1,22.89 198.61,23.38 193.91,23.38 193.24,22.72 193.07,22.72 v1(192.8,22.98)
  IN1 w0.079: v1(115.19,31.52) 114.93,31.78 114.93,32.67 113.87,33.73 113.87,38.11 117.55,41.79 117.55,45.29 113.94,48.9 113.94,50.43 114.72,51.21 114.72,51.76 115.78,52.82 115.78,53.79 115.25,54.33 115.25,55.67 112.72,58.2 112.72,58.63 112.35,58.99 111.45,58.99 110.2,60.24 103.17,60.24 102.72,60.69 102.72,61 v1(102.93,61.21)
  BOTTOM w0.076: v1(102.93,61.21) 102.8,61.34 102.8,61.43 102.86,61.49 103.68,61.49 103.88,61.3 103.88,61.09 103.82,61.03 103.55,61.03 103.52,61.06 U80.AJ1
  BOTTOM w0.102: v1(192.8,22.98) 192.8,22.77 192.68,22.64 192.32,22.64 191.68,23.27 185.45,23.27 182.32,20.15 167.35,20.15 166.22,19.01 150.9,19.01 149.83,17.94 124.17,17.94 123.07,19.04 121.97,19.04 120.77,20.25 120.77,22.2 114.83,28.14 114.83,31.31 115.04,31.52 v1(115.19,31.52)
USB2_DN*<6>: length 166.4
  IN1 w0.079: v1(112.22,32.09) 111.99,32.31 111.99,39.9 112.34,40.24 115.09,40.24 116.07,41.22 116.07,44.18 112.77,47.48 112.77,50.68 112.06,51.39 112.06,51.75 111.54,52.26 111.54,53.66 112.72,54.84 112.72,55.88 113.12,56.28 113.12,56.94 112.49,57.56 111.4,57.56 110.86,58.11 110.86,58.44 110.17,59.13 108.33,59.13 107.61,59.85 106.93,59.85 v3(106.56,59.48)
  IN2 w0.079: v1(223.42,16.16) 223.64,16.16 223.78,16.02 223.78,15.88 223.25,15.35 218.46,15.35 211.98,21.83 206.42,21.83 205.76,22.49 203.17,22.49 202.61,23.05 200.7,23.05 197.6,26.14 182.69,26.14 181.15,24.6 176.24,24.6 175.95,24.32 154.64,24.32 154.14,23.82 152.66,23.82 149.93,26.55 136.87,26.55 136.31,27.11 121.29,27.11 117.9,30.5 114.7,30.5 113.57,31.63 111.94,31.63 111.8,31.77 111.8,32.04 111.9,32.14 112.17,32.14 v1(112.22,32.09)
  BOTTOM w0.102: U80.AF6 106.56,59.41 v3(106.56,59.48) ; v1(223.42,16.16) 223.63,16.37 223.63,17.14 224.77,18.28 225.01,18.28 225.54,18.81 225.63,18.81 225.78,18.95 CN2.21
USB2_DN*<9>: length 98.8
  IN1 w0.079: v3(102.35,59.3) 102.47,59.3 102.58,59.2 102.58,58.96 102.43,58.82 100.22,58.82 99.49,59.55 98.62,59.55 98.15,59.07 97.58,59.07 97.29,58.78 95.64,58.78 95.11,58.26 93.25,58.26 92.82,58.69 90.53,58.69 89.89,58.06 88.04,58.06 84.08,54.09 82.67,54.09 82.07,53.49 80.49,53.49 80.18,53.18 78.78,53.18 78.58,52.97 76.87,52.97 75.18,51.28 75.18,51.12 73.7,49.65 70.83,49.65 68.98,51.5 64.42,51.5 62.93,53 62.34,53 61.83,53.51 61.05,53.51 56.69,57.86 55.7,57.86 55.6,57.96 v1(55.6,58.22)
  BOTTOM w0.076: v3(102.35,59.3) 102.48,59.3 102.85,59.67 103.35,59.67 103.52,59.85 U80.AG1
  BOTTOM w0.102: EUCP4040.2 30.83,31.14 30.98,31 31.12,31 32.53,32.41 32.53,34.62 36.99,39.08 36.99,39.26 v1(36.47,39.78) 37.03,40.34 37.03,40.43 45.97,49.37 45.97,49.97 47.45,51.45 51.87,51.45 54.87,54.46 54.87,57.68 55.12,57.93 55.31,57.93 v1(55.6,58.22)
USB2_DP<1>: length 111.1
  TOP w0.102: U90.3 21.69,66.31 21.57,66.19 21.57,66.11 21.63,66.05 21.94,66.05 21.98,66.01 21.98,65.7 21.82,65.54 20.13,65.54 19.7,65.97 19.7,66.27 19.8,66.37 v1(20.12,66.37)
  IN1 w0.079: v3(108.53,57.42) 108.42,57.42 108.26,57.58 108.26,57.86 108.04,58.07 104.12,58.07 103.7,57.65 101.8,57.65 101.66,57.5 97.77,57.5 97.2,56.93 95.84,56.93 95.41,56.5 94.51,56.5 94.19,56.81 93.24,56.81 92.85,56.42 91.17,56.42 90.2,55.46 87.67,55.46 86.35,54.14 86.35,53.47 84.28,51.4 83.51,51.4 83.36,51.55 82.5,51.55 82.03,51.08 82.03,50.4 80.98,49.36 76.72,49.36 75.88,48.52 74.41,48.52 74.24,48.35 70.29,48.35 68.81,49.83 65.93,49.83 65.6,50.16 63.85,50.16 62.32,51.68 59.75,51.68 59.28,52.15 59.28,52.79 57.98,54.08 56.69,54.08 53.07,57.71 53.07,59.43 47.84,64.66 46.59,64.66 46.22,65.03 42.47,65.03 39.75,67.75 30.49,67.75 29.84,67.1 28.19,67.1 27.36,67.93 26.74,67.93 26.44,67.63 23.76,67.63 23.28,67.16 21.97,67.16 20.64,65.83 19.96,65.83 19.86,65.92 19.86,66.11 v1(20.12,66.37)
  BOTTOM w0.102: U80.AB10 108.53,57.28 v3(108.53,57.42)
USB2_DP<2>: length 69.9
  IN1 w0.079: v1(54.02,62.58) 53.71,62.28 53.71,57.98 55.4,56.29 56.73,56.29 60.2,52.82 61.6,52.82 62.09,52.34 62.63,52.34 64.17,50.8 65.93,50.8 66.26,50.47 69.08,50.47 70.56,49 73.97,49 74.15,49.18 75.56,49.18 76.4,50.03 80.74,50.03 81.32,50.6 81.32,51.98 81.69,52.35 83.5,52.35 87.27,56.12 89.95,56.12 90.9,57.06 92.35,57.06 92.88,57.6 96.93,57.6 97.48,58.15 102.76,58.15 103.28,58.66 105.38,58.66 105.8,59.09 106.77,59.09 106.99,58.88 106.99,58.75 v3(107.22,58.52)
  BOTTOM w0.102: J8L1.36 53.9,61.42 53.76,61.56 53.76,62.32 v1(54.02,62.58) ; v3(107.22,58.52) 106.9,58.19 U80.AD7
USB2_DP<3>: length 143.8
  IN1 w0.079: v1(115.95,33.15) 115.72,33.38 115.72,33.83 114.63,34.92 114.63,37.93 120.07,43.36 120.07,50.27 119.96,50.38 119.96,52.08 119.53,52.51 119.53,55.18 118.18,56.53 116.81,56.53 115.84,57.5 115.44,57.5 114.36,58.58 113.83,58.58 112.84,59.58 111.83,59.58 111.24,60.16 111.24,60.69 110.7,61.23 109.26,61.23 109.05,61.02 108.4,61.02 108.25,61.17 107.49,61.17 107.28,61.38 104.64,61.38 104.05,61.96 102.2,61.96 100.5,60.27 100.5,59.44 v3(100.32,59.26)
  BOTTOM w0.076: U80.AJ3 104.82,61.23 104.82,60.43 104.75,60.36 104.58,60.29 104.42,60.29 104.29,60.33 104.29,60.34 104.27,60.34 104.24,60.34 104.21,60.35 104.08,60.35 103.95,60.3 103.94,60.29 103.74,60.29 103.58,60.37 102.81,60.37 102.3,59.87 100.79,59.87 100.53,59.61 100.53,59.47 v3(100.32,59.26)
  BOTTOM w0.102: CN8.3 186.54,28.95 186.25,28.66 185.62,28.66 185.2,28.24 185.2,24.01 182.03,20.84 167.03,20.84 165.96,19.78 150.52,19.78 149.45,18.7 124.43,18.7 123.33,19.8 122.23,19.8 121.48,20.55 121.48,22.48 116.04,27.92 116.04,31.83 115.56,32.32 115.56,33.08 115.64,33.15 v1(115.95,33.15)
USB2_DP<5>: length 153.4
  TOP w0.102: EU1B2.3 202.9,15.7 202.75,15.85 200.51,15.85 198.89,17.47 198.89,22.8 198.52,23.17 194,23.17 193.33,22.5 193.07,22.5 v1(192.8,22.24)
  IN1 w0.079: v1(114.48,31.52) 114.74,31.78 114.74,32.6 113.68,33.65 113.68,38.18 117.37,41.87 117.37,45.21 113.75,48.83 113.75,50.5 114.54,51.29 114.54,51.84 115.6,52.9 115.6,53.72 115.06,54.25 115.06,55.59 112.53,58.12 112.53,58.56 112.28,58.81 111.37,58.81 110.13,60.05 103.09,60.05 102.53,60.61 102.53,60.95 v1(102.29,61.18)
  BOTTOM w0.076: U80.AJ2 103.75,61.65 102.76,61.65 v1(102.29,61.18)
  BOTTOM w0.102: v1(114.48,31.52) 114.62,31.37 114.62,28.05 120.56,22.11 120.56,20.16 121.89,18.83 122.99,18.83 124.09,17.73 149.91,17.73 150.99,18.8 166.31,18.8 167.44,19.94 182.41,19.94 185.53,23.06 191.59,23.06 192.23,22.43 192.62,22.43 v1(192.8,22.24)
USB2_DP<6>: length 166.3
  IN1 w0.079: v3(107.2,59.48) 107.2,59.63 107.23,59.67 107.54,59.67 108.26,58.95 110.09,58.95 110.67,58.37 110.67,58.03 111.32,57.38 112.42,57.38 112.93,56.86 112.93,56.35 112.53,55.96 112.53,54.91 111.36,53.74 111.36,52.18 111.87,51.67 111.87,51.31 112.58,50.6 112.58,47.4 115.88,44.1 115.88,41.3 115.01,40.43 112.26,40.43 111.81,39.97 111.81,31.81 111.7,31.71 111.57,31.71 111.41,31.88 v1(111.41,32.09)
  IN2 w0.079: v1(111.41,32.09) 111.62,31.88 111.62,31.69 111.87,31.44 113.49,31.44 114.62,30.31 117.82,30.31 121.21,26.92 136.24,26.92 136.8,26.36 149.85,26.36 152.59,23.63 154.22,23.63 154.72,24.13 176.03,24.13 176.32,24.42 181.23,24.42 182.77,25.96 197.53,25.96 200.62,22.87 202.53,22.87 203.09,22.31 205.68,22.31 206.34,21.65 211.9,21.65 218.38,15.16 223.33,15.16 223.97,15.81 223.97,15.98 v1(224.16,16.16)
  BOTTOM w0.102: v1(224.16,16.16) 224.11,16.11 223.92,16.11 223.84,16.19 223.84,17.05 224.86,18.06 225.1,18.06 225.63,18.59 225.72,18.59 225.86,18.45 CN2.22 ; U80.AF7 107.2,59.39 v3(107.2,59.48)
USB2_DP<9>: length 98.8
  IN1 w0.079: v1(55.6,57.48) 55.8,57.68 56.61,57.68 60.97,53.32 61.76,53.32 62.26,52.81 62.85,52.81 64.35,51.32 68.9,51.32 70.76,49.46 73.78,49.46 75.36,51.04 75.36,51.2 76.95,52.79 78.66,52.79 78.86,52.99 80.26,52.99 80.57,53.3 82.15,53.3 82.75,53.91 84.15,53.91 88.12,57.87 89.97,57.87 90.6,58.5 92.74,58.5 93.18,58.07 95.19,58.07 95.72,58.6 97.37,58.6 97.66,58.88 98.22,58.88 98.7,59.36 99.42,59.36 100.14,58.63 102.51,58.63 102.76,58.88 102.76,59.06 v1(102.98,59.28)
  BOTTOM w0.076: v1(102.98,59.28) 103.22,59.52 103.41,59.52 103.55,59.66 103.93,59.66 U80.AG2
  BOTTOM w0.102: v1(55.6,57.48) 55.37,57.72 55.21,57.72 55.08,57.59 55.08,54.37 51.95,51.24 47.54,51.24 46.18,49.88 46.18,49.28 37.24,40.34 37.24,40.28 v1(37.74,39.78) 37.2,39.25 37.2,39 32.74,34.53 32.74,32.32 31.2,30.79 30.98,30.79 30.83,30.64 EUCP4040.3
USB2_OC*<0>: length 107.7
  TOP w0.102: PU2.C1 31.98,67.11 v1(32.86,66.23)
  IN1 w0.079: v1(32.86,66.23) 32.91,66.17 32.91,64.81 39.54,58.18 42.63,58.18 46.3,54.52 46.3,51.89 48.48,49.71 48.48,48.72 50.08,47.11 50.08,44.12 52.92,41.28 56.64,41.28 59.32,38.6 61.35,38.6 67.93,32.02 67.93,31.92 70.59,29.26 73.05,29.26 73.87,28.44 78.8,28.44 79.07,28.17 83.39,28.17 83.96,27.6 85.06,27.6 85.37,27.91 87.84,27.91 88.78,28.86 90.19,28.86 94.79,33.46 98.42,33.46 104.41,39.45 104.41,41.54 v1(104.61,41.73)
  BOTTOM w0.076: U80.A9 108.17,45.24 106.98,44.05 105.94,44.05 105.49,43.61
  BOTTOM w0.102: 105.49,43.61 104.61,42.72 v1(104.61,41.73) 104.61,41.36 RAP1434.2
USB2_OC*<1>: length 8.4
  BOTTOM w0.076: U80.C9 108.18,47.06 108.35,46.77 108.42,46.56 108.43,46.52 108.43,46.35 108.38,46.15 108.38,46 108.43,45.89 108.43,45.13 107.13,43.82 107.03,43.82
  BOTTOM w0.102: 107.03,43.82 105.96,43.82 104.89,42.76 104.89,42.3 TP253.1 105.22,41.24 RAP1438.2
USB2_OC*<2>: length 129.7
  TOP w0.102: v1(206.16,19.11) 205.86,18.81 EU1B2.13
  IN2 w0.079: v1(105.35,42.63) 105.68,42.3 105.68,38.88 106.42,38.14 106.42,33.79 110.48,29.73 110.48,29.04 110.96,28.56 117.1,28.56 120.6,25.05 135.63,25.05 136.1,24.58 147.27,24.58 150.89,20.97 153.72,20.97 154.32,21.57 154.88,21.57 155.44,21.01 160.98,21.01 161.64,21.67 165.6,21.67 166.63,20.65 169.7,20.65 169.7,20.64 172.47,20.64 173.37,21.55 184.53,21.55 186.77,23.78 194.05,23.78 198.02,19.81 205.46,19.81 v1(206.16,19.11)
  BOTTOM w0.076: 107.03,43.59 107.28,43.59 108.6,44.91 108.6,45.92 108.56,46.02 108.56,46.21 108.6,46.3 108.6,46.54 108.6,46.56 108.57,46.66 108.46,47.02 108.46,47.14 108.38,47.41 108.36,47.44 U80.D9
  BOTTOM w0.102: 107.03,43.59 106.29,43.59 105.35,42.66 v1(105.35,42.63) 105.35,42.58 105.66,42.27 105.66,41.36 RAP1436.2
USB2_OC*<3>: length 115.2
  IN1 w0.079: v1(103.96,41.55) 103.96,41.48 104.21,41.24 104.21,39.5 98.53,33.82 94.89,33.82 90.11,29.04 88.71,29.04 87.77,28.09 85.29,28.09 84.98,27.78 84.03,27.78 83.47,28.35 79.15,28.35 78.06,29.44 70.66,29.44 68.11,32 68.11,32.1 61.43,38.78 59.4,38.78 56.71,41.46 53,41.46 50.26,44.2 50.26,47.19 48.66,48.79 48.66,49.97 47.06,51.57 v1(47.06,52.75)
  BOTTOM w0.076: U80.B9 107.84,46.11 107.84,45.17 106.95,44.28 105.91,44.28 105.42,43.79
  BOTTOM w0.102: RAP1440.2 103.79,41.14 103.96,41.32 v1(103.96,41.55) 103.96,41.63 104.41,42.07 104.41,42.78 105.42,43.79 ; v1(47.06,52.75) 47.06,52.32 45.46,50.71 45.46,49.55 36.78,40.87 v1(35.45,40.87) 34.13,40.87 33.6,40.34 28.01,34.75 EUCP4040.13
USB2_OTG_ID: length 45.5
  IN2 w0.079: v3(105.59,60.75) 105.16,60.75 104.09,59.68 100.04,59.68 99.58,59.22 98.6,59.22 98.45,59.07 95.91,59.07 95.85,59.13 91.48,59.13 90.75,58.41 90.75,57.86 89.4,56.5 89.4,55.57 89.1,55.28 89.1,54.3 89.73,53.68 89.73,51.35 89.33,50.95 89.33,48.73 91.66,46.4 v1(91.66,45.63)
  BOTTOM w0.076: v3(105.59,60.75) 105.59,60.23 105.55,60.19 105.35,60.19 105.05,59.9 U80.AG3
  BOTTOM w0.102: v1(91.66,45.63) 90.82,45.63 90.7,45.75 87.4,45.75 86.85,45.2 86.85,44.56 86.4,44.1 85.62,44.1 85.21,43.7 81.73,43.7 81.49,43.93 81.49,44.52 81.21,44.81 EUPM3247.B40
USB2_OTG_VBUS_SNS: length 46.9
  IN2 w0.079: v1(88.97,56.57) 88.98,56.57 89,56.6 89.24,56.6 90.57,57.93 90.57,58.48 92.03,59.94 95.29,59.94 95.99,59.25 98.37,59.25 98.53,59.4 99.51,59.4 99.97,59.86 104.01,59.86 105.28,61.12 105.75,61.12 106.13,60.75 v3(106.13,60.63)
  BOTTOM w0.102: v3(106.13,60.63) 105.88,60.38 105.88,60.23 105.55,59.9 U80.AG4 ; EUPM3247.A46 85.46,46.99 85.97,47.51 v1(85.97,48.59) 85.97,49.68 84.34,51.32 83.69,51.32 82.19,52.81 78.6,52.81 78.25,53.17 78.25,53.8 78.48,54.03 78.84,54.03 79.15,53.73 81.24,53.73 81.96,54.45 81.96,54.91 82.26,55.2 83.58,55.2 84.68,56.29 88.23,56.29 88.51,56.57 v1(88.97,56.57)
USB3_A_TX_DN*: length 10
  BOTTOM w0.102: J2.8 12.95,31.41 13.1,31.55 13.23,31.55 14.07,30.71 16.65,30.71 U6.10 16.79,30.71 17.35,30.71 17.4,30.76 20.59,30.76 20.82,30.54 20.82,30.41 20.65,30.24 LCP4042.3
USB3_A_TX_DP: length 10
  BOTTOM w0.102: LCP4042.2 21.2,30.24 21.03,30.41 21.03,30.63 20.68,30.97 18.59,30.97 U6.1 18.45,30.97 17.32,30.97 17.26,30.92 14.16,30.92 13.32,31.77 13.14,31.77 12.95,31.96 J2.9
USB3_RX_DN*<1>: length 123.1
  IN1 w0.079: v1(30.46,59.27) 30.27,59.27 30.17,59.16 30.17,58.91 31.13,57.95 37.16,57.95 38.38,56.73 42.16,56.73 43.56,55.33 43.56,54.48 44.09,53.96 44.09,49.93 48.38,45.63 48.38,44.66 53.33,39.71 57.04,39.71 59.29,37.47 60.71,37.47 66.54,31.64 66.82,31.64 70.02,28.44 72.22,28.44 73.04,27.62 78.46,27.62 78.73,27.35 83,27.35 83.58,26.76 87.85,26.76 88.73,27.64 90.48,27.64 94.22,31.38 101.65,31.38 103.24,32.98 103.24,35.27 105.78,37.8 105.78,43.49 107.01,44.73 107.01,48.33 107.94,49.26 107.94,49.57 108.46,50.09 v3(108.46,50.19)
  BOTTOM w0.102: v1(30.46,59.27) 30.25,59.06 30.25,58.77 29.91,58.43 28.52,58.43 27.84,59.11 24.5,59.11 23.89,58.5 22.87,58.5 22.18,59.18 U96.17 ; v3(108.46,50.19) 108.19,50.45 U80.H8
USB3_RX_DN*<2>: length 152.7
  IN2 w0.079: v3(107.45,50.79) 107.45,50.71 107.54,50.62 107.86,50.62 108.09,50.39 108.09,47.81 107.8,47.51 107.8,43.68 107.51,43.39 107.51,42.17 106.35,41.01 106.35,39.15 107.06,38.44 107.06,34.06 110.79,30.34 113.03,30.34 114.16,29.21 117.36,29.21 120.78,25.79 135.81,25.79 136.37,25.23 147.54,25.23 149.85,22.92 150.51,22.92 151.07,22.37 154.7,22.37 155.31,22.98 156.41,22.98 156.49,22.89 165.42,22.89 166.96,21.35 172.18,21.35 173.07,22.24 183.76,22.24 186.33,24.81 196.92,24.81 201.21,20.51 210.86,20.51 217.31,14.06 223.8,14.06 223.99,14.26 224.58,14.26 224.76,14.07 224.76,13.78 v1(225,13.55)
  BOTTOM w0.102: CN2.28 225.85,15.45 225.77,15.53 225.77,15.6 225.7,15.67 225.53,15.67 224.68,14.82 224.68,13.63 224.76,13.55 v1(225,13.55) ; v3(107.45,50.79) 107.13,51.11 U80.J6
USB3_RX_DN*<3>: length 150.1
  IN2 w0.079: v1(225.2,20.24) 225.41,20.03 225.67,20.03 225.95,19.75 225.95,18.73 225.43,18.21 224.85,18.21 223.26,16.62 223.11,16.62 222.47,15.98 218.48,15.98 211.49,22.97 203.47,22.97 202.81,23.63 201.19,23.63 198.21,26.6 182.42,26.6 180.89,25.08 176.07,25.08 175.78,24.79 157.91,24.79 157.38,25.32 151.81,25.32 150.1,27.03 137.05,27.03 136.48,27.59 134.76,27.59 134.01,28.35 120.7,28.35 117.12,31.93 115.41,31.93 113.2,34.14 109.5,34.14 109.18,34.46 109.18,38.19 108.68,38.69 107.81,38.69 107.2,39.3 107.2,41.18 108.37,42.36 108.37,47.44 108.7,47.77 108.7,48.63 108.83,48.76 108.83,50.43 109.06,50.65 109.25,50.65 v3(109.45,50.85)
  BOTTOM w0.102: CN2.18 225.92,20.45 225.72,20.25 225.72,20.13 225.65,20.06 225.38,20.06 v1(225.2,20.24) ; U80.J10 109.2,51.11 v3(109.45,50.85)
USB3_RX_DN*<4>: length 138
  IN1 w0.079: v3(109.38,48.28) 109.35,48.28 109.17,48.46 108.98,48.46 108.44,47.93 108.44,47.06 108.8,46.7 108.8,44.36 111.25,41.91 111.25,35.16 110.44,34.35 110.01,34.35 104.87,29.21 102.02,29.21 100.64,27.84 98.82,27.84 98.58,27.59 98.05,27.59 97.3,26.85 93.39,26.85 91.23,24.69 88.96,24.69 88.91,24.64 86,24.64 85.62,24.26 82.59,24.26 81.65,25.2 77.82,25.2 77.73,25.28 70.1,25.28 69.54,25.84 68.65,25.84 64.91,29.58 64.91,30.22 59.82,35.31 57.78,35.31 55.81,37.27 54.6,37.27 54.35,37.52 54.35,37.7 v1(54.12,37.94)
  BOTTOM w0.102: v1(54.12,37.94) 54.38,38.2 54.38,38.3 54.19,38.49 43.63,38.49 42.84,37.7 41.7,37.7 41.52,37.52 37.69,37.52 34.13,33.96 34.13,31.75 33.13,30.75 33.13,29.8 30.64,27.31 30.64,25.9 29.11,24.37 20.6,24.37 19.19,25.77 19.19,27.24 18.87,27.56 17.51,27.56 17.46,27.51 16.79,27.51 U6.6 16.65,27.51 16.37,27.51 15,26.14 14.23,26.14 13.63,25.53 13.19,25.53 12.95,25.29 J2.5 ; U80.E10 108.92,48.46 109.1,48.28 v3(109.38,48.28)
USB3_RX_DP<1>: length 123.1
  IN1 w0.079: v1(29.59,59.27) 29.98,58.88 29.98,58.83 31.06,57.76 37.09,57.76 38.3,56.55 42.08,56.55 43.38,55.25 43.38,54.41 43.9,53.88 43.9,49.85 48.19,45.56 48.19,44.59 53.25,39.53 56.97,39.53 59.21,37.28 60.64,37.28 66.46,31.45 66.74,31.45 69.94,28.25 72.15,28.25 72.96,27.44 78.38,27.44 78.66,27.16 82.92,27.16 83.51,26.58 87.93,26.58 88.81,27.46 90.56,27.46 94.3,31.19 101.72,31.19 103.43,32.9 103.43,35.19 105.96,37.73 105.96,43.41 107.2,44.65 107.2,48.25 108.13,49.18 108.13,49.49 108.19,49.55 v3(108.46,49.55)
  BOTTOM w0.102: v3(108.46,49.55) 108.21,49.8 U80.G8 ; U96.16 22.58,59.55 22.39,59.37 22.39,59.27 22.95,58.71 23.8,58.71 24.42,59.32 27.92,59.32 28.61,58.64 29.83,58.64 30.04,58.85 30.04,59.39 29.94,59.49 29.82,59.49 v1(29.59,59.27)
USB3_RX_DP<2>: length 152.7
  IN2 w0.079: v1(224.27,13.55) 224.5,13.55 224.58,13.62 224.58,14 224.5,14.07 224.07,14.07 223.87,13.87 217.23,13.87 210.78,20.33 201.13,20.33 196.84,24.62 186.4,24.62 183.84,22.05 173.14,22.05 172.26,21.17 166.89,21.17 165.35,22.71 156.41,22.71 156.33,22.79 155.39,22.79 154.78,22.18 150.99,22.18 150.44,22.73 149.78,22.73 147.46,25.04 136.29,25.04 135.73,25.6 120.71,25.6 117.29,29.02 114.08,29.02 112.96,30.15 110.71,30.15 106.88,33.98 106.88,38.36 106.16,39.07 106.16,41.09 107.32,42.24 107.32,43.46 107.61,43.76 107.61,47.59 107.91,47.88 107.91,50.31 107.78,50.43 107.6,50.43 107.45,50.28 v3(107.45,50.15)
  BOTTOM w0.102: CN2.27 225.85,15.95 225.78,15.88 225.44,15.88 224.47,14.91 224.47,13.75 v1(224.27,13.55) ; v3(107.45,50.15) 107.14,50.45 U80.H6
USB3_RX_DP<3>: length 150.1
  IN2 w0.079: v1(225.2,19.43) 225.06,19.43 224.9,19.58 224.9,19.74 225.01,19.85 225.6,19.85 225.77,19.68 225.77,18.8 225.36,18.4 224.77,18.4 223.18,16.8 223.04,16.8 222.39,16.16 218.56,16.16 211.57,23.15 203.55,23.15 202.89,23.82 201.26,23.82 198.29,26.79 182.34,26.79 180.81,25.26 175.99,25.26 175.7,24.98 157.99,24.98 157.46,25.51 151.88,25.51 150.18,27.21 137.13,27.21 136.56,27.78 134.84,27.78 134.09,28.53 120.78,28.53 117.2,32.11 115.49,32.11 113.28,34.32 109.58,34.32 109.36,34.53 109.36,38.27 108.76,38.88 107.88,38.88 107.38,39.38 107.38,41.1 108.56,42.28 108.56,47.36 108.89,47.69 108.89,48.55 109.02,48.68 109.02,50.35 109.13,50.47 109.48,50.47 109.59,50.35 109.59,50.24 v3(109.48,50.13)
  BOTTOM w0.102: CN2.19 225.85,19.95 225.75,19.85 225.37,19.85 225.2,19.68 v1(225.2,19.43) ; U80.H10 109.15,50.45 v3(109.48,50.13)
USB3_RX_DP<4>: length 138
  IN1 w0.079: v1(54.86,37.94) 54.65,37.94 54.54,37.83 54.54,37.6 54.68,37.46 55.89,37.46 57.85,35.49 59.89,35.49 65.09,30.29 65.09,29.66 68.73,26.03 69.61,26.03 70.17,25.47 77.81,25.47 77.89,25.38 81.73,25.38 82.66,24.45 85.54,24.45 85.92,24.82 88.83,24.82 88.88,24.87 91.16,24.87 93.31,27.03 97.22,27.03 97.97,27.78 98.5,27.78 98.75,28.02 100.57,28.02 101.94,29.4 104.79,29.4 109.93,34.53 110.36,34.53 111.07,35.24 111.07,41.84 108.62,44.28 108.62,46.62 108.25,46.98 108.25,48 108.9,48.65 109.12,48.65 109.39,48.92 v3(109.41,48.92)
  BOTTOM w0.102: J2.6 12.95,25.94 13.14,25.75 13.54,25.75 14.14,26.35 14.91,26.35 16.28,27.72 17.37,27.72 17.42,27.77 18.45,27.77 U6.5 18.59,27.77 18.96,27.77 19.41,27.33 19.41,25.86 20.69,24.58 29.02,24.58 30.43,25.99 30.43,27.4 32.92,29.89 32.92,30.84 33.92,31.84 33.92,34.05 37.61,37.73 41.43,37.73 41.61,37.91 42.75,37.91 43.54,38.7 54.28,38.7 54.59,38.39 54.59,38.2 v1(54.86,37.94) ; U80.F10 109.16,48.92 v3(109.41,48.92)
USB3_TX_DN*<1>: length 123.5
  IN1 w0.079: v1(110.36,38.34) 110.08,38.61 109.01,38.61 108.83,38.79 107.92,38.79 107.08,37.95 107.08,35.61 102.02,30.55 99.43,30.55 98.44,29.57 93.58,29.57 90.83,26.81 89.08,26.81 88.2,25.93 83.06,25.93 82.48,26.51 78.39,26.51 78.15,26.75 72.69,26.75 71.86,27.58 69.66,27.58 66.54,30.71 66.26,30.71 60.33,36.63 58.95,36.63 57.1,38.48 55.95,38.48 55.55,38.88 52.98,38.88 47.48,44.38 47.48,45.36 43.25,49.59 43.25,53.52 42.72,54.05 42.72,55 41.81,55.9 35.75,55.9 34.71,56.95 30.93,56.95 28.87,59 28.87,61.14 28.67,61.34 28.57,61.34 v1(28.31,61.09)
  BOTTOM w0.076: U80.C13 110.48,46.92 110.48,46.82 110.56,46.74 110.81,46.74 110.88,46.67 110.93,46.52 110.93,46.33 110.89,46.24 110.89,45.99 110.91,45.93 110.91,45.52 110.46,45.07 110.46,44 109.76,43.3 109.76,43.03 109.73,43 109.73,42.98
  BOTTOM w0.102: U96.12 23.79,60.98 23.89,61.08 26.29,61.08 26.65,61.44 27.96,61.44 v1(28.31,61.09) ; v1(110.36,38.34) 110.1,38.59 109.96,38.59 109.73,38.82 109.73,42.98
USB3_TX_DN*<2>: length 146.9
  IN2 w0.079: v1(225.37,16.83) 225.16,17.04 225.04,17.04 224.89,16.9 224.89,16.55 224.78,16.44 224.78,15.7 223.6,14.52 217.51,14.52 211.06,20.97 206.08,20.97 205.45,21.6 200.91,21.6 197.21,25.3 185.79,25.3 184.24,23.75 176.57,23.75 175.61,22.79 172.94,22.79 172.07,21.92 167.33,21.92 165.78,23.47 155.08,23.47 154.45,22.84 152.46,22.84 149.6,25.7 136.54,25.7 135.98,26.27 120.95,26.27 117.55,29.67 114.35,29.67 113.22,30.8 110.98,30.8 110.04,31.73 110.04,32.54 107.53,35.06 107.53,36.97 107.87,37.3 108.1,37.3 v1(108.32,37.52)
  BOTTOM w0.076: U80.B13 110.37,46.16 110.07,46.16 109.82,45.91 109.82,43.99 109.06,43.23 109.06,42.69 109.03,42.66 109.03,42.65
  BOTTOM w0.102: v1(225.37,16.83) 225.61,17.08 225.8,17.08 225.93,16.95 CN2.25 ; v1(108.32,37.52) 108.32,37.42 108.49,37.25 108.72,37.25 109.03,37.56 109.03,42.65
USB3_TX_DN*<3>: length 136.2
  IN2 w0.079: v1(113.08,37.26) 113.13,37.31 113.13,37.47 113.04,37.56 112.73,37.56 112.45,37.28 112.45,36.42 112.76,36.11 114.12,36.11 120.91,29.32 134.32,29.32 135.2,28.44 136.81,28.44 137.38,27.87 150.45,27.87 152.12,26.2 157.68,26.2 158.24,25.64 174.74,25.64 175.25,26.14 180.73,26.14 182.02,27.44 198.56,27.44 201.26,24.73 203.07,24.73 203.96,23.84 211.8,23.84 213.19,22.44 216.45,22.44 218.38,24.37 222.52,24.37 225.09,21.81 225.41,21.81 225.49,21.9 225.49,22.06 v1(225.41,22.14)
  BOTTOM w0.076: U80.B15 112.13,46.3 112.36,46.3 112.55,46.11 112.55,44.23 113.81,42.96 113.81,42.74 113.83,42.73
  BOTTOM w0.102: v1(113.08,37.26) 113.27,37.44 113.51,37.44 113.83,37.76 113.83,42.73 ; CN2.15 225.85,21.95 225.76,21.86 225.69,21.86 v1(225.41,22.14)
USB3_TX_DN*<4>: length 123.2
  IN1 w0.079: v1(56.14,37.97) 56.35,37.76 56.35,37.66 58.04,35.97 60.09,35.97 65.57,30.49 65.57,29.93 68.57,26.92 71.55,26.92 72.41,26.07 77.92,26.07 78.12,25.86 82.01,25.86 82.97,24.91 85.27,24.91 85.65,25.28 88.46,25.28 88.88,25.7 90.67,25.7 92.46,27.49 95.47,27.49 96.5,28.52 98.46,28.52 99.84,29.9 102.29,29.9 102.9,30.51 104.67,30.51 106.09,31.93 106.09,33.05 109.66,36.63 109.96,36.63 v1(110.23,36.36)
  BOTTOM w0.076: 111.24,42.98 111.24,43 111.21,43.03 111.21,43.89 111.97,44.65 111.97,45.28 111.72,45.53 111.72,45.53 111.7,45.59 111.7,45.69 111.71,45.8 111.75,45.94 111.76,46.22 111.73,46.33 111.73,46.5 111.74,46.57 111.78,46.69 111.88,46.78 112.1,46.78 112.16,46.84 112.16,46.92 U80.C15
  BOTTOM w0.102: 111.24,42.98 111.24,37.02 110.85,36.63 110.49,36.63 v1(110.23,36.36) ; v1(56.14,37.97) 56.37,38.21 56.37,38.39 56.3,38.46 55.82,38.46 55.08,39.2 43.27,39.2 42.53,38.46 41.41,38.46 41.22,38.26 37.45,38.26 33.44,34.25 33.44,32.04 32.44,31.04 32.44,30.09 29.95,27.6 29.95,26.31 29.39,25.76 21.29,25.76 20.89,26.15 20.89,26.35 CCP4195.2
USB3_TX_DN*<4>_C: length 1.4
  BOTTOM w0.102: LCP4042.4 20.65,28.5 20.82,28.33 20.82,28 CCP4195.1
USB3_TX_DP<1>: length 123.5
  IN1 w0.079: v1(110.36,39) 110.15,38.79 109.09,38.79 108.91,38.97 107.84,38.97 106.89,38.02 106.89,35.69 101.94,30.73 99.35,30.73 98.37,29.75 93.51,29.75 90.75,27 89,27 88.12,26.12 83.14,26.12 82.55,26.7 78.46,26.7 78.22,26.94 72.76,26.94 71.93,27.77 69.74,27.77 66.62,30.89 66.34,30.89 60.41,36.82 59.02,36.82 57.18,38.67 56.02,38.67 55.62,39.07 53.06,39.07 47.67,44.46 47.67,45.43 43.43,49.67 43.43,53.59 42.9,54.13 42.9,55.07 41.89,56.09 35.83,56.09 34.79,57.13 31.01,57.13 29.06,59.08 29.06,61.21 28.75,61.53 28.61,61.53 v1(28.31,61.82)
  BOTTOM w0.076: U80.D13 110.79,47.52 110.86,47.41 110.94,47.14 110.94,47.02 110.95,47 110.99,46.85 111,46.82 111.08,46.54 111.08,46.3 111.04,46.21 111.04,46.02 111.07,45.95 111.07,45.46 110.61,45 110.61,43.93 109.91,43.23 109.91,43.03 109.94,43 109.94,42.98
  BOTTOM w0.102: v1(110.36,39) 110.16,38.8 110.04,38.8 109.94,38.91 109.94,42.98 ; U96.11 23.77,61.38 23.86,61.29 26.2,61.29 26.57,61.65 28.26,61.65 28.31,61.71 v1(28.31,61.82)
USB3_TX_DP<2>: length 146.9
  IN2 w0.079: v1(108.32,36.81) 108.4,36.89 108.4,37.04 108.32,37.12 107.94,37.12 107.71,36.89 107.71,35.14 110.23,32.62 110.23,31.81 111.06,30.98 113.3,30.98 114.43,29.85 117.63,29.85 121.03,26.46 136.05,26.46 136.62,25.89 149.67,25.89 152.54,23.03 154.37,23.03 155,23.66 165.85,23.66 167.4,22.11 171.99,22.11 172.86,22.98 175.53,22.98 176.49,23.93 184.16,23.93 185.71,25.48 197.28,25.48 200.98,21.78 205.53,21.78 206.15,21.16 211.13,21.16 217.59,14.7 223.53,14.7 224.6,15.77 224.6,16.52 224.71,16.63 224.71,16.97 224.96,17.23 225.34,17.23 225.44,17.33 225.44,17.49 v1(225.37,17.57)
  BOTTOM w0.076: 109.24,42.65 109.24,42.66 109.21,42.69 109.21,43.16 109.97,43.92 109.97,45.85 110.13,46.01 110.51,46.01 110.65,45.87 U80.A13
  BOTTOM w0.102: CN2.24 225.93,17.45 225.77,17.29 225.65,17.29 v1(225.37,17.57) ; v1(108.32,36.81) 108.55,37.04 108.81,37.04 109.24,37.48 109.24,42.65
USB3_TX_DP<3>: length 136.3
  IN2 w0.079: v1(225.41,21.41) 225.19,21.63 225.01,21.63 222.45,24.19 218.46,24.19 216.53,22.26 213.12,22.26 211.72,23.66 203.88,23.66 202.99,24.54 201.19,24.54 198.48,27.25 182.1,27.25 180.81,25.96 175.33,25.96 174.82,25.45 158.17,25.45 157.61,26.01 152.04,26.01 150.37,27.69 137.3,27.69 136.74,28.25 135.12,28.25 134.24,29.13 120.83,29.13 114.04,35.92 112.69,35.92 112.26,36.35 112.26,37.36 112.65,37.75 112.89,37.75 v1(113.1,37.96)
  BOTTOM w0.076: 113.64,42.69 113.66,42.72 113.66,42.9 112.39,44.16 112.39,46.05 112.3,46.14 111.97,46.14 111.91,46.09 111.91,45.87 U80.A15
  BOTTOM w0.102: CN2.16 225.97,21.45 225.77,21.65 225.65,21.65 v1(225.41,21.41) ; 113.64,42.69 113.61,42.67 113.61,37.84 113.42,37.65 113.19,37.65 113.1,37.74 v1(113.1,37.96)
USB3_TX_DP<4>: length 123.2
  IN1 w0.079: v1(110.23,37.1) 110.23,36.92 110.11,36.81 109.58,36.81 105.9,33.13 105.9,32 104.6,30.7 102.82,30.7 102.21,30.09 99.76,30.09 98.38,28.71 96.43,28.71 95.4,27.68 92.39,27.68 90.59,25.89 88.8,25.89 88.39,25.47 85.57,25.47 85.19,25.09 83.04,25.09 82.09,26.05 78.2,26.05 78,26.25 72.48,26.25 71.63,27.11 68.65,27.11 65.75,30.01 65.75,30.56 60.16,36.15 58.12,36.15 56.53,37.74 56.53,37.88 56.63,37.97 v1(56.87,37.97)
  BOTTOM w0.076: U80.D15 111.78,47.41 111.69,47.06 111.64,46.74 111.59,46.6 111.58,46.51 111.58,46.31 111.61,46.2 111.6,45.96 111.56,45.82 111.55,45.72 111.55,45.69 111.55,45.58 111.58,45.46 111.61,45.42 111.82,45.21 111.82,44.71 111.06,43.96 111.06,43.03 111.03,43 111.03,42.98
  BOTTOM w0.102: 111.03,42.98 111.03,37.11 110.76,36.84 110.49,36.84 v1(110.23,37.1) ; CCP4196.2 21.1,26.49 21.1,26.24 21.37,25.97 29.3,25.97 29.74,26.4 29.74,27.69 32.22,30.18 32.22,31.13 33.22,32.12 33.22,34.33 37.36,38.47 41.13,38.47 41.32,38.67 42.44,38.67 43.19,39.41 55.17,39.41 55.91,38.67 56.39,38.67 56.58,38.48 56.58,38.26 v1(56.87,37.97)
USB3_TX_DP<4>_C: length 1.4
  BOTTOM w0.102: LCP4042.1 21.2,28.52 21.03,28.35 21.03,28 CCP4196.1
USB_A0_ILIM_SEL: length 97.9
  TOP w0.102: v1(55.98,40.88) 55.51,41.36 49.48,41.36 48.29,40.17 40.6,40.17 40.19,40.57 36.06,40.57 31.86,36.38 30.44,36.38 29.18,35.11 R5099.2
  IN1 w0.079: v1(57.7,52.55) 57.7,52.25 59.12,50.83 61.88,50.83 63.55,49.15 65.44,49.15 66.28,48.3 68.91,48.3 69.69,47.52 74.59,47.52 74.76,47.7 76.27,47.7 77.06,48.49 80.09,48.49 80.46,48.12 80.82,48.12 80.99,48.29 81.09,48.29 82.59,49.79 83.14,49.79 83.82,50.48 87.5,50.48 88.4,49.58 89.11,49.58 90.24,50.71 90.24,52.18 91.15,53.1 92.1,53.1 92.93,53.93 93.59,53.93 94.07,54.41 95.88,54.41 96.23,54.06 103.07,54.06 v1(103.31,53.82)
  IN2 w0.079: v1(55.98,40.88) 55.81,41.06 55.81,45.74 55.1,46.45 55.1,47.71 56.42,49.03 56.42,51.27 v1(57.7,52.55)
  BOTTOM w0.076: v1(103.31,53.82) 103.53,53.6 104.34,53.6 104.67,53.27 U80.P3
USB_A0_PWR_EN: length 139.2
  TOP w0.102: EU1B2.5 204.36,13.83 203.47,12.94 RCP4221.1 202.84,12.22 v1(202.43,12.63)
  IN2 w0.079: v1(92.29,36.43) 93.61,35.11 94.77,35.11 96.29,33.58 96.29,32.1 97.14,31.25 97.32,31.25 101.81,26.76 108.58,26.76 109.15,26.19 116.09,26.19 119.4,22.88 123.75,22.88 124.22,22.41 145.71,22.41 146.68,21.44 146.78,21.44 147.52,20.7 147.52,20.32 149.17,18.68 155.16,18.68 155.5,19.02 167.16,19.02 167.48,19.34 169.16,19.34 169.82,18.68 172.35,18.68 173.91,20.23 181.52,20.23 184.06,17.69 188.39,17.69 189.3,18.6 198.85,18.6 199.35,19.1 200,19.1 200.3,18.8 200.58,18.8 200.98,18.4 200.98,17.67 v1(200.56,17.25)
  BOTTOM w0.102: v1(202.43,12.63) 200.4,12.63 200.04,12.99 200.04,16.73 v1(200.56,17.25) ; v1(92.29,36.43) 91.38,37.35 89.74,37.35 89.38,36.98 89.38,36.43 88.92,35.97 87.98,35.97 87.28,36.67 EUPM3247.B68
USB_A0_STATUS*: length 213.6
  TOP w0.102: CPM4192.2 30.79,30.1 30.83,30.14 v1(31.34,30.14) 31.34,31.53 31.46,31.66 ; v1(181.4,17.31) 182.81,17.31 186.65,13.46 191.46,13.46 194.07,10.86 197.15,10.86 197.28,10.73 v1(201.67,10.73) 206.56,10.73 207.08,11.25 207.08,13.89 207.03,13.94 207.03,14.46 207.4,14.83 207.4,15.01 207.21,15.2 EU1B2.9
  IN1 w0.079: v1(31.34,30.14) 31.83,30.14 35.2,33.51 42.31,33.51 47.74,28.08 48.06,28.08 48.65,28.67 51.54,28.67 51.91,28.3 51.91,27.95 52.49,27.37 52.49,25.31 52.93,24.88 53.66,24.88 63.92,14.62 74.31,14.62 74.95,15.26 78.26,15.26 78.71,14.81 85.72,14.81 86.22,14.3 90.98,14.3 91.48,14.81 93.11,14.81 97.17,10.75 98.87,10.75 100.57,9.05 109.74,9.05 110.34,9.66 111.52,9.66 112.13,9.05 113.92,9.05 114.29,9.43 114.29,15.18 116.65,17.53 120.19,17.53 121.69,19.03 141.52,19.03 141.85,18.7 144.7,18.7 144.99,19 154.47,19 155.68,20.2 160.32,20.2 161.85,21.73 163.92,21.73 164.89,20.76 179.95,20.76 181.4,19.31 v1(181.4,17.31)
  BOTTOM w0.102: EUCP4040.4 v1(31.34,30.14)
USB_A1_ILIM_SEL: length 102.6
  TOP w0.102: R5098.2 v1(34.17,37.04) 35.23,38.1 35.54,38.4 37.3,40.17 40.02,40.17 40.52,39.67 41.31,39.67 41.85,39.12 42.56,39.12 43.2,39.76 48.45,39.76 49.17,40.48 54.66,40.48 v1(54.93,40.75)
  IN1 w0.079: v1(55.35,52.29) 55.87,52.29 58.9,49.26 58.9,48.72 59.5,48.12 60.01,48.12 60.18,47.95 60.61,47.95 61,47.56 61,47.12 61.5,46.63 62.66,46.63 64.83,44.46 66.37,44.46 66.76,44.85 70.11,44.85 70.92,44.04 72.52,44.04 73.78,42.78 74.49,42.78 76.73,40.54 79.54,40.54 80.58,41.58 84.13,41.58 84.54,41.98 84.54,42.36 84.8,42.63 85.03,42.63 85.47,43.07 85.47,43.68 85.71,43.91 88.37,43.91 91.49,47.03 91.49,47.64 92.4,48.55 92.4,48.88 93.02,49.49 93.02,50.64 93.96,51.59 v1(94.84,51.59)
  IN2 w0.079: v1(54.93,40.75) 55.63,41.44 55.63,45.67 54.92,46.38 54.92,47.78 56.24,49.11 56.24,51.41 v1(55.35,52.29)
  BOTTOM w0.076: U80.P4 105.16,52.96 104.21,52.96 103.89,53.06 103.75,53.06 103.57,52.98 103.46,52.98 103.41,53.01 103.28,53.06 103.06,53.06 102.5,53.62
  BOTTOM w0.102: v1(94.84,51.59) 94.84,51.72 96.26,53.14 96.26,53.57 96.9,54.21 98.57,54.21 99.24,54.89 101.24,54.89 102.5,53.62
USB_A1_PWR_EN: length 96.6
  TOP w0.102: v1(29.18,28.1) 29.18,28.66 27.63,30.21 26.68,30.21 26.38,29.9 26.04,29.9 25.78,30.16 24.66,30.16 24.25,30.56 24.25,31.68 25.32,32.75 25.32,33.87 25.74,34.29 27.98,34.29 30.27,36.58 31.78,36.58 35.98,40.77 40.28,40.77 40.68,40.37 48.2,40.37 49.4,41.56 56.1,41.56 56.74,40.93 57.39,40.93 57.88,40.44 60.41,40.44 60.43,40.46 63.72,40.46 66.5,37.67 66.5,33.64 69.17,30.97 72.43,30.97 73.69,29.71 v1(81.2,29.71)
  IN2 w0.079: v1(82.39,38.01) 82.24,38.16 80.69,38.16 80.18,38.67 80.18,39.28 79.93,39.53 78.94,39.53 78.32,38.92 78.32,37.32 78.84,36.81 78.84,33.81 79.39,33.26 79.39,32.45 81.2,30.63 v1(81.2,29.71)
  BOTTOM w0.102: EUCP4040.5 29.51,28.75 29.18,28.42 v1(29.18,28.1) RCP4029.1 ; EUPM3247.B8 83.21,36.75 82.82,37.14 82.82,37.57 v1(82.39,38.01)
USB_A1_STATUS*: length 215.5
  TOP w0.102: v1(190.85,20.78) 192.3,20.78 194.2,22.69 198.21,22.69 198.41,22.49 198.41,17.27 v1(199.86,15.82) 199.86,15.48 200.97,14.38 R5103.2 ; v1(26.21,30.31) 25.95,30.31 QCP4007.3
  IN1 w0.079: v1(26.21,30.31) 26.26,30.36 26.26,32.16 28.82,34.73 32.2,34.73 33.24,33.69 44.31,33.69 47.01,31 47.01,30.74 48.9,28.85 51.61,28.85 52.09,28.37 52.09,28.02 52.67,27.44 52.67,25.39 53,25.06 53.74,25.06 63.81,14.98 74.41,14.98 74.88,15.45 78.33,15.45 78.79,14.99 85.9,14.99 86.4,14.49 90.82,14.49 91.33,14.99 93.19,14.99 97.1,11.08 106.57,11.08 107.79,9.86 111.6,9.86 112.23,9.23 113.84,9.23 114.11,9.51 114.11,15.26 116.59,17.74 120.14,17.74 121.63,19.24 140.48,19.24 141.04,19.79 141.04,20.45 141.6,21.01 145.18,21.01 145.91,20.28 154.2,20.28 155.24,21.32 159.89,21.32 161.4,22.83 164.42,22.83 165.32,21.93 183.81,21.93 184.96,20.78 v1(190.85,20.78)
  BOTTOM w0.102: EUCP4040.9 26.37,30.14 v1(26.21,30.31) 26.2,30.31 26.1,30.31 25.62,29.83 CPM4189.2
USB_C0_BC12_INT*: length 84.3
  TOP w0.102: U90.12 22.69,70.63 v1(22.95,70.9)
  IN1 w0.079: v1(65.03,52.28) 64.51,52.28 63.68,53.11 63.68,54.43 63.16,54.95 63.16,55.86 61.59,57.43 61.59,60.15 56.03,65.71 54.38,65.71 52.24,67.85 43.63,67.85 40.76,70.72 23.13,70.72 v1(22.95,70.9) ; v1(86.24,44.93) 84.65,46.52 84.65,47.95 84.29,48.32 83.96,48.32 83.46,47.81 83,47.81 82.49,47.3 82.49,46.82 82.06,46.38 78.23,46.38 78.11,46.26 74.56,46.26 74.04,46.78 69.38,46.78 68.6,47.56 65.51,47.56 64.76,48.3 v1(64.76,48.39)
  IN2 w0.079: v1(65.03,52.28) 64.73,51.98 64.73,48.43 v1(64.76,48.39)
  BOTTOM w0.102: v1(86.24,44.93) 86.21,44.96 EUPM3247.B50
USB_C0_CC1_CONN: length 2.2
  BOTTOM w0.203: v1(13.82,64.7) 13.74,64.79 U133.1
  BOTTOM w0.254: v1(8.81,65.26) 8.8,65.25 JCP4038.A5
  vias: v1(9.39,64.88) v1(15.92,57.71) v1(16.16,58.29)
USB_C0_CC1_DEVICE_ODL: length 25.6
  TOP w0.102: R5039.1 19.66,54.19 19.93,54.47 20.59,54.47 v1(20.92,54.14) ; v1(34.46,45.06) 34,44.6 R981.1 R980.2 35.02,44.64 34.89,44.77 U95.32
  BOTTOM w0.102: v1(20.92,54.14) 21.35,53.7 21.84,53.7 22.04,53.91 23.67,53.91 26.05,51.52 27.73,51.52 29.23,50.03 29.23,47.98 28.97,47.72 28.97,46.79 30.81,44.96 34.36,44.96 v1(34.46,45.06)
USB_C0_CC1_MCU: length 4.2
  TOP w0.102: C887.2 28.86,54.19 28.8,54.14 R982.2 v1(29.88,53.75) 30.95,53.75 31.39,53.32 U95.12
USB_C0_CC1_TX_DATA: length 30.1
  TOP w0.102: v1(38.43,47.84) 37.94,48.34 U95.40
  BOTTOM w0.102: v1(38.43,47.84) 38.85,47.42 38.85,47 37.32,45.46 31.03,45.46 29.33,47.17 29.33,47.57 29.59,47.83 29.59,50.17 27.88,51.88 26.2,51.88 23.51,54.57 19.65,54.57 v1(19.32,54.24) 18.99,53.91 R983.2
USB_C0_CC1_VCONN_EN: length 18.6
  TOP w0.102: U97.3 19.13,58.77 v1(19.35,58.55) ; v1(27.5,49.56) 27.91,49.97 28.9,49.97 29.02,49.85 R3614.1 29.59,49.56 29.81,49.34 U95.19
  IN1 w0.079: v1(27.5,49.56) 27.94,49.99 27.94,50.98 25.8,53.11 23.65,53.11 19.81,56.94 19.81,58.09 v1(19.35,58.55)
USB_C0_CC2_CONN: length 27
  IN1 w0.152: 6.95,67.95 6.95,67.43 6.4,66.88 5.33,66.88 JCP4038.B5
  IN1 w0.508: v1(13.81,65.67) 14.52,64.96 14.52,64.45 14.11,64.04 v1(13.76,64.04) 15.61,62.19 15.61,60.64 16.8,59.45 16.8,57.56 16.29,57.06 v1(14.65,57.06)
  IN2 w0.152: 6.77,67.58 6.68,67.49 6.68,67.13 6.44,66.88 5.33,66.88 JCP4038.B5
  IN2 w0.305: v1(9.19,68.31) 7.5,68.31 6.77,67.58
  BOTTOM w0.203: v1(13.76,64.04) 13.49,64.31 U133.2
  BOTTOM w0.508: v1(13.81,65.67) 13.81,67.01 12.51,68.31 v1(10.85,68.31) v1(9.19,68.31)
USB_C0_CC2_DEVICE_ODL: length 36.4
  TOP w0.102: R986.1 26.8,51.16 26.21,51.16 R985.2 26.15,50.81 26.59,50.81 v1(26.74,50.66) ; U95.33 v1(35.39,45.06) ; v1(12.41,54.08) 12.3,53.97 12.3,53.26 13.33,52.24 R5043.1
  IN1 w0.079: v1(26.74,50.66) 25.16,52.23 17.96,52.23 16.27,53.93 14.77,53.93 14.55,53.71 12.79,53.71 v1(12.41,54.08)
  BOTTOM w0.102: v1(35.39,45.06) 34.84,44.51 v1(32.8,44.51) 30.76,44.51 30.16,45.11 29.47,45.11 28.62,45.96 28.62,47.87 28.88,48.12 28.88,49.88 27.59,51.17 26.97,51.17 26.74,50.93 v1(26.74,50.66)
USB_C0_CC2_MCU: length 3.2
  TOP w0.102: U95.14 30.03,51.84 29.86,52 v1(29.63,52) 29.35,51.72 C888.2 R987.2
USB_C0_CC2_TX_DATA: length 2.1
  TOP w0.102: R988.2 29.53,50.58 v1(29.66,50.71) 29.79,50.84 U95.16
USB_C0_CC2_VCONN_EN: length 18.1
  TOP w0.102: v1(27.63,48.22) 27.68,48.27 28.77,48.27 29.02,48.52 R3611.1 29.35,48.67 29.52,48.84 U95.20 ; v1(19.32,56.57) 19.03,56.29 U98.3
  IN1 w0.079: v1(19.32,56.57) 19.92,56.57 23.57,52.93 25.73,52.93 27.76,50.9 27.76,50.37 27.11,49.73 27.11,49.4 27.63,48.88 v1(27.63,48.22)
USB_C0_HOST_HIGH: length 42.3
  TOP w0.102: U95.13 30.09,52.34 29.25,53.17 27.71,53.17 27.1,52.56 26.66,52.56 26,51.9 R985.1 25.6,51.33 25.6,50.7 25.9,50.4 26.41,50.4 26.74,50.07 v1(26.89,50.07) ; v1(14.29,49.68) R5042.2 14.13,49.23 17.2,49.23 R5038.2 ; R980.1 v1(35.02,42.79)
  IN1 w0.079: v1(14.29,49.68) 14.85,50.24 15.68,50.24 17.34,51.9 24.94,51.9 26.77,50.07 v1(26.89,50.07)
  BOTTOM w0.102: v1(35.02,42.79) 34.61,43.19 31.57,43.19 v1(30.79,43.97) 30.01,44.75 29.32,44.75 28.26,45.81 28.26,48.01 28.52,48.27 28.52,49.73 28.28,49.97 26.98,49.97 v1(26.89,50.07)
USB_C0_TX_CLKIN: length 6.2
  TOP w0.102: v1(38.44,47.18) 37.78,47.84 U95.39 ; R977.2 38.27,50.71 v1(38.19,50.63)
  IN2 w0.079: v1(38.19,50.63) 38.19,49.56 38.83,48.93 38.83,47.58 v1(38.44,47.18)
USB_C0_TX_CLKOUT: length 3.9
  TOP w0.102: U95.45 37.82,50.84 38.09,51.11 39.95,51.11 40.11,50.95 R977.1 v1(40.11,49.84)
USB_C0_VBUS_WAKE*: length 89.3
  TOP w0.102: v1(47.03,63.61) 46.25,64.4 46.25,65.59 45.89,65.95 44.59,65.95 41.94,63.3 40.03,63.3 39.01,62.28 39.01,61.83 38.78,61.6 38.47,61.6 v1(37.94,61.07) 37.41,60.54 35.65,60.54 35.15,60.03 35.15,58.38 34.99,58.22 ; 34.99,58.22 35.4,57.82 35.4,56.93 35.17,56.7 R1163.2 34.89,56.23 35.43,55.7 35.43,54.72 35.83,54.31 35.83,53.55 35.89,53.5 U95.3 ; 34.99,58.22 33.04,58.22 32.76,58.5 32.76,59.4 32.53,59.63 32.01,59.63 PR8.1 31.3,60.33 29.41,60.33 29.18,60.1 PQ129.3
  IN1 w0.079: v1(86.5,42.68) 86.11,43.07 85.73,43.07 85.4,42.74 85.4,40.85 85.16,40.61 80.25,40.61 79.99,40.36 76.66,40.36 74.46,42.55 72.38,42.55 71.29,43.64 71.06,43.64 70.03,44.67 66.84,44.67 66.45,44.28 64.76,44.28 62.59,46.45 59.58,46.45 58.72,47.31 58.72,49.19 56.01,51.89 55.2,51.89 54.38,52.71 54.38,53.65 51.38,56.65 50.12,56.65 49.33,57.44 49.19,57.44 48.42,58.21 48.42,62.3 47.67,63.04 47.6,63.04 v1(47.03,63.61)
  BOTTOM w0.102: EUPM3247.B56 86.92,43.04 86.56,42.68 v1(86.5,42.68)
USB_C1_TX_CLK: length 2.6
  TOP w0.102: U95.26 31.89,45.58 v1(32.25,45.22) 32.56,45.22 32.89,45.55 U95.28
USB_C_REF: length 4.8
  TOP w0.305: U95.11 31.89,53.85 31.73,54.01
  TOP w0.508: R999.1 31.2,56.95 31.22,56.93 C946.1 R1000.2 31.22,54.52 v1(31.47,54.26) 31.73,54.01
USB_MCU_EC_INT*: length 64.6
  TOP w0.102: U95.37 37.87,46.84 38.93,45.78 v1(38.93,45.44) 38.93,45.09 41.01,43.01 50.02,43.01 50.04,42.98 56.69,42.98 56.82,42.85 60.48,42.85 61.75,41.58 64.18,41.58 67.62,38.14 67.62,36.45 70.69,33.38 72.1,33.38 73.13,32.36 73.13,32.14 74.1,31.17 81.76,31.17 83.34,29.59 v1(83.96,29.59)
  BOTTOM w0.102: v1(83.96,29.59) 84.59,29.59 84.85,29.85 84.85,31.54 85.14,31.83 87.17,31.83 87.47,32.13 87.47,32.68 RPM3123.2 86.96,33.61 87.09,33.74 87.09,34.53 86.46,35.15 EUPM3247.A1
