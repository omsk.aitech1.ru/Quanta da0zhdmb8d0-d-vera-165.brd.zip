# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCPGPPC: length 24.2
  IN2 w0.508: 109.77,55.81 105.81,55.81 104.43,54.43 102.78,54.43 102.17,55.04 98.76,55.04 98.42,54.69 98.09,54.69 97.86,54.46 94.14,54.46 93.77,54.08 91.87,54.08 v1(91.48,54.47)
  BOTTOM w0.254: U80.Y16 112.56,56.51 v3(112.56,56.67)
  BOTTOM w0.508: v1(91.48,54.47) 91.57,54.47 CAP1287.1 91.71,53.75 90.87,53.75 v1(90.62,54.01) 90.57,53.96 90.19,53.96 89.4,54.75 RPM3328.1
+VCCPGPPD: length 78.6
  TOP w0.381: v3(111.33,56.67) 111.33,56.67 111.03,56.37 111.03,56.21 110.64,55.83 105.69,55.83 105.39,55.53 102.38,55.53 101.91,55.06 98.81,55.06 98.37,55.51 98.37,55.99 97.75,56.61 96.78,56.61 96.71,56.54 96.17,56.54 95.55,55.92 v1(94.78,55.92) 94.26,55.92 93.96,55.62 92.4,55.62 92.07,55.29 91.68,55.29 91.4,55.01 90.45,55.01 v1(90.24,54.81)
  TOP w0.508: v1(56.56,61.48) 56.38,61.48 54.97,60.07 54.16,60.07 53.71,59.63 53.71,54.68 54.64,53.76 54.64,49.62 53.31,48.29 PR88.1
  BOTTOM w0.254: v3(111.33,56.67) 111.33,56.56 U80.Y15
  BOTTOM w0.508: v1(56.56,61.48) 60.82,61.48 61.25,61.91 71.03,61.91 71.67,61.28 76.16,61.28 76.52,60.92 77.6,60.92 77.99,60.53 78.48,60.53 79.08,59.93 81.24,59.93 83.91,57.27 86.07,57.27 86.33,57.52 RPM3324.1 87.31,57.72 88.2,57.72 88.74,57.18 89.25,57.18 89.63,56.8 89.63,56.08 RPM3323.2 90.24,55.11 v1(90.24,54.81)
+VCCPGPPE: length 27.1
  IN2 w0.254: v3(112.6,54.18) 112.6,55 112.12,55.48 111.18,55.48 110.91,55.21 110.91,55.11 110.53,54.73 109.59,54.73 109.56,54.7 106.15,54.7
  IN2 w0.508: v1(95.69,53.53) 95.7,53.53 96.02,53.85 98.11,53.85 98.34,54.08 98.67,54.08 99.01,54.43 101.84,54.43 103.2,53.07 104.77,53.07 105.68,53.98 105.68,54.24 106.15,54.7
  BOTTOM w0.254: v3(112.6,54.18) 112.29,54.49 U80.T16
  BOTTOM w0.508: v1(95.69,53.53) 95.03,54.19 94.89,54.19 94.4,54.68 94.4,56.24 v1(94.16,56.49) 93.91,56.74 93.91,57.59 CAP1296.1 93.49,58.25 93.3,58.45 RPM3329.1
+VCCPGPPF: length 78.1
  TOP w0.508: v1(55.57,62.52) 55.57,62.39 54.46,61.29 53.65,61.29 52.49,60.13 52.49,54.17 53.42,53.25 53.42,50.58 53.16,50.33 PR89.1
  IN2 w0.508: v1(93.62,56.17) 95.46,56.17 96.05,56.76 96.54,56.76 97.23,57.44 101.15,57.44 101.47,57.13 101.47,56.8 101.83,56.43 103.13,56.43 104.81,58.11 105.19,58.11 105.94,58.86
  BOTTOM w0.254: v3(111.96,58.34) U80.AF16
  BOTTOM w0.508: v1(55.57,62.52) 55.9,62.85 60.46,62.85 60.75,63.13 78.2,63.13 78.51,62.82 79.47,62.82 80.44,61.86 82.19,61.86 83.02,61.02 83.02,60.46 83.56,59.93 86.3,59.93 90.09,63.71 90.59,63.71 91.13,63.18 91.13,61.27 91.01,61.15 91.01,59.77 91.8,58.98 91.8,58.67 92.19,58.28 92.47,58.28 92.95,57.8 RPM3331.1 92.95,57.24 93.3,56.89 93.3,56.49 v1(93.62,56.17) 93.78,56.01 C2.2
+VCCPGPPG: length 19.9
  IN2 w0.508: v1(91.84,55.84) 93.01,55.84 93.6,55.25 97.53,55.25 97.76,55.48 98.09,55.48 98.43,55.83 103.38,55.83 104.87,57.31 105.46,57.31 106.14,57.98
  BOTTOM w0.254: U80.AD15 111.37,58.26 v3(111.31,58.34) ; v1(91.69,55.15) 91.84,55.3 v1(91.84,55.84)
  BOTTOM w0.508: v1(91.84,55.84) 91.76,55.84 91.43,56.17 91.41,56.17 90.77,56.8 C1C7.1 90.58,57.03 89.92,57.7 RPM3333.1
+VCCPRIM_1P0: length 1.6
  BOTTOM w0.254: v3(113.97,57.51) 113.97,57.36 U80.AB19 ; v3(113.27,54.14) 113.59,53.73 U80.P18 ; U80.AB20 v3(114.57,57.51)
  vias: v1(94.52,59.97)
+VCCPRIM_3P3: length 31.7
  TOP w0.254: RPM3315.1 99.86,85.11 101.3,83.67 101.64,83.67 102.57,82.74 102.57,82.49 103.66,81.41 107.95,81.41 110.16,79.2 111.56,79.2 114.01,76.75 114.01,73.7 v1(114.22,73.49) 114.22,72.68 115,71.89 115,71.68 CAP1275.1
  BOTTOM w0.254: U80.AJ21 115.87,60.11 v3(115.87,60.02) 115.87,59.8 116.33,59.34 116.33,57.13 116.34,57.12 116.34,56.46 115.7,55.83 114.66,55.83 U80.V19
+VCCPRIM_CORE: length 1.1
  BOTTOM w0.254: v3(113.92,59.18) 113.92,59.09 U80.AF18 ; v3(114.57,59.18) 114.57,59.09 U80.AF19
  vias: v1(94.04,52.83) v1(94.3,53.42) v1(94.65,52.83) v1(94.91,53.4) v1(95.28,52.83) v3(115.91,54.96) v3(116.06,55.52) v3(116.47,54.96)
+VCCPRTC_3P3: length 2.1
  BOTTOM w0.178: U80.BB14 111.5,69.33 v3(111.55,69.38)
  BOTTOM w0.254: v3(114.87,61.82) U80.AK19
+VCCPRTCPRIM_3P3: length 1.1
  BOTTOM w0.254: v3(112.09,61.8) 112.22,61.67 112.47,61.67 112.87,61.28 U80.AK17
+VCCPSPI: length 26.7
  TOP w0.254: RPM3314.1 97.23,73.29 96.83,72.89 96.42,72.89 95.98,72.45 v1(95.98,72.04)
  IN2 w0.254: v1(95.98,72.04) 95.98,72.27 96.31,72.6 97.2,72.6 97.34,72.46 99.1,72.46 100.38,71.17 101.34,71.17 101.87,71.71 102.63,71.71 102.98,71.36 104.39,71.36 107.29,68.46 107.45,68.46 109.84,66.07 109.84,62.22 111.2,60.86 v3(111.91,60.86)
  BOTTOM w0.305: v3(111.91,60.86) 111.91,60.83 U80.AJ16
+VCCSA: length 117.9
  TOP w0.203: PR33.2 198.4,31.68 v1(198.25,31.83)
  IN2 w0.152: v1(198.25,31.83) 194.34,31.83 193.87,32.3 181.54,32.3 180.39,31.15 169.77,31.15 166.84,28.23 160.03,28.23 159.47,28.79 153.53,28.79 152.16,30.16 152.16,30.72 v1(151.92,30.96) ; v1(145.59,30.84) 146.02,30.41 151.35,30.41 153.23,28.53 159.36,28.53 159.91,27.97 167.25,27.97 170.17,30.89 183.48,30.89 183.93,31.34 193.28,31.34 v1(193.81,30.81)
  BOTTOM w0.127: 119.89,50.45 U80.K28 ; U80.K28 119.62,50.73 ; U80.K28 119.89,51.01 ; U80.G27 118.63,49.8 ; U80.G27 118.98,50.21 ; U80.G27 118.98,49.49 ; 117.61,49.99 U80.J23 ; U80.J23 117.33,50.27 ; U80.J23 117.89,50.27 ; U80.J23 117.61,50.55 ; 117.43,49.98 U80.G23 ; U80.J27 119.44,50.55 ; U80.J27 119.72,50.27 ; U80.J27 119.44,49.99 ; U80.J27 119.16,50.27 ; U80.G25 118.35,49.8 ; U80.G25 118.07,50.08 ; U80.G25 118.07,49.53 ; U80.G25 117.79,49.8 ; U80.K27 119.26,50.73 ; U80.K27 118.98,51.01 ; U80.K27 118.98,50.45 ; 116.78,49.96 116.71,50.22 U80.J22 117.05,50.27 ; 117.15,51.01 U80.K23 ; U80.K23 117.47,50.73 ; U80.K23 117.15,50.42 ; U80.K23 117.15,50.45 ; 118.07,50.45 U80.K25 ; U80.K25 117.79,50.73 ; U80.K25 118.07,51.01 ; 117.15,50.08 U80.G23 ; U80.G23 v3(117.61,49.55) ; 119.89,50.08 U80.G28 ; U80.G28 v3(119.44,49.55) ; U80.G28 119.62,49.8
  BOTTOM w0.203: U80.K30 120.81,51.1 ; U80.AK23 117.15,60.24 v3(117.23,60.16) ; v3(118.07,60.16) U80.AK25
  BOTTOM w0.254: PL7.2 v1(151.92,30.96) ; U80.AK25 118.38,61.1
  vias: v1(116.76,37.91) v1(116.78,37.12) v3(117.68,51.62) v3(117.66,51.04) v3(118.54,54.89) v3(118.53,54.19) v3(118.54,51.69) v3(118.52,49.55) v3(119.14,57.92) v3(119.33,51.64) v3(119.4,51.06) v3(119.94,55.57) v3(120.32,58.09) v5(116.22,37.52) v5(116.22,36.76) v5(116.22,36.02) v5(116.32,35.21) v5(116.84,36.41) v5(116.86,35.68)
+VCCSFR_OC: length 47.3
  TOP w0.254: v1(101.38,84.49) 102.93,82.94 102.93,82.64 103.8,81.77 108.1,81.77 110.28,79.59 113.4,79.59 113.98,80.16 114.53,80.16 116.15,78.54 v1(116.15,77.36) 116.15,70.09 115.73,69.67 115.73,68.96 116.29,68.4 116.29,67.73 117.15,66.87 117.15,62.2 117.29,62.06 CAP1250.2 117.29,61.45 v3(116.69,60.85)
  IN1 w0.254: v1(101.38,84.49) 101.01,84.86 101.01,86.16 v1(102.84,87.99)
  BOTTOM w0.203: U80.AL23 v3(116.69,60.85) ; PR32.2 v1(102.84,87.99)
  BOTTOM w0.305: CAP14493.2 101.53,84.34 v1(101.38,84.49) 100.95,84.92 99.39,84.92 99.38,84.93 99.11,84.93 98,86.05 JP5100.2
+VCCSRAM_1P0: length 9.4
  TOP w0.889: RPM3289.1 96.66,54.62 v1(97.15,54.14) 97.49,53.79 97.73,53.79 97.77,53.75 102.11,53.75
  BOTTOM w0.254: U80.AF21 115.55,58.67 v3(115.22,58.34) 114.9,58.67 U80.AF20 ; U80.T20 114.9,54.69 v3(114.57,55.02) 114.4,54.84 114.4,54.73 U80.T19 113.92,54.9 v3(113.92,55.05)
+VDDQ_MEM: length 117.2
  TOP w0.254: v1(79.8,93.86) 78.59,95.07 PR26.2
  BOTTOM w0.076: v3(169.68,68.87) 169.82,69.01 169.82,70.04 USM2000.L12
  BOTTOM w0.102: v3(173.25,67.49) 173.25,68.02 172.62,68.65 172.62,68.89 172.48,69.02 USM2000.R12 ; v3(168.6,68.65) 168.76,68.82 168.76,69.14 169.23,69.61 USM2000.K12 ; v3(171.18,68.43) 171.23,68.47 171.23,70.06 USM2000.N12
  BOTTOM w0.127: 110.07,89.41 v3(110.07,89.42) ; v3(109.42,89.42) 109.74,89.1 USM2003.G5 ; 110.07,88.61 v3(110.07,88.62) ; USM2000.G2 167.28,78.12 v3(166.96,78.44) 166.63,78.11 USM2000.F2 ; USM2002.F2 127.82,91.49 v3(128.15,91.82) 128.47,91.5 USM2002.G2
  BOTTOM w0.152: USM2000.H3 167.87,77.31 167.28,77.9 USM2000.G2 ; USM2002.H3 129.07,90.69 128.47,91.29 USM2002.G2
  BOTTOM w0.178: USM2000.U8 173.59,73.31 173.22,72.94 173.03,72.94 172.81,72.72 172.81,72.15 v1(172.85,72.12) 173.2,72.12 173.59,72.51 USM2000.U9
  BOTTOM w0.203: v3(167.61,72.17) 167.93,72.5 USM2000.H9 ; v3(168.9,76.04) 168.9,76.03 USM2000.J5 ; v3(170.67,78.57) 170.67,78.24 USM2000.M2 USM2000.L2 ; v3(123.94,86.76) 124.01,86.69 USM2002.A8 ; v3(174.09,70.55) 174.09,70.6 USM2000.U11 ; USM2000.C12 164.36,69.79 v3(164.36,69.77) ; USM2000.H11 167.93,70.9 v3(167.61,70.57) ; v3(166.96,76.04) 166.96,76.03 USM2000.G5 ; v3(172.15,76.84) 172.15,76.83 USM2000.P4 ; USM2000.G12 167.28,70.1 v3(167.61,69.77) 167.93,70.1 USM2000.H12 ; v3(168.25,71.37) 168.25,71.38 USM2000.J10 ; v3(165.01,76.84) 165.01,76.83 USM2000.D4 ; USM2000.H8 167.93,73.27 v3(168.24,72.96) ; v3(162.86,72.51) USM2000.A9 ; v3(172.15,75.24) 172.15,75.23 USM2000.P6 ; USM2001.H3 151.68,88.69 USM2001.G2 150.71,89.66 v3(150.71,89.68) ; USM2000.J9 168.58,72.5 v3(168.25,72.17) ; USM2000.N8 v3(170.85,73.64) ; v3(109.42,91.82) 109.42,91.81 USM2003.G2 110.39,90.84 USM2003.H3 ; USM2000.K5 169.23,75.72 v3(169.55,76.04) ; v3(150.11,84.16) 150.11,84.17 USM2001.E8 ; USM2000.L5 169.88,75.72 v3(170.2,76.04) ; v3(172.15,76.04) 171.83,75.72 USM2000.P5 ; USM2000.H5 167.93,75.72 v3(167.61,76.04) ; USM2000.K6 169.23,75.02 v3(169.55,75.34) ; v3(162.93,70.82) 163.01,70.91 USM2000.A11 ; USM2000.H6 167.93,74.92 v3(167.61,75.24) ; USM2000.E12 165.98,69.84 165.85,69.71 v3(165.85,69.55) ; v3(162.85,73.24) 162.93,73.31 USM2000.A8 ; v3(165.01,75.24) 165.01,75.23 USM2000.D6 ; v3(165.01,76.04) 165.01,76.03 USM2000.D5 ; v3(168.9,75.34) 168.58,75.02 USM2000.J6 ; USM2000.K11 USM2000.K12
  BOTTOM w0.254: USM2001.D4 148.76,88.06 v3(148.76,88.08) ; v3(107.47,90.22) 107.47,90.21 USM2003.D4 ; v3(135.24,83.91) 135.18,83.97 135.18,84.08 USM2002.U11 ; v3(132.02,83.13) 132.37,83.48 USM2002.N12 ; v3(153.23,81.74) 153.22,81.74 153.22,81.9 USM2001.K11 ; v3(153.3,87.28) 153.3,87.26 USM2001.K5 ; v3(155.25,84.21) 155.25,84.22 USM2001.N8 ; USM2001.P5 155.9,87.26 v3(155.9,87.28) ; USM2001.H5 151.36,87.26 v3(151.36,87.28) ; USM2001.U9 158.1,83.74 158.48,84.13 v3(158.48,84.24) ; USM2002.H8 v3(129.45,86.36) 129.77,86.04 USM2002.J9 ; v3(108.73,82.76) 108.44,83.05 USM2003.E12 ; USM2001.L2 153.95,89.66 v3(153.95,89.68) ; USM2002.N8 v3(132.37,87.23) ; USM2002.R12 133.49,83.31 133.49,83.25 v3(133.3,83.06) ; v3(153.3,84.21) 153.3,84.22 USM2001.K8 ; USM2001.H11 152.02,82.48 v3(152.02,82.59) ; v3(125.75,82.05) 125.75,82.15 125.87,82.27 USM2002.C12 ; USM2001.D5 148.76,87.26 v3(148.76,87.28) ; v3(148.76,86.48) 148.76,86.46 USM2001.D6 ; v3(111.81,82.77) 111.81,83.36 USM2003.K12 ; v3(107.47,89.42) 107.47,89.41 USM2003.D5 ; USM2001.M2 154.59,89.65 v3(154.59,89.7) ; v3(151.36,83.41) 151.36,83.42 USM2001.H9 ; USM2002.U8 135.32,86.69 v3(135.45,86.82) ; v3(111.36,88.62) 111.36,88.61 USM2003.J6 ; USM2002.L2 131.07,92.59 v3(131.27,92.79) 131.27,92.54 131.72,92.09 USM2002.M2 ; USM2001.L5 153.95,87.26 v3(153.95,87.28) ; USM2002.K12 130.42,83.48 v3(130.74,83.16) USM2002.L12 ; USM2003.P5 114.61,89.41 v3(114.61,89.42) ; USM2001.E12 149.74,81.33 149.74,80.47 149.73,80.46 v3(150.06,80.13) ; USM2003.L12 112.34,82.83 v3(112.39,82.77) ; v3(113.78,83.01) 113.64,83.16 USM2003.N12 ; v3(152.65,82.61) 152.65,82.62 USM2001.J10 ; v3(158.17,81.8) 157.99,81.97 157.7,81.97 USM2001.U11 ; v3(108.03,86.29) 108.05,86.29 USM2003.E8 ; v3(126.2,89.42) 126.2,89.41 USM2002.D5 ; v3(116.72,85.94) 116.69,85.91 116.26,85.91 USM2003.U9 ; v3(152.65,83.41) 152.65,83.42 USM2001.J9 ; USM2003.A11 105.57,84.02 v3(105.23,84.02) ; USM2003.P4 114.29,89.9 v3(114.61,90.22) ; USM2002.K6 130.42,88.36 130.76,88.71 v3(130.76,88.72) ; USM2003.L5 112.66,89.41 v3(112.66,89.42) ; v3(130.09,89.42) 130.09,89.41 USM2002.J5 ; USM2002.H12 v3(129.45,83.16) ; USM2003.G12 109.77,83.46 110.36,83.46 USM2003.H12 110.73,83.14 v3(110.73,83.09) ; USM2002.H5 128.8,89.41 v3(128.8,89.42) ; v3(107.2,82.8) 107.14,82.87 USM2003.C12 ; USM2003.H9 v3(110.72,85.55) 111.04,85.24 USM2003.J10 ; USM2003.J5 111.36,89.41 v3(111.36,89.42) ; USM2003.P6 114.61,88.61 v3(114.61,88.62) ; USM2002.J6 129.77,88.36 130.11,88.71 v3(130.11,88.72) ; USM2003.K8 111.69,86.67 v3(112.01,86.35) ; v3(128.15,89.42) 128.15,89.41 USM2002.G5 ; v3(112.01,88.62) 112.01,88.61 USM2003.K6 ; USM2001.A11 146.81,81.82 v3(146.81,81.81) ; USM2003.H5 110.07,89.41 ; v3(168.9,73.79) 168.9,73.64 USM2000.K8 ; v3(128.8,83.16) 128.79,83.16 128.47,83.48 USM2002.G12 ; v3(165.78,72.9) 165.98,73.11 USM2000.E8 ; v3(152.65,86.48) 152.65,86.62 USM2001.J5 ; v3(105.12,87.02) 105.51,87.02 USM2003.A8 ; USM2002.D4 126.2,90.21 v3(126.2,90.22) ; v3(108.77,91.82) 108.77,91.81 USM2003.F2 ; USM2001.K12 152.98,81.34 v3(153.31,81.02) 153.63,81.34 USM2001.L12 ; v3(151.36,86.48) 151.36,86.46 USM2001.H6 ; v3(133.34,88.62) 133.34,88.61 USM2002.P6 ; v3(130.74,83.96) 130.42,84.28 USM2002.K11 ; USM2001.J6 152.33,85.91 152.59,85.65 v3(152.59,85.66) ; USM2003.K5 112.01,89.41 v3(112.01,89.42) ; v3(116.72,84.24) 116.67,84.29 USM2003.U11 ; USM2003.H8 v3(110.72,86.35) 111.04,86.04 USM2003.J9 ; v3(148.02,80.94) 148.03,80.94 USM2001.C12 ; USM2001.P6 155.9,86.46 v3(155.9,86.48) ; v3(130.74,89.42) 130.74,89.41 USM2002.K5 ; v3(123.93,84.04) 124.18,84.29 USM2002.A11 ; USM2003.N8 113.64,86.67 v3(114.02,86.29) ; v3(150.16,89.75) 150.16,89.57 USM2001.F2 ; v3(123.45,85.68) 123.65,85.89 USM2002.A9 ; USM2003.H6 110.07,88.61 ; USM2001.K6 153.3,86.46 v3(153.3,86.48) ; USM2002.J10 129.77,85.24 v3(129.45,85.56) USM2002.H9 ; v3(127.43,83.05) 127.44,83.06 127.44,83.2 127.17,83.48 USM2002.E12 ; USM2001.R12 156.23,80.2 v3(156.17,80.14) ; v3(150.71,87.28) 150.71,87.26 USM2001.G5 ; v3(133.34,90.22) 133.34,90.21 USM2002.P4 ; USM2002.L5 131.39,89.41 v3(131.39,89.42) ; USM2002.K8 130.42,86.68 v3(130.74,86.36) ; USM2001.A9 146.81,83.42 v3(146.81,83.41) ; USM2002.U9 135.42,85.89 v3(135.46,85.92) ; v3(133.34,89.42) 133.34,89.41 USM2002.P5 ; USM2001.A8 146.81,84.22 v3(146.81,84.21) ; v3(154.96,80.17) 154.93,80.2 USM2001.N12 ; USM2001.P4 155.9,88.06 v3(155.9,88.08) ; v3(157.86,84.21) USM2001.U8 ; USM2003.L2 112.54,91.69 112.54,92.16 v1(112.43,92.27) ; v3(114.94,83.02) USM2003.R12 ; USM2002.E8 v3(127.5,86.36) ; v3(113.31,91.82) 112.99,91.5 USM2003.M2 ; v3(110.74,83.93) USM2003.H11 ; USM2003.D6 107.47,88.61 v3(107.47,88.62) ; v3(105.08,85.89) USM2003.A9 ; v3(117.78,86.69) USM2003.U8 ; v3(129.44,83.96) 129.44,84 129.15,84.29 USM2002.H11 ; USM2003.K11 111.95,84.03 v3(111.95,83.89) ; USM2002.H6 128.8,88.61 v3(128.8,88.62) ; USM2001.G12 151.03,81.27 v3(151.35,80.95) 151.35,81.01 USM2001.H12 ; v3(126.2,88.62) 126.2,88.61 USM2002.D6 ; v3(152.04,84.9) USM2001.H8
  vias: v1(79.85,93.1) v1(80.51,93.86) v1(80.61,93.1) v1(81.22,93.86) v1(81.32,93.1) v1(85.44,92.16) v1(149.75,90.99) v1(152,85.92)
+VDDQ_MEM_GND: length 18.9
  TOP w0.102: PR27.1 66.44,94.47 v1(66.44,93.04) v1(66.44,91.6)
  IN1 w0.079: v1(66.44,91.6) 66.07,91.23 66.07,87.59 67.71,85.95 70.34,85.95 71.16,85.12 71.16,84.01 71.38,83.79 71.38,81.85 71.49,81.74 71.49,80.21 v4(71.44,80.17)
  BOTTOM w0.102: v4(71.44,80.17) 71.44,79.71 PU3254.E6
+VDDQ_MEM_SOC: length 29.2
  TOP w0.381: 117.66,77.03 117.66,77.63 114.7,80.58 113.81,80.58 113.23,80 110.45,80 108.27,82.19 105.08,82.19 103.72,83.55 103.27,83.55 v1(101.59,85.22)
  BOTTOM w0.152: U80.BB41 126.3,68.91
  BOTTOM w0.178: U80.BB32 121.34,68.01 v3(121.34,68.98) ; v3(129.92,69.02) 129.96,68.95 129.96,68.61 U80.BB47 ; v3(116.19,69.33) 116.33,69.2 116.33,68.04 U80.BB23 ; U80.BB51 132.42,68.14 132.42,68.43 132.42,68.94 v3(132.38,68.97)
  BOTTOM w0.254: v3(126.32,69.86) 126.32,68.92 126.3,68.91 ; U80.AU28 119.98,65.24 v3(120.35,64.99) ; v3(117.61,64.99) U80.AU23 ; v3(124.01,64.99) U80.AU35 ; U80.AM40 126.28,62.04 v3(125.84,62.44) ; U80.AU42 v3(127.67,64.99)
  vias: v1(118.78,74.44) v3(130.02,69.67)
GND: length 998.8
  TOP w0.102: 111.24,82.81 v3(111.24,82.81)
  TOP w0.178: v1(208.02,28.99) 207.87,28.84 PU51.11 ; v1(82.26,60.64) 82.42,60.49 82.42,59.62 82.28,59.48 PU14.8
  TOP w0.203: RAP1422.1 54.35,58.1 v1(54.45,58.2) ; v1(99.88,81.99) 99.91,81.96 RAP1431.2 ; v1(60.51,54.61) 60.51,54.35 60.75,54.11 CAP1499.1 ; PR23.2 59.78,83.83 59.78,83.82 PC1206.2 ; v3(96.82,55.94) 96.82,55.76 97.26,55.32 97.26,55.22 R1143.1 ; U135.3 96.39,90.35 v1(96.39,90.81) ; RAP3047.2 v1(91.89,90.33) ; R3608.2 39.15,49.79 v1(38.78,50.15) ; PU19.8 45.02,49.86 v1(44.95,49.79) ; U83.7 149.76,20.19 149.52,19.95 147.34,19.95 v1(146.47,20.81) ; CAP1291.1 115.69,48.32 v3(115.88,48.14) ; PR29.2 77.13,86.8 76.98,86.95 76.98,88.42 ; v3(104.45,86.46) 104.48,86.49 CSM2139.1 ; v1(54.32,58.83) 54.32,58.88 54.35,58.91 CAP1500.1 ; RAP1067.2 112.8,72.45 112.02,71.67 CAP1318.2
  TOP w0.254: RAP1035.2 90.85,64.35 v1(91.2,64.7) ; v3(114.6,86.35) 114.6,86.34 115.28,86.34 CSM2142.1 ; PC1323.1 72.43,84.09 v1(72.43,84.31) ; RAP1067.2 113.5,72.08 CAP1268.2 ; PU23.8 52.43,71.98 v1(52.32,72.09) ; U5.3 32.39,23.41 v1(32.45,23.48) ; D60.3 14.57,42.93 v1(14.7,43.06) ; CSM2036.2 167.34,73.24 v3(167.67,72.91) ; v1(21.63,54.11) 22.05,54.53 PU22.8 ; U82.32 57.17,60.66 57,60.83 v1(56.6,60.83) ; U82.2 55.86,59.02 v1(55.74,58.89) ; v1(201.47,22.26) 201.83,22.62 PU50.3 ; UAP1008.3 71.09,56.66 71.32,56.88 v1(71.32,56.93) ; R1116.2 137.2,71.98 137.49,71.68 v3(137.49,71.66) ; R136.2 136.59,39.07 136.37,38.85 v3(136,38.85) ; v1(57.38,54.61) 57.17,54.82 U82.9 ; R3611.2 v1(28.09,48.67) ; D61.3 v1(14.6,47) ; v1(48.73,51.9) 48.42,52.22 PU17.8 ; v1(62.4,59.32) 62.83,58.88 CAP1498.1 62.18,58.81 61.96,59.02 U82.23 ; U82.16 60.67,54.77 v1(60.51,54.61) ; v1(28.11,49.56) R3614.2
  TOP w0.305: CRCP4011.8 CRCP4011.3 131.79,20.35 v1(131.8,20.35) ; U130.1 41.02,46.53 40.84,46.72 40.84,47.18 v1(40.94,47.28) ; v1(38.19,51.58) 37.94,51.84 U95.47 ; v1(15.94,66.35) 15.94,66.17 16.2,65.92 UCP4034.3 UCP4034.8 ; v1(125.27,20.38) 125.27,20.38 125.06,20.58 CRCP4043.3 CRCP4043.8 ; PR177.1 199.11,42.74 199.61,42.74 v1(199.69,42.82) ; CPM3440.1 78.51,42.27 80.66,42.27 v1(80.74,42.2) ; U95.8 v1(33.39,53.67) ; CSM2100.2 129.43,89.56 v3(130.09,90.22) ; CSM2131.2 110.78,89.56 111.36,90.14 v3(111.36,90.22) ; v3(134.05,81.95) 133.67,82.33 CSM2107.1 ; v1(46.58,32.93) 46.4,32.75 PC1284.1 ; PC1326.1 54.38,25.16 v1(54.37,25.16) ; v1(200.05,41.55) 199.99,41.6 PC9119.2 ; CCP4215.1 174.21,27.49 v1(173.83,27.87) ; v1(9.24,70.52) UCP4036.3 UCP4036.8 v1(11.52,70.52) ; PU11.2 v1(105.45,32.8) ; v1(128.44,20.38) 128.44,20.63 128.49,20.68 CRCP4014.3 CRCP4014.8 ; U95.23 v1(29.74,47.34) ; v1(135.02,20.35) 135.02,20.36 135.02,20.58 135.09,20.66 CRCP4010.3 CRCP4010.8 ; v3(124.89,83.09) 125.38,83.58 CSM2106.2 ; v1(174.57,27.9) 175,27.9 175.35,27.54 C842.1 ; v1(138.83,20.38) 138.83,20.38 138.83,20.99 138.52,21.29 CRCP4009.3 CRCP4009.8 ; v1(205.36,18.52) EU1B2.14 ; v1(143.45,20.33) 143.45,20.33 143.45,20.71 143.98,21.24 CRCP4008.3 CRCP4008.8 ; v1(76.93,88.47) 76.98,88.42
  TOP w0.381: v3(116.16,53.67) 116.16,53.98 116.19,54.01 v3(116.19,54.25) 115.58,54.25 CAP1256.2 ; v3(116.16,53.67) 116.41,53.42 v3(116.72,53.42) 116.86,53.28 CAP1261.2 ; v3(116.16,53.67) 115.78,53.28 C1140.1 ; v1(65.7,86.01) 66.13,85.59 PR170.2 ; C850.1 25.62,67.19 25.38,66.95 v1(25.38,66.68) ; CAP1275.2 115.54,72.55 v3(115.58,72.59) ; CSM2038.2 171.95,73.64 v3(171.52,73.64) ; v1(17.44,22.49) 17.75,22.49 18,22.23 C1C50.2 ; PC1144.1 46.06,50.59 v1(46.02,50.63) ; CAP14481.2 114.22,56.13 v3(113.92,55.83) ; C1C42.1 27.42,14.38 v1(27.18,14.13) ; v1(17.16,10.42) 17.59,10.42 17.75,10.27 C4.1 ; v3(121.38,88.47) 121.74,88.47 RSM2076.1 ; CSM1017.2 151.95,80.58 v3(152.36,80.17) ; v3(166.94,69.77) 166.96,69.75 CSM2034.1 ; PC309.1 v1(207.87,31.19) ; v1(27.04,62.59) 27.17,62.47 C8L13.2 ; R1C5.2 15.71,16.49 v1(15.38,16.16) ; RAP1023.2 167.11,82.08 v1(167.35,82.33) ; PC8.2 66.68,20.26 v1(66.68,19.62) ; v1(42.72,51.47) 42.33,51.08 PC1149.1 ; CSM1025.2 151.69,90.01 v3(151.36,89.68) ; C133.2 41.23,53.69 41.67,54.14 v1(41.67,54.24) ; PC1148.1 26.52,57.73 27.32,58.53 v1(27.32,58.63) ; R41.1 v1(22.06,29.75) ; v3(111.05,72.5) 111.05,72.35 CAP1318.2 ; v1(141.11,41.56) 141.11,41.14 R138.2 ; PR98.2 v1(26.76,66.07) ; C1C43.2 29.13,11.51 v1(29.18,11.46) ; v3(74.68,79.66) 74.68,79.84 PR187.2 ; CSM1023.2 151.27,84.24 v3(151.34,84.16) ; C1M8.2 v1(22.45,21.98) ; v1(102.91,39.76) 102.91,39.2 R6001.1 ; C1080.1 v1(33.12,55.53) 33.49,55.53 33.76,55.79 C1.2 ; C1C4.1 20.29,20.53 v1(20.24,20.48) ; v3(152.65,87.28) 152.75,87.37 CSM1019.2 ; v1(18.86,39.23) 19.03,39.23 C344.1 ; v1(15.12,58.3) 15.12,57.76 C948.2 ; CSM2136.1 114.76,82.44 v3(114.32,82.44) ; v1(27.14,16.67) 27.66,16.15 R1A2.2 ; v1(155.75,22.31) 155.75,22.17 R5106.1 ; v1(204.49,21.01) 204.18,20.71 R1M4.1 ; PC1146.1 79.38,62.37 v1(79.19,62.18) ; PR180.2 77.67,82.47 v1(77.67,83.07) ; C8L20.2 17.17,69.73 v1(16.6,70.29) ; PR188.1 72.92,73.35 72.53,72.96 v1(72.53,72.78) ; C1M7.2 17.38,16.79 v1(17.54,16.95) ; C843.1 v1(176.12,19.21) ; PC1274.2 v1(41.88,50.08) PC1305.2 ; C893.1 27.73,46.52 v1(27.45,46.8) ; v1(87.22,83.22) 87.48,82.96 R6003.1 ; v1(27.86,23.91) 27.92,23.85 C1C29.2 ; v1(141.95,39.4) 141.96,39.4 CAP1152.2 ; v1(26.92,19.72) 27.25,19.72 27.53,20.01 C1114.2 ; v3(111.96,56.67) 111.96,56.4 111.68,56.12 CAP14482.1 ; C1M6.2 21.3,21.75 v1(21.13,21.93) ; PC1275.2 v1(218.43,30.01) ; PC9113.2 73.6,80.29 v4(73.44,80.14) ; PC1248.2 130.09,82.57 v3(130.09,83.16) ; PC1315.2 61.65,72.73 60.81,72.73 PC9114.2 60.33,72.64 59.94,73.03 v1(59.94,74.2) ; RSM2075.1 122.18,89.92 121.74,89.92 v3(121.46,90.2) ; EC1.2 8.62,68.62 8.62,68.63 8.92,68.93 v1(9.19,68.93) ; v1(174.83,19.2) 174.83,19.7 175.23,20.1 RCP4021.2 ; v1(36.8,56.68) 36.92,56.55 C867.1 ; R5037.2 135.96,40.24 v3(135.99,40.22) ; C1138.2 110.98,39.31 110.69,39.61 v1(110.43,39.61) ; v3(113.27,53.37) 113.27,53.15 113.43,52.99 CAP1244.2 ; PC307.2 v1(207.61,22.29) ; v3(112.15,48.89) 112.29,48.89 C1102.1 ; C341.1 C340.1 24.58,48.19 v1(24.88,47.89) ; C1105.2 196.02,15.4 v1(196.14,15.52) ; C2M1.2 v1(30.2,17.56) ; C8L14.2 27.72,64.64 v1(27.58,64.5) ; RAP1034.2 v1(169.97,85.55) ; v1(103.01,90.99) 102.9,90.88 RSM2112.1 RSM2113.1 ; PR147.1 v1(65.85,82.96) ; R936.1 25.25,70.27 24.99,70.01 v1(24.99,69.61) ; PC308.2 v1(206.6,22.29) ; RAP1030.2 v1(172.69,85.5) ; C1113.2 24.72,19.66 v1(24.55,19.49) ; v1(99.11,79.33) 99.13,79.32 99.13,79.13 98.57,78.57 R5147.1 ; v3(168.26,69.78) 168.29,69.75 CSM2029.2 ; C868.1 40.11,53.63 39.88,53.86 v1(39.87,53.86) ; CSM3132.2 109.31,83.35 v3(109.71,82.95) ; D46.2 16.53,9.93 v1(16.53,10.42) ; v1(92.78,82.45) 92.37,82.04 U138.7 ; C1139.2 112.61,38.26 112.97,38.62 v1(113.12,38.62) ; C1D17.2 29.56,12.73 v1(29.18,12.35) ; v1(20.26,53.93) 20.26,53.83 20.57,53.53 21.01,53.53 PR97.2 ; RAP1021.2 v1(172.69,82.08) ; D50.2 16.23,18.14 v1(16.43,18.14) ; R1D11.2 38.03,25.24 37.66,24.87 v1(37.66,24.16) ; v1(112.41,41.31) CAP1249.2 ; R1D19.1 16.86,22.39 v1(16.76,22.49) ; v1(170.02,82.33) 169.81,82.12 RAP1025.2 ; R1182.1 v1(36.16,42.79) ; PC1306.2 v1(213.57,27.44) ; v1(19.58,19.26) 19.26,19.57 C2M5.2 ; RAP1055.2 112.43,39.84 v1(112.43,39.72) 112.8,39.72 C1141.1 ; D49.2 17.42,8.26 v1(17.8,8.26) ; v1(45.1,44.91) 45.05,44.86 R3609.2 ; PC1280.2 v1(208.63,22.29) ; v1(67.58,19.62) 67.91,19.95 PC9.2 ; v1(28.54,23.91) 28.54,24.29 28.16,24.67 C1C28.2 ; R1M5.1 v1(205.33,20.96) ; PU15.2 83.94,64.6 v1(84.83,63.71) ; PC1.2 54.39,68.7 v1(53.99,69.1) ; PC1307.2 v1(218.43,26.83) ; C849.1 v1(23.97,71.42) ; v1(102.89,42.65) 102.76,42.53 102.76,41.57 R1064.1 ; PC1220.2 111.24,82.81 ; C2B3.2 v1(203.04,20.99) ; RCP4221.2 v1(203.47,11.29) ; C1107.2 v1(36.19,24.3) ; C343.1 v1(18.86,39.86) ; PC310.1 v1(208.88,31.19) ; CAP14491.2 v1(30.06,20.99) ; RAP1032.2 v1(167.34,85.51) ; PC1318.2 v1(201.93,36.29) ; PR157.2 v1(201.92,34.32) ; CCP4019.2 v1(174.21,19.21) ; PC1320.1 74.55,77.73 v3(74.72,77.9) 74.05,78.57 PC1316.2 ; PR167.1 v1(201.93,35.32)
  TOP w0.508: v1(22.4,53.14) 22.8,53.55 PC1310.2 ; v1(78.38,47.28) 77.68,47.97 C831.2 ; v1(107.94,43.14) 107.42,42.61 CAP1271.2 ; Q121.1 11.37,82.35 10.71,81.69 10.71,80.22 Q125.1 11.73,79.31 13.94,77.1 v1(13.94,76.72) ; v1(29.15,55.96) 28.1,55.96 PC1304.2 ; C946.2 30.44,56.79 v1(30.27,56.95) ; CAP1276.2 96,58.29 v1(95.91,58.2) ; v1(26.08,60.03) 26.24,59.86 26.24,59.1 PQ129.1 ; CPM4431.1 v1(92.93,87.99) ; QCP4007.1 v1(24.1,32.14) ; v1(12.74,66.86) 13.17,67.29 U4.2 14.42,67.29 v1(14.83,66.89) ; v1(67.05,72.91) 67.4,72.91 PC1324.1 ; PC1190.2 65.67,67.11 65.65,67.14 v1(65.6,67.14) 66.31,67.85 66.41,67.85 66.67,68.11 PC1191.2 ; R1000.1 v1(30.44,54.26) ; v1(152.77,21.37) 152.77,20.34 R1C10.2 ; C1M9.2 19.12,10.78 v1(18.74,10.4) ; CSM2156.1 v1(59.78,44.43) ; v1(52.77,69.27) 52.77,68.72 PC1301.2 ; C590.1 152.62,24.21 v1(152.93,24.52) ; v1(94.53,30.23) 95.12,30.23 CPM3479.1 ; v1(78.5,72.12) 78.17,72.12 77.67,72.63 PR138.1 ; v1(23.64,56.85) 23.64,57.12 PC1311.2 ; CAP1268.2 113.5,69.4 v3(113.89,69.01) ; v1(84.37,56.57) 84.37,57.13 PC1270.2 PC1299.2 ; R5080.2 76.29,45.66 v1(76.1,45.85) ; PC9112.2 70.99,70.95 v1(71.04,70.9) ; PR90.2 75.99,75.47 v3(76.14,75.62) ; PC1267.1 79.47,65.5 78.96,64.99 v1(78.96,63.91) ; C1106.2 v1(177.09,90.11) ; v1(71.34,22.13) 71.59,21.88 PD2.2 ; C1D8.2 v1(34.07,27.47) ; v5(72.27,18.87) 72.28,18.88 PD1.2 ; U132.2 22.19,27.41 v1(22.06,27.54) ; QPM3387.1 75.43,38.13 v1(75.53,38.23) ; QAP1009.1 70.66,59.72 v1(71.29,59.09) ; PC1276.2 v1(22.06,56.79) 21.82,56.55 C1009.2 ; v1(77.39,45.85) C1089.1 ; PC1278.2 v1(50.76,49.56) ; v1(80.66,48.78) 80.24,49.2 C832.2 ; PC9110.1 69.28,71.37 v1(69.28,71.05) 69.28,71.03 69.7,70.61 PC1321.1 ; v1(50.84,52.61) 50.39,52.16 PC1312.2 ; C437.2 v1(177.39,85.25) ; v1(172.18,27.85) 171.68,27.35 EC2.2 ; v1(19.91,55.07) 19.96,55.02 PC1309.2 ; Q110.1 11.93,74.48 v1(12.16,74.71) ; HOLE4.1 HOLE4.6 ; Q109.1 v1(14.8,75.27)
  IN2 w0.254: v3(127.67,48.9) v3(127.67,49.55)
  BOTTOM w0.076: USM2006.N2 56.94,45.34 56.48,45.34 56.2,45.07 v1(56.2,44.86) ; v1(125.05,45.03) 125.05,45.31 125.21,45.47 125.21,45.95 125.37,46.11 125.66,46.11 125.82,46.27 125.82,46.38 U80.B39 ; U80.BB60 137.39,68.1
  BOTTOM w0.102: v3(123.71,44.56) 123.71,44.99 124.09,45.37 124.09,46.38 U80.B34 ; v1(61.69,47.07) 61.69,47.08 USM2006.C4
  BOTTOM w0.127: 112.61,60.02 112.62,60.03 112.62,60.95 U80.AK16 ; v3(130.55,92.74) 130.11,92.74 129.84,92.46 129.32,92.46 129.09,92.22 129.09,91.52 USM2002.H2
  BOTTOM w0.152: 137.39,68.1 137.39,68.98 v3(137.41,69) ; v1(13.15,63.79) 13.1,63.79 12.79,64.09 U133.5 ; v3(134.05,81.95) 134.64,82.55 134.64,82.85 ; U80.C25 118.42,46.74 118.42,45.95 v1(118.82,45.54) ; USM2000.T12 173.13,69.84 173.46,69.51 173.46,68.98 v3(173.47,68.97)
  BOTTOM w0.153: USM2000.D12 164.91,69.68 164.91,69.53 v3(164.5,69.12) ; USM2003.G9 109.41,86.21 v3(109.41,86.36)
  BOTTOM w0.178: U80.AG71 144.74,59.6 144.91,59.43 v3(144.92,59.38) ; U80.BB30 120.02,68.19 120.02,68.82 120.02,69.14 v3(119.88,69.28) ; v3(144.64,50.12) 144.52,50 U80.H71 ; U80.BB26 117.67,68.96 v3(117.62,69.01) ; v3(115.93,81.84) 115.91,81.85 115.91,83.16 USM2003.T12 ; U80.BB64 139.73,68.62 139.73,69 v3(139.73,69) ; U80.BB55 134.79,68.1 134.79,68.96 v3(134.75,69) ; U80.BB34 122.65,68.36 122.65,69.64 v3(122.69,69.68) ; U80.AT71 144.74,64.6 144.74,64.61 144.89,64.61 v3(144.93,64.62) ; U80.BB18 113.92,68.98 v3(113.89,69.01) ; U80.BB38 124.99,68.1 124.99,69.04 v3(124.96,69.07) ; v3(144.92,62.31) 144.86,62.25 U80.AM71 ; v3(127.63,69.04) 127.6,69.01 U80.BB43
  BOTTOM w0.203: USM2002.B2 124.9,91.81 v3(124.9,91.82) ; USM2000.B5 163.71,76.03 v3(163.71,76.04) ; U80.F42 v3(127.67,49.55) ; USM2000.L8 169.55,73.64 v3(169.55,73.79) ; PU13.8 99.42,87.25 v1(99.38,87.28) ; v3(166.96,76.84) 166.96,76.83 USM2000.G4 ; v3(114.32,82.44) 113.71,82.44 112.99,83.17 USM2003.M12 ; USM2001.G9 151.34,84.05 v3(151.34,84.16) ; v3(124.89,83.09) 124.89,83.16 USM2002.B12 ; U80.K61 138.66,50.73 U80.K63 ; USM2000.C6 164.36,75.23 v3(164.36,75.24) ; U80.AV1 103.29,65.92 103.07,66.14 v3(102.89,66.14) ; v3(148.94,84.99) 149.08,84.86 USM2001.D8 ; PR162.1 v1(172.48,49.04) ; USM2003.E6 108.12,88.61 v3(108.12,88.62) ; USM2000.T2 173.45,78.43 v3(173.45,78.44) ; USM2000.L9 169.55,72.84 v3(169.55,72.97) ; USM2003.E5 108.12,89.41 v3(108.12,89.42) ; U80.D48 U80.D47 130.46,47.74 130.08,47.74 130.05,47.76 129.76,47.76 129.74,47.74 129.35,47.74 U80.D45 U80.D44 ; v3(106.17,88.62) 106.17,88.61 USM2003.B6 ; v3(109.38,65.63) 109.08,65.92 U80.AW10 ; v3(170.53,69.62) USM2000.M12 ; v3(115.91,91.02) 115.91,91.01 USM2003.T3 ; RPM3465.2 76.96,34.57 v1(76.7,34.83) ; U80.AV68 141.87,65.8 141.87,65.43 141.79,65.35 141.79,65.29 141.87,65.03 U80.AT68 141.87,64.22 141.84,64.19 141.84,63.89 141.87,63.86 U80.AP68 141.87,62.99 141.84,62.96 141.84,62.67 141.87,62.64 U80.AM68 141.87,61.76 141.79,61.68 141.79,61.4 142.2,60.99 U80.AK68 142.2,60.81 U80.AH67 ; U96.15 22.98,59.33 v1(23.18,59.13) ; USM2003.G3 109.42,91.01 v3(109.42,91.02) ; CSM2035.1 173.21,82.94 CSM2031.2 ; 134.64,82.85 134.32,83.17 USM2002.T12 ; PU3254.E1 74.65,79.69 v3(74.68,79.66) ; v3(124.01,51.06) U80.J35 ; CN17.20 103.53,16.75 103.42,16.86 v1(103.42,16.9) ; USM2002.G3 128.15,91.01 v3(128.15,91.02) ; PU3254.C2 73.47,80.16 v4(73.44,80.14) ; USM2002.D3 126.2,91.01 v3(126.2,91.02) ; v1(118.52,51.06) U80.J25 ; USM2000.F6 166.31,75.23 ; 166.31,75.23 165.99,74.91 USM2000.E6 ; 166.31,75.23 v3(166.31,75.24) ; U80.G43 127.71,50.22 U80.J42 ; U80.AW6 106.7,66.56 v3(106.67,66.59) 106.66,66.61 U80.BA6 U80.BB6 ; RAP1455.2 97.5,39.89 v1(97.55,39.83) ; CN17.8 105.93,16.8 v1(105.83,16.9) ; USM2001.H10 151.98,83.24 v3(151.98,83.31) ; USM2006.J5 59.18,47.55 v1(59.2,47.57) ; USM2000.G9 167.28,72.54 167.66,72.91 v3(167.67,72.91) 167.67,72.92 USM2000.G8 ; v3(108.77,88.62) 108.77,88.61 USM2003.F6 ; USM2003.B2 106.17,91.81 v3(106.17,91.82) ; USM2002.N6 132.69,88.61 v3(132.69,88.62) ; USM2003.F5 108.77,89.41 v3(108.77,89.42) ; v3(144.83,51.36) 144.72,51.35 U80.K71 ; v3(125.81,50.96) 125.84,50.93 U80.J38 ; RAP1326.1 98.95,72.08 98.68,72.35 v3(98.68,73.61) ; v3(65.63,80.19) 65.85,80.19 66.36,79.69 PU3254.E16 ; USM2000.B2 163.71,78.43 v3(163.71,78.44) ; v3(151.34,85.12) 151.34,84.85 USM2001.G8 ; U80.F37 v3(124.01,49.55) U80.F35 ; v3(165.01,72.97) 165.01,72.99 USM2000.D8 ; v3(142.49,69.08) 141.81,68.41 U80.BB67 ; v3(130.55,92.74) 130.55,91.62 USM2002.K2 ; v3(166.96,77.64) 166.96,77.63 USM2000.G3 ; U80.F32 v3(122.18,49.55) U80.F33 ; USM2002.C3 125.55,91.01 v3(125.55,91.02) ; USM2000.E5 165.66,76.03 v3(165.66,76.04) ; v3(148.76,88.88) 148.76,88.86 USM2001.D3 ; v3(166.31,76.84) 166.31,76.83 ; 166.31,76.83 USM2000.F4 ; 166.31,76.83 165.99,76.51 USM2000.E4 ; v3(151.36,89.68) 151.36,89.66 USM2001.H2 ; USM2001.B2 147.46,89.66 v3(147.46,89.68) ; R1045.1 94.78,61.73 v3(94.68,61.63) ; USM2003.T2 115.91,91.81 v3(115.91,91.82) ; U80.AL52 132.24,60.8 132.02,60.59 v3(131.54,60.59) ; v3(128.54,60.89) 128.58,60.93 U80.AL45 ; v3(152.98,90.33) USM2001.K2 ; USM2000.H10 167.61,71.39 v3(167.61,71.37) ; v4(73,78.7) 73,78.21 PU3254.H3 ; U80.AL66 140.8,61.94 140.76,61.99 140.38,61.99 140.33,61.94 U80.AL65 140.17,61.94 140.12,61.99 139.74,61.99 139.7,61.94 U80.AL64 ; v1(84.77,32.67) 85.18,33.08 R1054.2 ; USM2000.P12 171.83,69.95 171.91,69.87 171.91,68.84 171.99,68.76 171.99,68.03 v3(172.27,67.76) ; USM2000.F5 166.31,76.03 v3(166.31,76.04) ; v3(168.87,72.07) USM2000.K10 ; U80.AF4 105.13,59.24 v3(104.98,59.08) 104.65,59.08 U80.AF2 U80.AF1 ; USM2003.C6 106.82,88.61 v3(106.82,88.62) ; v1(99.28,16.92) 99.13,16.77 CN17.42 ; USM2000.G6 166.96,75.23 v3(166.96,75.24) ; U80.AD21 115.44,57.81 115.01,57.81 U80.AD20 ; v3(130.77,85.47) 130.77,85.43 130.43,85.09 USM2002.K10 ; v3(112.01,91.82) 112.01,91.81 USM2003.K2 ; 108.12,90.21 v3(108.12,90.22) ; v1(65.22,56.62) 64.94,56.9 RSM2150.2 ; USM2003.G6 109.42,88.61 v3(109.42,88.62) ; v3(106.17,89.42) 106.17,89.41 USM2003.B5 ; USM2002.T2 134.64,91.17 v3(134.64,91.02) ; C1136.2 70.13,54.27 69.09,54.27 RSM2152.2 ; v3(115.22,60.86) 115.4,61.04 115.4,61.13 U80.AK21 115.72,61.1 U80.AK22 ; v3(163.71,69.77) 163.71,69.79 USM2000.B12 ; USM2000.C3 164.36,77.63 v3(164.36,77.64) ; v3(165.01,77.64) 165.01,77.63 USM2000.D3 ; U80.AW10 U80.BA10 ; U80.AW10 108.59,66.13 108.56,66.1 108.27,66.1 108.24,66.13 U80.AW8 ; 108.77,90.21 v3(108.77,90.22) ; USM2003.G8 v3(109.41,86.36) ; v3(106.82,89.42) 106.82,89.41 USM2003.C5 ; CN17.15 104.33,12.22 v1(104.38,12.27) ; v1(60.42,47.51) 60.42,47.32 USM2006.G5 ; USM2001.D12 149.08,81.1 148.83,80.84 148.83,80.63 148.64,80.44 v3(148.64,80.19) ; U80.AK27 118.86,60.99 118.86,60.28 v3(118.98,60.16) ; U80.AU20 114.41,66.08 114.38,66.1 ; v3(133.22,60.64) 133.92,60.64 134.07,60.79 U80.AL55 ; v3(171.52,73.64) 171.52,73.62 USM2000.P8 ; U80.AW12 110.66,66.13 110.69,66.1 110.98,66.1 111.02,66.13 U80.AW14 111.61,66.13 v3(112.12,65.63) 112.63,66.13 U80.AW16 113.08,66.13 113.11,66.1 113.41,66.1 113.44,66.13 U80.AW18 114.35,66.13 114.38,66.1 ; USM2000.B6 163.71,75.23 v3(163.71,75.24) ; USM2001.F12 150.38,80.95 v3(150.55,80.78) ; U96.18 v1(21.78,59.09) ; v3(130.04,60.61) 130.41,60.98 U80.AL48 ; v3(166.94,69.77) 166.63,70.08 USM2000.F12 ; USM2003.H2 110.36,91.49 109.14,92.7 v3(109,92.7) ; 114.38,66.1 114.68,66.1 114.71,66.13 U80.AW21 115.5,66.13 115.53,66.1 115.83,66.1 115.86,66.13 U80.AW23 116.83,66.13 116.86,66.1 117.15,66.1 117.18,66.13 U80.AW26 118.05,66.13 118.08,66.1 118.38,66.1 118.41,66.13 U80.AW28 119.28,66.13 119.31,66.1 119.61,66.1 119.64,66.13 U80.AW30 120.51,66.13 120.54,66.1 120.83,66.1 120.86,66.13 U80.AW32 121.69,66.13 v3(122.18,65.64) 122.55,66.01 U80.AW34 123.03,66.13 123.07,66.1 123.36,66.1 123.39,66.13 U80.AW36 124.26,66.13 124.29,66.1 124.59,66.1 124.62,66.13 U80.AW38 125.33,66.13 v3(125.85,65.63) 126.3,66.09 U80.AW41 126.76,66.13 126.79,66.1 127.09,66.1 127.12,66.13 U80.AW43 127.99,66.13 128.02,66.1 128.32,66.1 128.35,66.13 U80.AW45 129.22,66.13 129.25,66.1 129.54,66.1 129.57,66.13 U80.AW47 130.38,66.13 130.41,66.1 130.71,66.1 130.74,66.13 U80.AW49 131.64,66.13 131.67,66.1 131.96,66.1 131.99,66.13 U80.AW51 132.8,66.13 132.83,66.1 133.13,66.1 133.16,66.13 U80.AW53 134.03,66.13 134.06,66.1 134.36,66.1 134.39,66.13 U80.AW55 135.26,66.13 135.29,66.1 135.58,66.1 135.61,66.13 U80.AW57 136.53,66.13 136.56,66.1 136.86,66.1 136.89,66.13 U80.AW60 137.78,66.13 137.88,66.03 138.16,66.03 138.25,66.13 U80.AW62 138.99,66.13 139.02,66.1 139.31,66.1 139.34,66.13 U80.AW64 139.88,66.08 140.84,66.08 U80.AW66 141.11,66 141.19,66.08 141.21,66.08 v3(141.38,66.26) U80.AY66 U80.BA66 ; v3(114.61,91.02) 114.61,91.01 USM2003.P3 ; USM2002.L6 131.43,88.65 v3(131.43,88.7) ; U80.AF63 138.84,59.35 138.84,60.05 U80.AH63 ; USM2002.M6 132.08,88.65 v3(132.08,88.73) ; R1044.1 R1046.1 95.94,59.85 v1(96.15,59.64) ; v3(152.36,80.17) 152.36,81.31 USM2001.J12 ; USM2000.H2 167.93,80.07 168.3,80.43 168.98,80.43 v3(169.72,79.7) ; 109.42,90.21 v3(109.42,90.22) ; v3(126.85,86.36) 126.84,86.36 126.52,86.68 USM2002.D8 ; CN17.36 v1(100.33,16.93) ; PU3254.N16 66.42,75.73 v3(65.89,75.73) ; USM2006.P4 v1(56.18,46.58) ; PU3254.H1 74.43,78.19 v3(74.72,77.9) 74.66,77.83 74.12,77.83 PU3254.J1 ; v3(122.18,50.93) U80.J32 ; USM2003.C3 106.82,91.01 v3(106.82,91.02) ; U6.9 v1(16,29.84) ; U80.F40 v3(125.84,49.55) U80.F38 ; v1(73.96,42.02) 74.16,41.82 RPM3426.1 ; PU3254.N1 76.08,75.69 v3(76.14,75.62) ; USM2000.C5 164.36,76.03 v3(164.36,76.04) ; USM2001.C3 148.11,88.86 v3(148.11,88.88) ; PU3254.P5 71.97,75.67 v4(71.93,75.71) 71.47,76.17 PU3254.L6 ; CN17.31 101.13,12.14 v1(101.26,12.28) ; USM2000.J12 v3(168.26,69.78) ; U80.BA2 103.98,67.95 U80.BA1 103.32,68.15 v3(103.32,68.49) ; v1(55.86,47.91) 56.35,47.91 USM2006.P6 USM2006.N5 ; U80.AL58 v3(135.9,60.88) ; USM2002.J4 130.09,90.21 v3(130.09,90.22) ; U80.V18 v3(113.92,55.83) ; USM2001.G3 150.71,88.86 v3(150.71,88.88) ; v3(120.35,51.04) U80.J28 ; PU3254.B8 PU3254.A8 70.47,81.82 v1(70.81,82.15) 70.97,81.99 PU3254.A7 PU3254.B7 PU3254.B8
  BOTTOM w0.254: v3(156.55,88.08) 156.55,88.06 USM2001.R4 ; v3(154.6,87.28) 154.6,87.26 USM2001.M5 ; v3(115.26,90.22) 115.26,90.21 USM2003.R4 ; v1(59.99,50.07) 59.68,49.77 USM2006.H10 ; USM2002.N5 132.69,89.41 v3(132.69,89.42) ; U80.W6 106.35,55.9 106.77,56.32 v3(106.77,56.43) ; v3(131.32,64.36) U80.AR48 ; USM2001.P8 155.9,84.22 v3(155.9,84.19) ; U80.AW53 v3(133.59,66.64) U80.BA53 ; v3(149.41,88.08) 149.41,88.06 USM2001.E4 ; v3(155.25,88.08) 155.25,88.06 USM2001.N4 ; USM2000.T3 173.45,77.63 v3(173.45,77.64) ; v1(22.45,21.98) 22.75,21.98 22.95,21.78 22.95,21.5 22.84,21.38 U108.3 ; U80.F2 104.67,48.81 v3(104.98,48.81) 105.29,48.81 U80.F4 ; U80.D58 v3(136.1,47.26) U80.B58 ; v3(137.72,62.34) 137.63,62.35 U80.AM60 ; U80.E21 115.69,48.14 v3(115.88,48.14) 116.24,47.77 U80.D22 v3(116.28,47.26) U80.B22 ; USM2002.B5 124.9,89.41 v3(124.9,89.42) ; U80.G6 107.35,49.55 v3(107.52,49.55) 107.92,49.15 U80.F8 ; U80.AD20 114.69,58.13 114.45,58.13 U80.AD19 ; USM2002.N4 132.69,90.21 v3(132.69,90.22) 132.69,90.36 USM2002.P3 ; U80.F13 110.52,48.93 v3(110.35,48.93) 110.15,48.93 109.84,48.61 U80.E11 110.14,48.2 v3(110.33,48.2) 109.86,47.73 U80.D11 109.48,47.77 U80.D10 108.84,47.52 v3(109.09,47.28) 108.84,47.04 U80.B10 ; U80.F13 110.97,49.15 v3(111.21,48.92) 111.24,48.92 111.29,48.88 111.66,48.5 U80.E15 111.77,48.5 v3(112.15,48.89) 112.17,48.91 112.17,49.54 v3(112.15,49.56) 112.15,50.16 v3(112.12,50.19) ; U80.F13 110.75,49.24 110.43,49.56 v3(110.34,49.56) ; v3(170.2,75.34) 170.2,75.33 169.88,75.01 USM2000.L6 ; U80.D48 v3(131.15,47.26) U80.B48 ; PC1147.1 v1(97.6,94.71) ; v3(139.79,53.29) 139.8,53.29 139.92,53.16 139.93,53.16 140.2,52.89 U80.N65 ; v3(139.3,60.61) 139.52,60.28 U80.AH64 ; v3(139.3,60.61) U80.AH63 ; v3(139.3,60.61) U80.AK63 U80.AM61 v3(138.64,62.44) ; USM2003.K10 111.69,85.07 v3(112.01,84.75) ; v1(51.03,62.03) 51.4,61.65 J8L1.31 ; U80.AT63 139.55,64.36 ; 139.55,64.36 v3(139.53,64.36) ; 139.55,64.36 U80.AR63 ; v3(155.5,80.82) 155.58,80.91 USM2001.P12 ; v1(61.71,48.37) 61.62,48.37 61.34,48.08 USM2006.E7 ; v3(128.15,90.22) 128.15,90.21 USM2002.G4 ; U80.U64 139.27,55.13 ; 139.27,55.13 v3(139.27,55.13) ; 139.27,55.13 U80.U63 ; U80.AU10 v3(109.38,65.63) ; v3(131.32,49.55) U80.G48 ; U80.K70 v3(142.68,51.15) U80.K68 U80.K67 141.24,51.37 v3(141.24,51.42) ; U80.AM21 115.73,62.45 v3(115.78,62.45) ; U80.AL38 v3(124.92,60.88) ; U80.AW6 106.46,66.13 106.21,66.39 105.93,66.39 v3(105.69,66.63) ; USM2000.N4 171.5,76.83 v3(171.5,76.84) ; v3(124.01,63.72) U80.AP35 ; USM2000.R5 172.8,76.03 v3(172.8,76.04) ; USM2003.M4 113.31,90.21 v3(113.31,90.22) ; 136.79,64.43 136.77,64.33 U80.AR58 136.24,63.99 v3(135.9,64.34) ; 136.79,64.43 v3(136.81,64.43) ; 136.79,64.43 136.79,64.54 136.68,64.64 U80.AT58 136.2,64.64 v3(135.9,64.34) ; v3(153.3,83.41) 153.63,83.74 USM2001.L9 ; USM2001.C5 148.11,87.26 v3(148.11,87.28) ; U80.F23 116.76,49.55 v3(116.69,49.55) ; U80.W13 110.62,56.08 110.62,56.12 v3(110.38,56.35) ; v3(138.64,49.58) 138.64,50.28 U80.K61 ; v3(138.64,49.58) v3(138.64,48.93) v3(138.64,48.28) 138.58,48.22 U80.D62 v3(138.58,47.26) U80.B62 ; v3(138.64,49.58) 138.8,49.74 U80.G63 139.2,49.74 v3(139.66,50.2) 139.66,51 U80.K64 ; U80.AN37 v3(124.92,63.09) 124.96,63.05 U80.AN38 ; v3(132.04,89.42) 132.04,89.41 USM2002.M5 ; v3(142.06,45.13) 142.06,45.27 141.73,45.59 U80.A67 ; v3(119.35,60.76) 119.44,60.85 U80.AL28 ; USM2000.N5 171.5,76.03 v3(171.5,76.04) ; USM2001.T5 157.2,87.26 v3(157.2,87.28) ; U80.AL2 104.64,62.03 104.66,62.03 104.69,62.07 v3(104.96,62.07) 105.29,62.07 U80.AL4 U80.AJ4 ; U80.AG21 115.22,59.92 v3(115.22,60.02) ; U80.AT35 v3(124.01,64.36) U80.AR35 ; U80.AL32 121.27,60.86 v3(121.36,60.76) ; U80.N21 115.91,53.26 115.91,53.36 ; U80.AR42 v3(127.67,64.36) U80.AT42 ; v3(150.06,88.08) 150.06,88.06 USM2001.F4 ; 112.63,51.6 112.29,51.94 U80.L16 ; 112.63,51.6 v3(112.63,51.62) ; 112.63,51.6 112.94,51.91 U80.L17 113.04,52.15 113.5,52.15 U80.L18 ; U80.AH6 106.25,60.01 U80.AF4 ; v1(44.19,61.78) 44.4,61.57 J8L1.17 ; v3(109.71,82.95) 109.63,82.95 USM2003.F12 ; U80.T2 104.8,53.93 v3(104.98,54.11) 105.16,53.93 U80.T4 ; U80.AR53 v3(134.07,64.36) 134.16,64.36 U80.AR55 ; U80.BA71 144.65,67.95 v3(144.92,68.22) 144.73,68.41 U80.BB70 ; v3(127.67,49.55) 127.87,49.55 U80.G43 v3(128.58,49.55) U80.G45 129.42,49.59 v3(129.5,49.55) ; v3(125.86,48.84) 125.98,48.84 U80.F40 126.55,48.9 126.92,48.9 127.17,49.15 U80.F42 v3(127.67,48.9) ; v3(125.86,48.84) 125.69,48.84 U80.F38 125.09,48.87 124.75,48.87 U80.F37 124.47,49.15 124.27,48.96 v3(124.02,48.96) 123.75,48.96 U80.F35 123.48,49.08 122.71,49.08 U80.F33 ; v3(125.86,48.84) v3(125.86,48.19) 126.19,47.86 U80.D39 126.14,47.73 v3(126.14,47.27) 126.14,46.8 U80.B39 ; U80.P19 114.25,53.78 v3(113.91,54.12) 113.91,54.26 U80.T18 113.45,54.72 113.09,54.72 U80.T17 ; UCP4006.6 89.39,16.04 v1(89.6,16.25) ; v3(107.24,52.14) 107.24,52.07 U80.L8 108.01,51.3 U80.J8 ; v3(150.71,86.48) 150.71,86.46 USM2001.G6 ; v3(105.21,44.79) 105.21,45.21 U80.A5 ; U80.AD8 107.55,58.16 v3(107.86,58.47) ; v1(225.04,22.72) 225.57,22.72 225.83,22.45 CN2.14 ; USM2002.M4 132.04,90.21 v3(132.04,90.22) ; v3(113.95,63.72) U80.AP18 ; PU18.8 100.36,92.37 100.24,92.25 v1(100.24,91.85) ; U80.Y17 112.94,56.11 112.29,55.46 U80.V16 112.29,55.33 v3(111.96,54.99) ; U80.F68 U80.D69 142.92,48.12 v3(142.92,48.12) ; U80.BA23 v3(116.37,66.64) U80.AW23 ; U80.D6 106.37,47.75 v3(106.37,47.26) 106.12,47.26 105.94,47.08 U80.C5 ; U80.AP63 139.15,63.34 v3(139.53,63.72) ; U80.AM55 v3(134.98,62.44) ; U80.U67 141.22,55.13 ; 141.22,55.13 U80.U66 ; 141.22,55.13 v3(141.22,55.13) ; U80.V17 113.16,55.2 113.38,55.2 U80.V18 ; U80.N13 110.8,52.78 v3(110.43,53.14) 110.43,53.28 110.8,53.64 U80.R13 ; 143.17,55.13 v3(143.17,55.13) ; 143.17,55.13 U80.U70 ; 143.17,55.13 U80.U69 ; v3(126.85,89.42) 126.85,89.41 USM2002.E5 ; v3(119.42,62.52) 119.42,62.48 U80.AM27 ; U80.E46 130.38,48.93 v3(130.41,48.93) v3(130.41,48.28) 130.47,48.22 U80.D47 ; U80.AF10 108.47,58.71 v1(108.47,58.52) ; USM2000.J4 168.9,76.83 v3(168.9,76.84) ; U80.AU20 114.56,65.29 v3(114.85,65) 114.77,65 U80.AT20 ; v3(157.2,80.99) 156.88,81.31 USM2001.T12 ; U80.AN40 v3(126.75,63.09) 126.82,63.09 U80.AN42 ; USM2001.N6 155.25,86.46 v3(155.25,86.48) ; v3(125.55,88.62) 125.55,88.61 USM2002.C6 ; v3(170.85,76.04) 170.85,76.03 USM2000.M5 ; v3(113.96,89.42) 113.96,89.41 USM2003.N5 ; USM2002.B6 124.9,88.61 v3(124.9,88.62) ; v3(139.93,56.98) 139.93,56.98 140.25,56.54 U80.AA65 ; v3(152.65,87.28) 152.65,87.42 USM2001.J4 ; USM2003.N4 113.96,90.21 v3(113.96,90.22) ; v3(173.45,76.04) 173.45,76.03 USM2000.T5 ; U80.B66 v3(141.06,47.26) U80.D66 ; U80.B30 v3(121.23,47.26) U80.D30 121.21,47.8 121.21,48.82 v3(121.27,48.88) 121.45,48.88 U80.F32 ; USM2002.G8 v3(128.8,86.36) ; v3(115.22,60.02) 114.9,59.69 U80.AG20 114.85,59.65 114.29,59.65 U80.AG19 114.25,59.68 v3(113.91,60.02) ; v3(115.22,60.02) 114.9,60.35 U80.AJ20 115.22,60.77 v3(115.22,60.86) ; U80.N19 114.25,53.03 v3(114.58,53.36) 114.76,53.54 114.76,53.6 U80.P20 ; U80.AB18 113.17,57.51 112.71,57.51 ; v3(131.39,86.36) 131.39,86.21 USM2002.L9 ; USM2001.R6 156.55,86.46 v3(156.55,86.48) ; USM2002.T5 134.64,89.41 v3(134.64,89.42) ; v3(134.64,90.22) 134.64,90.21 USM2002.T4 ; v3(153.95,86.48) 153.95,86.46 USM2001.L6 ; v3(136.81,49.55) U80.G58 ; U80.C1 103.44,46.67 v3(103.03,46.67) ; v3(116.69,49.55) 116.44,49.8 U80.G22 ; v3(116.69,49.55) 116.3,49.15 U80.F22 ; JCP4038.A1 7.9,63.25 v1(8.4,62.75) ; 141.88,57.99 141.88,58.01 U80.AE68 142.36,58.17 142.36,58.01 v3(142.48,57.88) 142.85,58.25 U80.AE69 ; 141.88,57.99 U80.AE67 ; 141.88,57.99 v3(141.88,57.88) ; v3(116.55,51.1) 116.24,50.79 U80.K22 ; U80.AL66 141.11,62.15 U80.AM68 ; J8L1.8 39.9,61.43 40.07,61.6 40.45,61.6 40.84,61.98 v1(41.19,61.98) 41.19,61.63 41.4,61.42 J8L1.11 ; U80.F27 v1(119.44,48.92) U80.F28 ; v3(126.85,88.62) 126.85,88.61 USM2002.E6 ; R1119.2 130.71,72 v3(130.52,71.81) ; v3(150.71,88.08) 150.71,88.06 USM2001.G4 ; USM2000.M6 170.53,75.01 170.85,75.33 v3(170.85,75.34) ; v3(112.12,50.19) 111.93,50.19 U80.H15 ; v3(112.12,50.19) 112.12,51.05 U80.K16 112.36,51.22 112.77,50.81 113.13,50.81 113.14,50.81 U80.H18 113.6,50.56 U80.K18 ; v3(126.64,83) 126.64,83.35 126.52,83.48 USM2002.D12 ; PU3254.D15 66.97,80.68 v4(66.94,80.71) ; R1117.2 v3(133.56,74.24) R1115.2 ; USM2002.M12 131.72,83.47 131.56,83.32 131.56,82.89 131.57,82.89 v3(131.98,82.49) ; v3(130.09,83.16) 130.09,83.2 129.8,83.49 USM2002.J12 ; v3(157.2,88.08) 157.2,88.06 USM2001.T4 ; v3(114.85,64.37) 114.41,64.02 U80.AR20 ; v1(169.21,40.22) 169.06,40.06 PU6.20 ; U80.B18 v3(113.8,47.26) U80.D18 113.8,48.2 U80.E18 ; USM2003.D3 USM2003.C3 ; 112.71,57.51 U80.AD16 112.29,58.03 112.94,58.68 U80.AF17 ; 112.71,57.51 112.71,57.5 U80.AB16 111.96,56.75 v3(111.96,56.67) 111.64,56.98 U80.AB15 110.8,57.93 U80.AD13 ; v3(126.59,41.69) 126.56,41.69 125.99,42.26 CAP1446.2 ; v1(29.08,26.53) 29.18,26.63 RCP4029.2 ; U80.AT28 v3(120.35,64.36) U80.AR28 ; U80.AP23 117.35,63.34 v3(117.61,63.09) U80.AN23 ; USM2001.T2 157.2,89.66 v3(157.2,89.68) ; v3(113.04,64.36) U80.AR16 ; USM2000.M4 170.85,76.83 v3(170.85,76.84) ; USM2003.M5 113.31,89.41 v3(113.31,89.42) ; U80.AG18 113.91,59.92 v3(113.91,60.02) ; v3(107.6,87.53) 107.6,87.07 107.79,86.88 USM2003.D8 ; U80.N6 106.52,52.97 106.55,52.97 106.59,53 v3(106.59,53.15) 106.59,53.42 U80.R6 ; v3(130.41,64.36) U80.AR46 ; v1(79.96,47.3) EUPM3247.A35 ; CAP1423.1 72.3,59.57 v1(72.44,59.43) 72.45,59.44 73,59.44 CAP1422.1 ; v3(132.67,83.13) 133.02,83.48 USM2002.P12 ; U80.AN32 122.18,63.09 v3(122.18,63.72) U80.AP32 ; USM2002.R6 133.99,88.61 v3(133.99,88.62) ; U80.D44 v3(128.67,47.26) U80.B44 ; v3(135.9,65.64) 136.07,65.82 U80.AW57 136.07,66.62 v3(136.05,66.64) 136.07,66.67 U80.BA57 ; v1(14.7,43.06) U23.3 U23.8 ; U80.AN30 120.81,62.7 v3(121.29,63.1) ; PU3254.P13 67.58,75.19 v4(67.53,75.24) ; 140.59,51.45 U80.K65 U80.K64 ; 140.59,51.45 U80.K66 ; 140.59,51.45 v3(140.59,51.42) ; v3(141.2,60.59) 141.53,60.16 U80.AH67 ; v3(150.06,86.48) 150.06,86.46 USM2001.F6 ; v3(128.27,82.15) 128.27,83.03 127.82,83.48 USM2002.F12 ; v3(109.18,55.19) 109.18,55.16 U80.U10 108.53,55.15 v3(108.53,55.21) ; v3(147.46,81.01) 147.46,81.05 147.75,81.34 USM2001.B12 ; v3(127.5,90.22) 127.5,90.21 USM2002.F4 ; v3(154.6,86.48) 154.6,86.46 USM2001.M6 ; U80.G10 108.95,49.8 109.27,49.48 v3(109.4,49.48) ; J8L1.14 42.9,61.38 43.24,61.72 v1(43.24,62.16) ; U111.3 49.09,54.63 v1(49.16,54.69) ; U80.R13 U80.T15 ; U80.R13 110.8,53.88 v3(110.41,54.27) ; v1(95.91,58.2) 95.89,58.22 95.88,58.22 95.47,58.63 R1047.1 ; USM2002.F6 127.5,88.61 v3(127.5,88.62) ; U80.AM43 128.42,62.34 128.74,62.34 U80.AM45 v3(129.5,62.44) ; USM2002.G6 128.15,88.61 v3(128.15,88.62) ; v3(113.31,88.62) 112.99,88.3 USM2003.M6 ; v3(115.91,88.62) 115.91,88.61 USM2003.T6 ; U80.AW28 v3(118.84,66.64) U80.BA28 ; v3(115.91,89.42) 115.59,89.1 USM2003.T5 ; v3(113.91,60.02) 113.6,60.33 U80.AJ18 113.6,60.44 113.78,60.62 113.78,61.09 U80.AK18 113.6,61.46 v3(113.95,61.82) ; v3(130.42,62.44) 130.41,62.44 U80.AM46 ; v1(119.44,48.27) 119.25,48.27 U80.D26 v1(118.76,47.26) ; U80.BA14 v3(111.5,66.79) U80.AW14 ; U80.AH13 110.71,60.28 v3(110.44,60.62) 109.98,60.62 U80.AK11 109.5,61.24 109.79,61.53 110.24,61.53 U80.AM13 ; U80.AH13 110.8,59.92 111.15,59.56 111.15,59.25 U80.AF15 112.29,59.41 U80.AG16 112.29,59.71 112.61,60.02 112.94,59.68 U80.AG17 ; U80.AH13 111.37,60.16 U80.AJ15 ; U80.BA49 v3(131.19,66.64) U80.AW49 ; USM2001.M4 154.6,88.06 v3(154.6,88.08) ; v3(125.55,89.42) 125.55,89.41 USM2002.C5 ; U80.Y19 113.92,55.92 v3(113.92,55.83) ; USM2000.K2 169.55,78.43 v3(169.55,78.44) ; v3(115.26,89.42) 115.26,89.41 USM2003.R5 ; v3(147.46,86.48) 147.46,86.46 USM2001.B6 ; U80.AB8 107.55,56.61 v3(107.37,56.43) ; USM2003.P8 114.6,86.38 v3(114.6,86.35) ; USM2003.D12 107.72,83.42 v3(107.72,83.02) ; v3(129.45,84.76) 129.45,84.79 129.15,85.09 USM2002.H10 ; U80.E50 v3(132.24,48.28) ; v3(127.67,63.72) U80.AP42 ; USM2002.P8 v3(133.01,87.23) ; U80.AF63 139.18,58.91 U80.AE64 ; v3(115.26,88.62) 115.26,88.61 USM2003.R6 ; v3(106.15,83.15) USM2003.B12 ; USM2003.G4 109.42,90.21 ; v1(63.66,82.89) 63.21,82.44 PC1317.2 ; U80.D34 v3(123.71,47.26) U80.B34 ; USM2006.A6 63.35,47.58 v1(63.58,47.81) ; v3(138.01,58.23) 138.36,57.87 U80.AD62 ; U80.AW32 v3(121.35,66.64) U80.BA32 ; U80.BA62 v3(138.55,66.64) U80.AW62 ; USM2001.L8 153.95,84.22 v3(153.95,84.21) ; U80.E71 144.52,48.19 v3(144.68,48.04) ; U80.AR45 v3(129.5,64.36) ; v3(123.1,63.09) U80.AN33 ; CRCP4042.3 CRCP4042.8 174.97,25.23 175.3,25.56 v1(175.61,25.56) ; v3(137.73,48.9) v3(137.73,49.55) U80.G60 ; USM2003.J4 111.36,90.21 v3(111.36,90.22) ; USM2006.K8 58.45,48.81 v1(58.26,48.81) ; U80.J13 110.68,51.11 v3(110.32,50.74) 109.96,51.11 U80.J11 ; v3(128.58,64.36) U80.AR43 ; v3(110.3,63.69) 110.14,63.69 U80.AR11 ; USM2001.E6 149.41,86.46 v3(149.41,86.48) ; v3(112.12,65.63) U80.AU15 ; U80.AP58 136.73,63.65 v3(136.79,63.65) ; U80.D53 v3(133.62,47.26) U80.B53 ; USM2000.R4 172.8,76.83 v3(172.8,76.84) 173.13,76.51 USM2000.T4 ; U80.AW18 v3(113.92,66.83) U80.BA18 ; U80.AN28 120.35,63.09 v3(120.35,63.72) U80.AP28 ; 115.9,53.73 U80.P21 ; v3(111.24,82.81) 111.24,83.28 USM2003.J12 ; USM2000.N6 171.5,75.23 v3(171.5,75.24) ; USM2002.L8 131.07,87.04 v3(130.89,87.21) ; U80.L11 109.5,51.89 v3(109.22,52.16) ; v1(77.67,83.07) 77.54,82.94 PC9111.2 ; USM2002.R4 133.99,90.21 v3(133.99,90.22) ; v3(157.2,88.88) 157.2,88.86 USM2001.T3 ; USM2002.T6 134.64,88.61 v3(134.64,88.62) ; v1(84.64,34.82) 84.46,35 EUPM3247.A5 ; U80.AA2 104.97,56.58 v3(104.98,56.6) 104.99,56.58 U80.AA4 ; v1(93.74,69.9) 93.96,70.13 RAP1054.2 ; v3(133.15,49.55) U80.G52 ; U80.AR23 v3(117.61,64.36) U80.AT23 ; U80.AK68 v3(142.68,60.75) U80.AK69 ; USM2003.E4 108.12,90.21 ; v3(112.63,86.28) 112.63,86.38 112.34,86.67 USM2003.L8 ; v3(139.55,63.09) 139.49,63.09 U80.AN63 ; v1(56.6,60.83) 56.47,60.7 J8L1.40 ; v3(135.9,64.99) U80.AT56 135.74,64.34 v3(135.9,64.34) ; USM2003.T4 115.91,90.21 v3(115.91,90.22) ; U80.AN20 114.41,62.73 114.85,63.11 v3(114.85,63.73) 114.41,63.37 U80.AP20 ; U80.Y20 U80.Y21 115.55,56.34 v3(115.87,56.67) 115.55,56.99 U80.AB21 U80.AD21 115.87,58.25 v3(115.87,58.34) ; v3(113.96,88.62) 113.96,88.61 USM2003.N6 ; U80.BA36 v3(123.83,66.64) U80.AW36 ; U80.AV71 U80.AV70 U80.AV69 v3(142.34,66) U80.AV68 141.86,65.84 141.42,66.26 v3(141.38,66.26) ; U80.K63 U80.K64 ; U80.D14 v3(111.32,47.26) U80.B14 ; USM2001.E5 149.41,87.26 v3(149.41,87.28) ; USM2000.T6 173.13,74.91 v3(172.8,75.24) 172.8,75.23 USM2000.R6 ; U80.AN35 v3(124.01,63.09) ; U80.BA41 v3(126.3,66.64) U80.AW41 ; v3(133.15,64.36) U80.AR52 v3(132.24,64.36) U80.AR50 ; 116.49,53.29 116.49,53.15 115.8,52.45 115.24,52.45 114.9,52.11 U80.L20 ; USM2003.P12 114.29,83.09 v3(114.35,83.03) ; USM2000.P3 172.15,77.63 v3(172.15,77.64) ; RAP1325.1 148.21,68.89 v1(147.89,68.57) ; U80.E53 v3(134.07,48.28) ; U80.F1 103.11,48.63 v3(103.08,48.6) ; U80.E56 v3(135.9,48.28) ; USM2003.F4 108.77,90.21 ; U80.AR8 108.07,63.99 v3(108.41,63.66) 108.72,63.34 U80.AP10 ; USM2002.G9 v3(128.8,85.56) ; U80.AT2 104.8,64.54 104.81,64.54 v3(104.98,64.54) 105.15,64.54 105.16,64.54 U80.AT4 ; U80.W9 108.54,56.23 v3(108.54,56.43) ; v3(125.84,63.72) U80.AP38 ; U80.AA68 v3(141.87,56.96) ; USM2003.L9 112.34,85.87 v3(112.66,85.55) ; v3(155.25,87.28) 155.25,87.26 USM2001.N5 ; v3(157.2,86.48) 157.2,86.46 USM2001.T6 ; USM2002.E4 126.85,90.21 v3(126.85,90.22) ; v3(113.27,53.37) U80.P17 ; v3(133.99,89.42) 133.99,89.41 USM2002.R5 ; USM2001.R5 156.55,87.26 v3(156.55,87.28) ; U80.L2 104.8,51.28 v3(104.98,51.46) 105.16,51.28 U80.L4 ; U80.AL35 v3(123.1,60.88) ; PU3254.H9 69.92,78.24 v4(69.92,78.67) 69.92,79.13 PU3254.F9 ; v3(112.12,64.36) U80.AR15 ; v1(125.05,45.03) 125.05,43.73 124.64,43.32 124.64,42.14 125.27,41.5 125.27,39.8 125.6,39.48 125.6,37.95 C186.1 125.86,37.03 v3(125.86,35.89) 125.86,34.29 125.59,34.01 123.53,34.01 122.85,33.33 122.36,33.33 121.52,34.17 121.52,37.23 121.61,37.32 121.93,37.32 C187.1 ; v3(150.06,87.28) 150.06,87.26 USM2001.F5 ; v1(7.77,69.76) 7.93,69.59 7.93,68.89 7.79,68.75 JCP4038.A12 ; USM2001.K10 153.3,82.62 v3(153.3,82.61) ; USM2002.T3 134.64,91.01 v3(134.64,91.02) ; U80.AP68 v3(142.48,63.43) U80.AP70 ; v3(140.67,48.93) 140.67,49.23 U80.G66 ; U80.A70 143.86,45.96 U80.B71 144.46,45.93 v3(144.6,45.93) ; v3(141.9,53.28) 141.9,53.14 U80.N68 ; USM2002.F5 127.5,89.41 v3(127.5,89.42) ; v3(155.9,88.88) 155.9,88.86 USM2001.P3 ; v3(110.72,84.75) USM2003.H10 ; USM2003.L6 112.66,88.61 v3(112.66,88.62) ; U80.AM8 107.89,61.92 v3(107.89,61.55) 107.55,61.2 U80.AK8 ; v3(125.85,65.63) U80.AU38 ; PC1325.1 63.07,79.35 62.53,79.89 v1(62.53,79.89) ; U80.AN58 v3(136.81,63.09) ; v3(147.46,87.28) 147.46,87.26 USM2001.B5 ; v1(106.6,64.37) 106.22,63.99 U80.AR5 ; USM2001.M12 154.29,81.33 154.29,80.83 v3(154.29,80.82) ; U80.E6 106.53,49.06 106.53,49.3 106.53,49.3 v3(106.53,49.51) 106.23,49.8 U80.G5 ; v3(148.11,86.48) 148.11,86.46 USM2001.C6 ; v3(134.98,49.55) U80.G55 ; RCP4162.1 22.06,57.58 v1(22.06,56.79) ; v3(128.78,66.64) U80.BA45 ; v3(122.18,65.64) U80.AU32 ; v3(140.67,48.28) U80.E65 ; U80.AM25 v3(118.52,62.44)
  BOTTOM w0.279: CN8.51 v1(186.07,16.95) ; CN8.39 v1(186.12,19.95) ; CN8.18 195.81,25.2 ; CN8.45 v1(186,18.45) ; CN8.33 v1(186.07,21.45) ; CN8.57 v1(188.56,15.45) ; CN8.75 188.61,10.95 ; v5(77.79,76.79) 77.79,76.37 77.31,75.89 77.31,74.94 75.27,72.9 73.12,72.9 71.97,74.05 PU3254.T5 ; CN8.69 v1(188.56,12.45) ; CN8.63 188.23,13.95 v1(188.55,14.27) ; CN8.7 188.62,27.95 ; CN8.1 188.48,29.45
  BOTTOM w0.305: v1(53.12,61.99) 52.9,61.77 J8L1.34 ; v1(190.43,41.6) 190.44,41.6 PC2.1 ; v1(227.65,14.95) CN2.29 ; v1(152.06,41.31) 152.34,41.03 RAP1327.2 ; PR163.1 160.44,34.62 v1(160.52,34.7) ; 188.48,29.45 188.61,29.32 v1(188.61,28.66) ; v1(189.17,12.45) 189.17,11.51 188.61,10.95 ; RAP1332.2 v1(148.23,45.88) ; RAP1336.2 146.95,48.96 v1(146.86,49.06) ; EUCP4040.14 v1(28.51,33.43) ; v1(124.42,20.39) 124.3,20.51 124.3,21.6 JCP4056.27 ; U123.4 84.66,26.33 84.27,26.73 v1(84.27,28.36) ; U80.AE66 140.9,58.17 v3(140.59,57.86) ; CN2.17 225.66,20.95 v1(225.49,20.78) ; v1(176.7,23.27) 176.25,22.82 CN3.4 ; U80.AL64 139.58,61.95 139.58,62.48 v3(139.56,62.5) ; v1(199.69,42.82) 199.62,42.75 PC9120.1 ; PU3254.A5 71.97,82.51 74.41,84.96 v1(74.41,85.17) ; PC9116.2 199.69,41.19 v1(200.05,41.55) ; v1(196.11,23.81) 196.11,24.9 195.81,25.2 ; RAP1333.2 v1(150.81,41.31) ; v1(227.6,23.95) CN2.11 ; RAP1330.2 148.13,43.06 v1(148.25,42.93) ; 67.66,69.81 68.37,70.52 68.37,74.09 PU3254.T12 ; U80.AE65 140.25,58.23 v3(139.91,57.89) ; 63.37,87.69 64.61,86.44 64.61,85.61 64.72,85.5 66.78,83.45 67.94,83.45 68.47,82.91 PU3254.A12 ; v1(227.63,19.45) CN2.20 ; RAP1337.2 148.67,47.43 148.23,46.98 v1(148.23,46.9) RAP1335.2 ; v3(104.14,85.39) 104.11,85.42 PC1150.1 102.85,85.4 CAP14493.1 ; C187.1 122.23,38.61 122.93,39.3 122.93,41.44 123.13,41.65 123.13,44.3 123.39,44.56 v3(123.71,44.56) ; U80.D25 118.08,47.81 v1(118.51,48.24) ; J8L1.37 v1(54.4,62.09) ; 188.62,27.95 v1(188.66,28) ; v1(227.65,16.45) CN2.26 ; v1(227.63,17.95) CN2.23 ; v1(65.97,77.75) 66.03,77.69 PU3254.J16 PU3254.J15 ; RAP1328.2 v1(148.3,44.1) ; RAP1331.2 v1(148.3,44.86)
  BOTTOM w0.381: v1(103.34,78.19) 103.34,77.1 103.83,76.61 C291.2 ; C952.2 v1(180.94,66.96) ; CAP1079.1 99.91,78.9 99.58,78.57 99.58,78.36 v1(99.55,78.34) 99.55,78.2 99.87,77.88 CAP1073.1 ; v1(107.26,76) 107.26,76.27 C289.2 ; C1110.2 54.22,56.95 54.22,57.97 v1(54.45,58.2) ; PC1281.1 192.17,34.28 192.63,33.81 192.63,33.54 v1(192.66,33.52) 191.99,33.52 PC9091.1 ; C783.2 v1(45.81,59.35) ; C8L17.2 24.87,67.66 24.25,67.04 v1(24.25,66.94) ; v3(116.19,54.25) 115.87,54.25 U80.T21 ; CSM2160.1 62.35,57.42 CSM2159.1 62.77,57.84 v1(62.91,57.84) ; v1(36.16,56.68) 35.79,56.68 C8L9.2 35.92,57.31 v1(36.16,57.31) 36.41,57.31 36.42,57.3 C1142.1 ; X5.4 v1(122.56,33.82) ; R679.1 15.45,49.34 v1(15.16,49.64) ; UCP4007.5 83.57,17.59 83.2,17.23 v1(83.2,16.91) ; C131.2 v1(184.88,66.96) C130.2 ; v1(47.13,57.08) 46.96,57.26 R619.1 ; v1(26.92,19.72) 27.15,19.96 CCP4216.2 ; v1(79.93,48.09) 79.86,48.16 CPM3436.1 ; 20.82,50.68 20.46,50.68 20.03,51.12 D21.2 18.7,51.12 C153.2 17.99,51.15 v1(17.8,50.96) ; 20.82,50.68 v1(20.85,50.68) ; 20.82,50.68 21.3,50.2 Q10.2 ; R6009.1 147.02,38.89 v1(146.58,39.33) ; v1(184.96,67.62) 185.44,68.11 C132.1 ; R1056.1 96.82,55.51 v3(96.82,55.94) ; CN17.1 107.21,11.62 108.02,12.43 v1(108.02,13.24) ; v3(136,38.85) 136.23,38.85 136.62,38.46 CAP1213.1 ; PU1.2 v1(181.86,74.46) ; v1(51.5,46.08) 51.16,45.74 CSM2158.1 CSM2157.1 ; v1(72.05,41.09) 72.28,41.32 RPM3431.2 ; R529.2 15.29,52.24 v1(16.07,53.02) ; C1136.2 70.91,53.68 v1(71.32,53.27) ; v1(72,43.49) D51.2 ; C8L3.1 41.61,57.32 v1(41.43,57.14) ; v1(14.6,47) 14.88,47.28 C1104.1 ; v1(15.12,58.3) 15.84,59.01 RCP4184.1 ; v1(31.26,58.65) 31.26,57.78 C8L11.2 31.87,57.71 v1(31.87,58.65) ; v1(12.9,53.25) 12.95,53.2 R979.2 ; U80.N10 109.19,53.03 v3(109.19,53.17) ; v1(16.4,60.89) 16.45,60.84 16.45,60.19 RCP4186.1 ; v3(121.46,90.2) 121.46,90.19 CSM2098.2 ; CSM2030.2 161.19,76.21 v1(161.22,76.24) ; v1(107.94,43.14) 107.45,42.64 106.79,42.64 106.26,42.11 CAP1297.2 ; v1(91.18,55.56) 91.05,55.56 C1C7.2 ; CN4.2 v1(186.38,63.28) ; v1(56.41,28.96) 55.89,29.48 PC9122.1 ; R6008.1 v1(93.83,90.85) ; R5150.2 108.57,76.99 108.57,77 v1(108.81,77.24) ; C1109.1 96.04,77.81 v1(96.11,77.88) ; v1(163.42,21.09) 163.42,21.49 163.03,21.87 C785.2 ; v1(50.79,32.11) 50.92,32.24 50.92,32.76 C8L15.2 C8L16.2 ; C8L7.2 35.54,58.53 35.55,58.55 v1(35.55,58.81) ; v1(93.46,53.17) 93.46,53.35 CAP1287.2 ; PU1.4 v1(184.88,75.4) ; PC27.2 40.14,22.76 v1(40.51,23.12) ; C67.2 v1(51.14,56.04) ; v1(141.95,39.4) 141.95,39.15 142.55,38.55 RAP1323.2 ; C1137.2 71.34,44.98 v1(71.34,45.12) ; X5.2 125.31,36.44 v3(125.86,35.89) ; C72.2 45.26,56.56 v1(45.29,56.53) ; v1(110.18,35.72) 109.59,35.72 109.2,35.33 CAP1306.1
  BOTTOM w0.508: SW1.6 112.34,14.38 v1(112.36,14.41) ; CAP1279.2 92.66,74.22 v1(92.3,73.86) ; v1(85.26,31.32) 85.52,31.32 QPM3371.1 ; JCP4056.31 147.08,20.2 v1(146.47,20.81) ; v1(99.02,60.13) 98.97,60.18 CAP1267.2 ; C1116.1 74.13,36.2 v1(74.67,35.67) ; CPM3439.1 84.64,32.54 v1(84.77,32.67) ; v1(173.37,83.81) CSM2031.2 ; v1(118.66,22) 118.85,21.82 JCP4056.32 ; C1026.2 v1(89.27,24.29) 89.27,24.53 C1025.2 ; v1(98.99,56.83) 99.09,56.93 CAP1311.2 ; v1(92.83,55.01) 92.96,54.88 93.59,54.88 C2.1 ; CPM3438.1 76.03,36.22 76.04,36.23 v1(76.09,36.23) ; HOLE4.1 HOLE4.6 ; v1(78.25,32.77) 78.07,32.6 R3594.2 ; CAP1255.1 90.75,51.59 v1(90.87,51.47) ; PC46.2 v1(186.16,72.92) ; RAP3041.1 74.52,34.31 v1(74.39,34.45) ; 18.51,15.91 17.57,15.91 v1(17.42,16.06) ; v1(71.93,32.7) 72.08,32.85 73.12,32.85 ; QPM3373.1 77.93,29.44 v1(77.38,28.89) ; C1024.2 87.5,23.27 v1(87.77,23.55) ; v1(17.16,10.42) 17.72,10.42 18,10.14 Q114.1 ; CAP1296.2 94.81,57.63 95.2,57.24 v3(95.2,56.98) 95.2,56.81 95.43,56.58 RAP1050.2 ; v1(81.58,33) 81.5,32.92 R3593.2 ; CAP1262.2 99.41,51.16 v1(98.93,50.68) ; SW1.5 v1(117.54,14.38) ; PC1279.2 v1(97.35,87.28) ; CPM3428.1 92.62,42.83 v1(92.65,42.86) ; SW1.3 111.93,12.42 v1(111.63,12.73) ; v1(92.12,32.8) UPM3253.4 ; EC2.2 171.68,27.35 v1(172.18,27.85) ; v1(95.72,16.64) 95.48,16.88 CCP4089.2 ; v1(190.04,9.85) CN8.77 v1(186.35,9.85) ; v1(82.9,50.37) 83.41,49.86 CPM3432.1 ; R6002.1 97.27,81.99 v1(97.55,82.28) ; v1(53.09,88.6) 53.54,88.15 PC1205.2 ; 68.29,35.59 v1(68.29,36.64) ; v1(81.3,55.34) 81.3,54.73 80.97,54.39 UAP1012.4 ; Q112.1 18.51,12.1 v1(19.17,12.76) ; HOLE43.1 11.73,85.15 ; QPM3374.1 v1(72.74,28.5) ; QPM3391.1 v1(96.49,38.56)
  vias: v1(8.96,64.35) v1(9.24,72.04) v1(9.77,65.57) v1(11.75,47.28) v1(12.54,45.47) v1(13.86,79.76) v1(14.93,14.05) v1(14.93,13.42) v1(14.93,12.76) v1(15.28,69.22) v1(15.46,72.04) v1(15.46,70.52) v1(16.43,37.04) v1(16.4,36.41) v1(16.98,36.76) v1(16.98,36.1) v1(17.37,57.03) v1(17.34,54.57) v1(17.44,67.01) v1(17.62,30.01) v1(17.62,29.24) v1(17.98,54.57) v1(18,57.03) v1(18.66,57.03) v1(18.61,54.57) v1(18.79,41.05) v1(18.86,62.14) v1(19.45,67.04) v1(19.8,29.4) v1(19.8,27.62) v1(19.91,8.19) v1(20.13,67.04) v1(20.34,9.2) v1(20.52,8.54) v1(20.69,36.13) v1(20.69,35.52) v1(20.92,68.87) v1(20.92,67.85) v1(21.15,8.87) v1(21.43,64.68) v1(21.43,62.77) v1(21.43,60.87) v1(21.73,60.1) v1(21.81,16.42) v1(21.81,15.02) v1(21.81,13.62) v1(21.94,68.87) v1(21.94,67.85) v1(22.09,31.88) v1(22.57,64.68) v1(22.57,62.77) v1(22.57,60.87) v1(22.95,68.87) v1(22.95,67.85) v1(22.96,18.58) v1(23.21,16.42) v1(23.21,15.02) v1(23.21,13.62) v1(23.61,11.44) v1(24.27,10.19) v1(24.6,16.42) v1(24.6,15.02) v1(24.6,13.62) v1(25.3,65.56) v1(25.34,64.12) v1(25.57,47.38) v1(25.62,11.97) v1(26,62.92) v1(26.54,43.42) v1(26.64,53.6) v1(26.89,71.79) v1(27.53,71.79) v1(27.68,61.02) v1(28.16,31.4) v1(28.16,30.39) v1(28.76,30.89) v1(28.97,61.86) v1(29.13,58) v1(29.3,31.4) v1(29.3,30.39) v1(29.74,43.92) v1(30.19,59.82) v1(30.32,71.48) v1(30.45,41.44) v1(30.45,35.52) v1(30.95,71.48) v1(31.59,64.93) v1(31.59,52.1) v1(31.59,49.56) v1(31.59,47.02) v1(31.59,37.75) v1(31.79,30.67) v1(31.84,64.04) v1(31.84,63.41) v1(31.84,62.77) v1(32.07,38.13) v1(32.1,33.43) v1(32.1,32.8) v1(32.1,10.7) v1(32.1,9.81) v1(32.22,40.8) v1(32.38,20.78) v1(32.48,68.16) v1(32.48,38.58) v1(32.48,24.16) v1(32.48,11.62) v1(32.73,12.61) v1(32.86,20.3) v1(33.06,24.9) v1(33.11,68.16) v1(33.37,12.61) v1(33.37,11.59) v1(33.49,39.43) v1(33.7,17.1) v1(33.7,16.37) v1(33.98,39.91) v1(34.13,52.1) v1(34.13,49.56) v1(34.13,47.02) v1(34.21,13.04) v1(34.21,12.35) v1(34.38,11.59) v1(34.38,9.91) v1(34.64,15.65) v1(34.89,71.41) v1(35.53,71.41) v1(35.53,11.59) v1(35.65,68.49) v1(36.16,71.41) v1(36.16,10.57) v1(36.16,9.81) v1(36.29,68.49) v1(36.39,11.54) v1(36.67,52.1) v1(36.67,49.56) v1(36.67,47.02) v1(36.8,71.41) v1(36.92,68.49) v1(37.18,70.21) v1(37.36,11.54) v1(37.43,28.48) v1(37.69,68.49) v1(37.66,53.73) v1(38.07,28.48) v1(38.32,68.49) v1(38.45,53.86) v1(38.57,30.51) v1(38.57,29.88) v1(38.57,29.12) v1(38.57,27.97) v1(38.57,17.94) v1(38.63,27.34) v1(38.96,68.49) v1(38.96,17.43) v1(39.28,28.43) v1(39.26,16.09) v1(39.34,18.02) v1(40.01,28.43) v1(42,20.81) v1(42.05,20.15) v1(42.08,19.51) v1(43.13,25.12) v1(43.12,23.94) v1(43.45,57.92) v1(43.62,24.5) v1(44.04,25.13) v1(44.05,23.88) v1(44.47,24.51) v1(44.89,23.89) v1(44.91,25.13) v1(45.25,24.51) v1(46.11,29.15) v1(46.12,28.54) v1(47.36,59.35) v1(49,27.14) v1(49.02,26.08) v1(49,25.18) v1(49.73,24.54) v1(50.02,27.14) v1(50.03,26.08) v1(50.02,25.18) v1(50.82,53.88) v1(50.98,27.14) v1(51,26.09) v1(50.98,25.19) v1(51.98,15.79) v1(51.91,14.58) v1(52.01,65.29) v1(52.11,17.18) v1(52.4,15.16) v1(52.8,14.57) v1(52.8,15.77) v1(52.98,97.95) v1(53.27,15.19) v1(53.53,38.08) v1(53.7,73.17) v1(53.69,64.73) v1(53.65,15.8) v1(53.68,14.57) v1(54.07,15.19) v1(54.32,73.16) v1(54.95,15.19) v1(55.1,25.17) v1(55.21,38.46) v1(55.64,66.63) v1(55.67,56.83) v1(55.85,50.71) v1(55.82,49.44) v1(56.28,66.68) v1(56.66,84.69) v1(57.37,57.77) v1(57.42,59.27) v1(57.41,56.26) v1(57.84,84.7) v1(58.92,59.29) v1(58.92,57.77) v1(58.92,56.29) v1(59.3,84.73) v1(60.46,59.3) v1(60.42,57.77) v1(60.41,56.28) v1(61.75,69.61) v1(62.45,69.6) v1(63.09,93.38) v1(63.54,67.9) v1(63.64,68.94) v1(64,69.61) v1(64.13,22.84) v1(64.25,67.9) v1(64.48,22.31) v1(64.99,68.99) v1(65.35,52.81) v1(65.63,46.54) v1(65.88,45.4) v1(65.93,42.67) v1(66.03,96.57) v1(67,96.27) v1(67.65,96.58) v1(69.17,96.58) v1(70.71,96.58) v1(71.27,69.53) v1(71.27,68.92) v1(71.3,68.26) v1(71.3,67.62) v1(71.26,66.91) v1(71.95,69.48) v1(72.24,96.58) v1(73.78,96.55) v1(74.81,89.07) v1(74.81,88.16) v1(75.38,96.55) v1(76.04,14.21) v1(76.85,14.21) v1(76.98,96.55) v1(77.51,89.82) v1(77.56,88.47) v1(77.82,64.5) v1(78.56,96.55) v1(78.96,51.6) v1(78.96,50.71) v1(79.34,71.81) v1(79.34,71.18) v1(79.99,89.69) v1(80.74,43.21) v1(80.74,41.18) v1(80.74,40.04) v1(80.74,38.9) v1(80.84,76.72) v1(80.97,71.46) v1(80.99,70.85) v1(81.27,39.48) v1(81.67,78.4) v1(81.72,89.7) v1(81.75,43.21) v1(81.75,42.2) v1(81.75,41.18) v1(81.75,40.04) v1(81.75,38.9) v1(82.06,76.69) v1(82.29,65.08) v1(82.31,78.4) v1(82.9,43.21) v1(82.9,42.2) v1(82.9,41.18) v1(82.9,40.04) v1(82.9,38.9) v1(82.81,30.7) v1(83.25,30.26) v1(83.43,89.71) v1(83.79,62.67) v1(83.91,43.21) v1(83.91,42.2) v1(83.91,41.18) v1(83.91,40.04) v1(83.91,38.9) v1(84.24,63.08) v1(84.93,43.21) v1(84.93,42.2) v1(84.93,41.18) v1(84.93,40.04) v1(84.93,38.9) v1(85.54,89.92) v1(86.15,89.92) v1(86.83,89.92) v1(86.83,84.87) v1(86.83,84.23) v1(87.27,8.95) v1(87.5,89.59) v1(87.47,84.87) v1(87.47,84.23) v1(90.71,40.68) v1(92.82,41.26) v1(92.97,40.47) v1(98.04,35.62) v1(98.57,36.02) v1(98.85,75.45) v1(98.85,52.87) v1(98.93,76.26) v1(99.46,52.87) v1(99.61,34.35) v1(99.92,33.28) v1(99.94,32.67) v1(103.4,93.63) v1(103.37,92.87) v1(104.11,35.21) v1(104.46,34.45) v1(105.1,34.45) v1(105.5,78.39) v1(105.5,77.63) v1(105.55,75.09) v1(108.25,36.18) v1(108.37,38.21) v1(110.38,37.7) v1(110.41,41.54) v1(111.09,75.16) v1(111.14,29.75) v1(111.32,31.4) v1(112.39,32.7) v1(112.44,29.73) v1(112.94,36.58) v1(114.35,32.14) v1(114.95,33.74) v1(115.02,43.1) v1(115.02,41.02) v1(115.36,30.89) v1(116.12,32.52) v1(118.14,90.4) v1(118.24,14.87) v1(118.54,52.56) v1(120.06,38.51) v1(120.38,34.64) v1(120.41,54.92) v1(120.77,37.22) v1(122.28,32.76) v1(122.26,32.05) v1(122.8,32.42) v1(123.18,32.93) v1(126.08,27.67) v1(126.41,39.66) v1(127.04,39.66) v1(127.68,39.43) v1(127.6,27.67) v1(128.69,38.06) v1(129.13,27.67) v1(129.38,54.72) v1(129.32,37.84) v1(130.65,27.67) v1(130.9,54.67) v1(130.9,54.06) v1(131.62,58.1) v1(131.62,57.49) v1(132.17,27.67) v1(132.43,54.74) v1(132.43,54.14) v1(132.55,41.05) v1(132.55,40.37) v1(133.57,40.59) v1(133.7,27.67) v1(133.95,54.69) v1(133.95,54.08) v1(134.65,41.78) v1(135.48,54.69) v1(135.48,54.08) v1(137.03,54.57) v1(137.81,60.74) v1(137.93,59.89) v1(138.3,30.51) v1(138.98,30.51) v1(139.54,97.42) v1(139.64,30.51) v1(140.3,30.54) v1(142.17,86.03) v1(148.79,14.71) v1(153.89,56.34) v1(153.92,55.74) v1(155.14,56.37) v1(155.16,55.76) v1(155.77,97.01) v1(156.46,56.37) v1(156.48,55.76) v1(157.32,56.07) v1(157.93,56.37) v1(158.33,32.92) v1(159.1,32.89) v1(159.22,56.8) v1(159.22,56.17) v1(159.83,57.61) v1(159.94,32.89) v1(160.37,56.5) v1(160.44,57.82) v1(161.05,57.82) v1(161.66,57.82) v1(162.28,32.26) v1(163.79,60.47) v1(164.15,32.09) v1(165.12,58.22) v1(165.14,32.1) v1(165.69,35.56) v1(165.8,58.22) v1(166.15,32.11) v1(166.46,58.22) v1(166.4,35.56) v1(167.1,58.25) v1(167.38,37.53) v1(167.38,36.18) v1(167.46,38.46) v1(167.48,13.42) v1(167.76,58.22) v1(168.19,35.42) v1(168.14,18.91) v1(168.25,37.5) v1(168.35,38.32) v1(168.34,36.21) v1(168.45,58.22) v1(168.75,18.93) v1(169.08,58.22) v1(169.2,38.2) v1(169.18,37.56) v1(169.74,58.22) v1(169.82,38.2) v1(169.83,37.55) v1(170.35,58.22) v1(170.99,58.22) v1(172.52,37.5) v1(173.22,37.5) v1(173.71,42.87) v1(173.93,61.53) v1(173.91,60.82) v1(173.93,60.18) v1(174.03,43.85) v1(174.36,89.72) v1(174.69,62.21) v1(174.69,61.53) v1(174.62,42.88) v1(174.72,60.87) v1(174.74,60.18) v1(175.13,89.72) v1(175.43,62.29) v1(175.43,61.53) v1(175.46,60.87) v1(175.48,60.18) v1(176.33,43.19) v1(176.31,42.26) v1(176.64,29.22) v1(177.16,81.29) v1(177.18,24.39) v1(177.25,29.22) v1(177.47,43.21) v1(177.5,42.29) v1(177.6,40.76) v1(177.51,23.27) v1(177.61,41.4) v1(177.8,81.32) v1(177.86,29.22) v1(178.15,23.27) v1(178.23,41.4) v1(178.24,40.76) v1(178.34,42.17) v1(178.42,43.14) v1(178.43,36.98) v1(178.47,29.19) v1(179.09,36.98) v1(179.08,29.19) v1(179.69,29.19) v1(180.09,19.28) v1(180.09,18.67) v1(181.96,29.34) v1(182.36,29.8) v1(183.2,97.11) v1(184.25,43.21) v1(185.04,42.27) v1(185.02,41.39) v1(185.29,30.71) v1(185.29,30.1) v1(186.24,41.37) v1(186.35,42.28) v1(186.46,40.48) v1(186.46,39.85) v1(187.09,42.93) v1(187.2,41.3) v1(187.12,40.48) v1(187.13,39.85) v1(187.36,42.26) v1(189.2,63.53) v1(189.68,64.14) v1(189.86,63.53) v1(190.54,63.51) v1(191.52,39.51) v1(192.27,23.35) v1(192.32,21.8) v1(193.69,21.45) v1(193.7,20.81) v1(193.73,20.15) v1(193.73,19.51) v1(193.75,13.88) v1(193.75,13.16) v1(193.75,12.5) v1(194.66,37.05) v1(194.66,35.72) v1(194.71,38.34) v1(196,38.36) v1(196,37.05) v1(196,35.8) v1(197.35,38.39) v1(197.43,37.05) v1(197.4,35.65) v1(198.75,52.23) v1(198.75,51.52) v1(198.77,50.81) v1(198.8,50.02) v1(199.33,51.19) v1(199.33,50.4) v1(204.54,16.52) v1(204.55,15.39) v1(204.77,28.43) v1(205.02,29.09) v1(205.11,15.95) v1(205.33,27.24) v1(205.45,28.43) v1(205.55,46.11) v1(205.67,16.51) v1(205.69,15.38) v1(207,26.83) v1(207.87,26.83) v1(208.78,26.83) v1(209.59,14.89) v1(210.13,16.37) v1(210.91,26.4) v1(211.6,26.4) v1(213.94,29.09) v1(218.31,33.69) v1(219.91,33.13) v1(222.85,15.76) v1(223.31,7.48) v1(223.59,13.37) v1(224.3,16.8) v1(224.99,18.84) v1(224.99,12.91) v1(225.21,16.24) v1(230.46,30.64) v1(230.5,12.94) v1(231.07,30.64) v1(231.16,12.94) v3(101.6,59.31) v3(102.44,71.25) v3(104.9,83.52) v3(106.42,92.75) v3(106.62,72.42) v3(107.66,70.42) v3(109.73,73.71) v3(113.68,92.35) v3(114.43,78.3) v3(114.49,76.5) v3(117.4,88.04) v3(117.61,60.85) v3(120.18,37.05) v3(120.22,36.5) v3(120.31,59.8) v3(120.32,53.13) v3(120.79,36.63) v3(120.78,36.01) v3(122.03,53.21) v3(122.3,58.91) v3(122.71,56.26) v3(123.15,83.08) v3(123.44,57.92) v3(124.17,53.12) v3(125.3,58.91) v3(125.62,56.22) v3(125.61,53.06) v3(126.21,56.06) v3(126.68,92.1) v3(126.96,45.28) v3(127.09,60.64) v3(127.14,44.04) v3(127.55,70.33) v3(127.67,60.65) v3(127.99,55.5) v3(128.2,51.84) v3(128.36,73.8) v3(128.48,58.85) v3(128.58,75.65) v3(128.86,42.17) v3(129.41,75.16) v3(129.51,73.17) v3(130.06,58.09) v3(130.06,57.53) v3(130.41,49.55) v3(131.32,62.44) v3(131.85,79.15) v3(132.24,62.44) v3(133.12,95.23) v3(133.14,62.42) v3(133.18,58.03) v3(133.18,57.48) v3(133.57,38.65) v3(134.07,62.44) v3(134.26,37.93) v3(134.27,37.37) v3(134.53,76.37) v3(134.79,57.49) v3(134.82,58.07) v3(135.72,36.93) v3(136.35,57.86) v3(137.41,41.41) v3(137.55,95.17) v3(138.56,77.03) v3(138.54,72.68) v3(139.27,75.12) v3(139.51,76.21) v3(152.76,78.05) v3(155.46,90.27) v3(156.22,72.97) v3(157.59,73.25) v3(161.44,71.29) v3(161.72,69.97) v3(161.9,83.2) v3(162.72,84.69) v3(165.06,72.14) v3(165.63,71.31) v3(167.82,67.84) v5(0.98,73.06) v5(1.87,6.64) v5(2.25,73.06) v5(2.51,58.83) v5(2.51,8.16) v5(3.14,71.53) v5(3.14,6.13) v5(3.27,60.36) v5(3.52,73.06) v5(4.41,1.68) v5(4.54,71.81) v5(4.54,58.58) v5(4.54,3.21) v5(4.67,60.23) v5(4.67,6.13) v5(4.79,73.19) v5(4.92,37.75) v5(5.22,56.75) v5(5.3,39.28) v5(5.55,0.92) v5(5.94,58.83) v5(5.94,8.67) v5(5.94,5.49) v5(6.57,59.98) v5(6.57,39.28) v5(6.7,56.75) v5(7.21,37.75) v5(7.84,39.28) v5(7.92,20.45) v5(8.22,36.23) v5(9.36,38.13) v5(9.44,20.45) v5(10.13,36.74) v5(10.13,8.67) v5(10.89,20.51) v5(11.65,38.13) v5(12.54,39.66) v5(12.67,36.61) v5(12.79,20.61) v5(13.56,15.15) v5(13.56,13.88) v5(13.56,12.61) v5(13.56,11.34) v5(13.86,17.31) v5(13.96,16.21) v5(14.06,10.09) v5(16.35,0.92) v5(16.48,77.12) v5(16.98,75.85) v5(16.98,74.46) v5(17.62,73.44) v5(17.87,0.92) v5(18.76,73.19) v5(19.52,0.92) v5(20.03,73.19) v5(20.16,4.73) v5(20.16,3.21) v5(20.16,1.94) v5(20.41,6.13) v5(21.3,73.19) v5(21.3,7.02) v5(22.45,7.65) v5(22.6,73.26) v5(23.87,73.26) v5(23.97,7.65) v5(25.14,73.26) v5(25.49,7.65) v5(26.41,73.26) v5(27.02,7.65) v5(27.68,73.26) v5(28.54,7.65) v5(28.95,73.26) v5(30.07,7.65) v5(30.22,73.26) v5(31.49,73.26) v5(31.84,7.65) v5(32.76,73.26) v5(33.62,7.65) v5(34.03,73.26) v5(35.3,73.26) v5(35.4,7.65) v5(36.57,73.26) v5(37.3,7.65) v5(37.84,73.26) v5(38.45,8.8) v5(39.11,73.26) v5(39.46,9.81) v5(40.38,73.26) v5(40.35,10.7) v5(41.37,11.46) v5(41.65,73.26) v5(42.66,11.69) v5(42.92,73.26) v5(43.93,11.69) v5(44.16,92.24) v5(44.16,90.58) v5(44.19,73.26) v5(45.2,11.69) v5(45.43,92.24) v5(45.46,73.26) v5(46.47,11.69) v5(46.73,73.26) v5(46.96,92.24) v5(47.46,90.08) v5(47.74,11.69) v5(48,73.26) v5(48.35,92.24) v5(49.01,11.69) v5(49.27,73.26) v5(49.5,90.08) v5(49.88,92.24) v5(50.28,11.69) v5(50.39,73.69) v5(51.27,74.46) v5(51.4,92.44) v5(51.4,89.31) v5(51.55,11.69) v5(51.66,75.47) v5(51.78,88.04) v5(51.78,86.65) v5(51.78,85.25) v5(51.78,83.85) v5(51.78,82.58) v5(51.78,81.31) v5(51.78,80.17) v5(51.78,78.9) v5(51.78,77.76) v5(51.78,76.61) v5(52.29,97.44) v5(52.29,96.17) v5(52.29,94.9) v5(52.29,93.63) v5(52.82,11.69) v5(53.84,98) v5(54.09,11.69) v5(54.3,93.3) v5(54.81,94.06) v5(55.11,98) v5(55.19,93.3) v5(55.36,11.69) v5(55.69,94.06) v5(56.08,93.3) v5(56.38,98) v5(56.58,94.06) v5(56.63,11.69) v5(56.96,93.3) v5(57.47,94.06) v5(57.65,98) v5(57.85,93.3) v5(57.9,11.69) v5(58.36,94.06) v5(58.74,93.3) v5(58.92,98) v5(59.09,82.24) v5(59.04,81.09) v5(59.17,11.69) v5(59.25,94.06) v5(60.19,98) v5(60.44,11.69) v5(61.46,98) v5(61.71,11.69) v5(61.92,94.06) v5(61.92,93.33) v5(62.73,98) v5(62.7,94.78) v5(62.7,90.05) v5(62.98,11.69) v5(63.42,90.05) v5(64,98) v5(64.25,11.69) v5(64.84,69.67) v5(64.99,68.33) v5(65.27,98) v5(65.52,11.69) v5(65.63,69.77) v5(65.65,68.99) v5(66.54,98) v5(66.79,11.69) v5(67.81,98) v5(68.06,11.69) v5(69.08,98) v5(69.33,11.69) v5(69.8,18.88) v5(70.35,98) v5(70.61,18.87) v5(70.6,11.69) v5(71.42,18.85) v5(71.62,98) v5(71.87,11.69) v5(72.89,98) v5(72.99,89.71) v5(72.99,88.92) v5(73.19,18.87) v5(73.14,11.69) v5(74.02,87.37) v5(74.05,18.87) v5(74.16,98) v5(74.11,88.11) v5(74.41,11.69) v5(74.81,87.37) v5(75.43,98) v5(75.68,11.69) v5(76.7,98) v5(77.97,98) v5(79.24,98) v5(80.12,77.46) v5(80.12,76.67) v5(80.51,98) v5(81.78,98) v5(83.05,98) v5(84.32,98) v5(84.68,97.06) v5(85.69,96.43) v5(86.3,7.73) v5(86.96,96.3) v5(87.57,7.73) v5(88.36,96.3) v5(88.84,7.73) v5(89.63,96.3) v5(90.11,7.73) v5(90.9,96.3) v5(91.38,7.73) v5(92.17,96.3) v5(92.65,7.73) v5(93.31,96.3) v5(93.92,7.73) v5(94.58,96.3) v5(95.19,7.73) v5(95.85,96.43) v5(96.46,7.73) v5(96.87,97.19) v5(97.73,7.73) v5(97.88,98.05) v5(99,7.73) v5(99.15,98.05) v5(100.27,7.73) v5(100.42,98.05) v5(101.54,7.73) v5(101.69,98.05) v5(102.81,7.73) v5(102.96,98.05) v5(104.08,7.73) v5(104.23,98.05) v5(105.35,7.73) v5(105.5,98.05) v5(106.62,7.73) v5(106.77,98.05) v5(107.89,7.73) v5(108.04,98.05) v5(109.16,7.73) v5(109.31,98.05) v5(110.43,7.73) v5(110.58,98.05) v5(111.7,7.73) v5(111.85,98.05) v5(112.97,7.73) v5(113.12,98.05) v5(114.24,7.73) v5(114.39,98.05) v5(115.51,7.73) v5(115.66,98.05) v5(116.78,7.73) v5(116.93,98.05) v5(118.05,7.73) v5(118.2,98.05) v5(118.58,9.94) v5(118.58,8.8) v5(119.02,10.9) v5(119.47,98.05) v5(120.08,11.56) v5(120.74,98.05) v5(121.51,11.62) v5(122.01,98.05) v5(122.67,11.69) v5(123.28,98.05) v5(123.94,11.69) v5(124.55,98.05) v5(125.21,11.69) v5(125.82,98.05) v5(126.48,11.69) v5(127.09,98.05) v5(127.75,11.69) v5(128.36,98.05) v5(129.02,11.69) v5(129.63,98.05) v5(130.29,11.69) v5(130.9,98.05) v5(131.56,11.69) v5(132.17,98.05) v5(132.83,11.69) v5(133.44,98.05) v5(134.1,11.69) v5(134.71,98.05) v5(135.37,11.69) v5(135.98,98.05) v5(136.64,11.69) v5(137.25,98.05) v5(137.91,11.69) v5(138.52,98.05) v5(139.18,11.69) v5(140.45,11.69) v5(141.72,11.69) v5(142.99,11.69) v5(144.11,11.69) v5(145.25,11.56) v5(146.4,11.59) v5(147.79,11.64) v5(149.19,11.59) v5(150.46,11.59) v5(151.73,11.59) v5(151.93,97.05) v5(152.49,98.05) v5(153,11.59) v5(153.76,98.05) v5(154.27,11.59) v5(155.03,98.05) v5(155.54,11.59) v5(156.3,98.05) v5(156.56,11.59) v5(157.92,32.33) v5(158.68,32.31) v5(158.97,45.88) v5(158.97,45.12) v5(159.52,32.32) v5(160.41,32.34) v5(161.37,32.28) v5(163.16,32.1) v5(165.69,34.22) v5(165.97,41.82) v5(165.96,41.08) v5(165.99,40.28) v5(165.99,34.89) v5(166.34,43.72) v5(166.46,98.05) v5(166.44,39.6) v5(166.44,34.22) v5(166.66,41.5) v5(166.64,40.66) v5(166.78,34.89) v5(167.08,40.04) v5(167.1,11.59) v5(167.21,34.2) v5(167.35,43.72) v5(167.49,40.74) v5(167.55,41.52) v5(167.51,34.9) v5(167.73,98.05) v5(167.85,40.07) v5(168.27,40.95) v5(168.24,11.84) v5(168.5,13.11) v5(169,98.05) v5(169.51,14) v5(170.27,98.05) v5(170.78,14.13) v5(171.54,98.05) v5(172.05,14.13) v5(172.81,98.05) v5(173.45,14.13) v5(173.92,44.74) v5(174.08,98.05) v5(174.76,44.76) v5(174.72,14.13) v5(174.97,43.55) v5(175.35,98.05) v5(175.37,44.2) v5(175.99,14.13) v5(176.62,98.05) v5(177.13,14.13) v5(177.89,98.05) v5(178.4,14.13) v5(179.16,98.05) v5(179.54,14.13) v5(180.08,43.49) v5(180.08,42.76) v5(180.11,45.09) v5(180.37,44.31) v5(180.43,98.05) v5(180.65,42.01) v5(180.97,45.11) v5(180.93,43.49) v5(180.93,42.77) v5(180.94,14.13) v5(181.26,44.31) v5(181.37,42.01) v5(181.7,98.05) v5(181.85,45.1) v5(181.82,43.49) v5(181.82,42.77) v5(182.11,44.31) v5(182.21,13.88) v5(182.31,42.02) v5(182.68,43.49) v5(182.67,42.76) v5(182.8,98.05) v5(182.74,45.1) v5(183,44.31) v5(183.04,42.02) v5(183.1,12.99) v5(183.23,11.72) v5(183.23,10.45) v5(183.23,9.05) v5(183.33,7.78) v5(183.52,43.5) v5(183.52,42.77) v5(183.83,42.04) v5(184.04,96.48) v5(184.6,7.78) v5(185.31,96.48) v5(185.87,7.78) v5(186.58,96.48) v5(187.14,7.78) v5(187.85,96.48) v5(188.1,44.04) v5(188.1,43.25) v5(188.41,7.78) v5(188.89,43.8) v5(188.91,43.02) v5(188.94,42.21) v5(189.12,96.48) v5(189.6,43.48) v5(189.67,42.65) v5(189.65,41.84) v5(189.68,7.78) v5(190.39,96.48) v5(190.95,7.78) v5(191.66,96.48) v5(192.22,7.78) v5(193.01,95.79) v5(193.01,94.39) v5(193.24,93.02) v5(193.39,68.36) v5(193.49,7.78) v5(193.51,67.09) v5(193.77,65.95) v5(194.02,64.8) v5(194.25,92.26) v5(194.25,90.99) v5(194.25,89.72) v5(194.25,88.45) v5(194.25,87.18) v5(194.25,85.91) v5(194.25,84.64) v5(194.25,83.37) v5(194.25,82.1) v5(194.25,80.83) v5(194.25,79.56) v5(194.25,78.29) v5(194.25,77.02) v5(194.25,75.75) v5(194.25,74.48) v5(194.25,73.21) v5(194.25,71.94) v5(194.25,70.67) v5(194.45,69.48) v5(194.4,63.66) v5(194.78,62.52) v5(194.76,7.78) v5(195.17,61.25) v5(196.03,7.78) v5(196.18,60.61) v5(197.2,59.98) v5(197.3,7.78) v5(197.71,58.71) v5(198.34,57.56) v5(198.57,7.78) v5(198.85,56.55) v5(199.36,55.41) v5(199.84,7.78) v5(200.12,54.39) v5(200.75,53.25) v5(201.11,7.78) v5(201.64,52.1) v5(202.15,49.56) v5(202.38,7.78) v5(202.4,50.96) v5(202.53,48.17) v5(203.17,47.15) v5(203.65,7.78) v5(204.18,46.52) v5(204.92,7.78) v5(206.19,7.78) v5(207.46,7.78) v5(208.73,7.78) v5(210,7.78) v5(211.27,7.78) v5(212.54,7.78) v5(213.81,7.78) v5(215.08,7.78) v5(216.35,7.78) v5(217.62,7.78) v5(218.53,35.52) v5(218.89,7.78) v5(219.91,34.93) v5(220.16,7.78) v5(221.18,34.35) v5(221.43,7.78) v5(222.39,33.69) v5(222.7,7.78) v5(223.64,33.1) v5(223.97,7.78) v5(224.81,32.62) v5(225.24,7.78) v5(226.05,32.16) v5(226.51,7.78) v5(227.32,32.16) v5(227.78,7.78) v5(228.59,32.16) v5(229.05,7.78) v5(229.86,32.16) v5(230.32,7.78) v5(231.13,32.16) v5(231.59,7.78) v5(232.4,32.16) v5(232.86,7.78) v5(233.67,32.16) v5(234.28,7.73) v5(234.94,32.16) v5(235.76,31.25) v5(235.76,29.98) v5(235.76,28.71) v5(235.76,27.44) v5(235.76,26.17) v5(235.76,24.9) v5(235.76,23.63) v5(235.76,22.36) v5(235.76,21.09) v5(235.76,19.82) v5(235.76,18.55) v5(235.76,17.28) v5(235.76,16.01) v5(235.76,14.74) v5(235.76,13.47) v5(235.76,12.2) v5(235.76,10.93) v5(235.76,9.66) v5(235.76,8.39)
