# Allegro board 大･ｬ Quanta da0zhdmb8d0-d-vera-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EMMC<7>: length 10.9
  BOTTOM w0.076: USM2006.B6 62.94,47.33 63.59,47.33
  BOTTOM w0.102: 63.59,47.33 63.67,47.33 63.96,47.62 63.96,49.06 64.56,49.66 65.35,49.66 67.38,51.7 67.38,52.38 v1(67.63,52.64) 67.64,52.64 RSM2151.2 69.78,52.64 R5133.1
EMMC_3P3:
  vias: v1(59.99,48.67) v1(60.52,48.34) v1(62.11,55.76) v1(62.72,55.74)
EMMC_C2: length 4.7
  TOP w0.508: CSM2156.2 v1(61.79,44.43)
  BOTTOM w0.076: 62.27,44.76 62.43,44.91 62.43,45.19 62.28,45.34 62.28,45.48 USM2006.C2 ; USM2006.C2 61.94,45.83 61.59,45.83 61.43,45.68 61.43,44.79 61.61,44.61 ; USM2006.C2 61.92,45.32 61.92,44.84
  BOTTOM w0.089: 61.61,44.61 v1(61.79,44.43)
EMMC_CLK: length 7.4
  BOTTOM w0.076: U80.AM3 104.55,62.28 104.07,62.28 103.66,62.12 103.26,62.12 103.22,62.17 102.14,62.17 102.07,62.09
  BOTTOM w0.102: 102.07,62.09 101.36,61.39 99.71,61.39 99.5,61.17 98.55,61.17 98.49,61.12 R5135.2
EMMC_CLK_D: length 58.2
  IN1 w0.079: v1(70.25,53.09) 70.25,52.43 71.3,51.38 72.12,51.38 72.49,51.02 73.77,51.02 74.21,51.45 74.21,51.61 75.4,52.8 75.4,53.67 76.13,54.4 76.86,54.4 77.31,53.96 77.91,53.96 78.38,54.43 81.6,54.43 82.49,55.32 82.49,56.3 83.17,56.97 84.55,56.97 84.94,56.97 86.26,58.3 86.26,58.8 87.48,60.02 89.62,60.02 89.94,60.34 90.61,60.34 91.31,61.03 92.53,61.03 93.05,60.52 93.27,60.52 93.6,60.18 95.28,60.18 95.47,60.37 97.74,60.37 98.08,60.04 v1(98.08,59.7)
  BOTTOM w0.076: USM2006.M6 57.68,47.73 57.44,47.97 57.44,48.2 57.3,48.34 57.04,48.34 56.94,48.45 56.94,48.72 56.84,48.83 56.48,48.83
  BOTTOM w0.102: v1(98.08,59.7) 98.01,59.76 R5135.1 ; v1(70.25,53.09) 70.25,53.36 C1136.1 69.41,53.68 69.39,53.66 RSM2152.1 68.57,53.66 68.42,53.8 v1(68.14,53.8) 67.84,53.8 66.85,52.82 66.85,51.85 65.93,50.93 64.23,50.93 63.3,51.86 56.55,51.86 56.35,51.67 56.35,48.95 56.48,48.83
EMMC_CMD: length 50.2
  IN1 w0.079: v1(74.37,52.44) 74.94,53.01 74.94,53.87 75.96,54.89 81.41,54.89 82.03,55.51 82.03,56.5 82.96,57.43 84.74,57.43 85.8,58.49 85.8,58.99 87.9,61.08 90.49,61.08 90.9,61.49 92.72,61.49 93.24,60.98 93.46,60.98 93.79,60.64 95.09,60.64 95.28,60.83 100.3,60.83 102.84,63.37 v1(102.84,64.21)
  BOTTOM w0.076: U80.AP4 104.9,64.17 104.01,64.17 103.58,64.34 103.34,64.34 103.21,64.21 v1(102.84,64.21)
  BOTTOM w0.102: v1(74.37,52.44) 74.37,52.42 74.37,52.08 74.57,51.88 74.57,50.4 73.52,49.36 72.52,49.36 72.02,48.86 72.02,46.36 71.98,46.31 71.98,44.74 v1(71.54,44.31) 70.71,43.48 R5134.2
EMMC_CMD_D: length 15.9
  BOTTOM w0.076: 62.94,44.77 62.94,45.18 62.94,45.18 62.79,45.34 62.58,45.34 62.44,45.48 62.44,46.19 62.37,46.26 62.3,46.34 61.36,46.34 61.24,46.45
  BOTTOM w0.102: 61.24,46.45 61.21,46.49 58.87,46.49 58.28,47.08 USM2006.M5 ; R5134.1 C1137.1 69.08,43.5 RSM2155.2 68.47,43.5 67.99,43.98 v1(67.78,43.98) 63.73,43.98 62.94,44.77
EMMC_D<0>: length 57.1
  IN1 w0.079: v1(73.58,51.51) 73.4,51.51 72.94,51.96 72.94,53.27 72.74,53.47 72.74,53.93 72.64,54.03 72,54.03 71.9,54.14 71.9,54.29 72,54.39 73.19,54.39 73.29,54.49 73.29,54.64 73.19,54.74 71.63,54.74 71.53,54.85 71.53,55 71.63,55.1 73.37,55.1 73.47,55.2 73.47,55.33 73.37,55.43 72.29,55.43 72.19,55.53 72.19,55.66 72.29,55.76 74.23,55.76 74.99,56.52 75.28,56.52 76.3,55.5 79.94,55.5 80.98,56.55 80.98,57.14 81.35,57.52 82.14,57.52 84.18,59.56 85.5,59.56 87.67,61.73 87.89,61.73 88.69,62.52 90.09,62.52 90.16,62.46 94.21,62.46 94.31,62.36 94.31,61.73 94.24,61.65 93.97,61.65 93.87,61.55 93.87,61.43 94.05,61.26 94.84,61.26 95.03,61.45 100.04,61.45 101.02,62.43 101.02,64.05 v1(101.38,64.41)
  BOTTOM w0.076: v1(101.38,64.41) 101.62,64.17 102.29,64.17 102.63,63.84 103.09,63.84 103.43,64.18 103.55,64.18 103.71,64.11 103.88,64.02 104.02,63.88 U80.AP2
  BOTTOM w0.102: R5126.2 71.34,48.03 71.34,49.14 72.63,50.44 72.63,50.5 73.58,51.45 v1(73.58,51.51)
EMMC_D<1>: length 56.6
  IN1 w0.079: v1(72.53,52.38) 72.13,52.38 71.92,52.59 71.92,53.54 71.32,54.13 68.48,54.13 68.38,54.23 68.38,54.92 68.48,55.02 70.97,55.02 72.12,56.17 72.36,56.17 72.46,56.27 72.46,56.64 72.56,56.74 72.74,56.74 72.84,56.64 72.84,56.27 72.94,56.17 73.09,56.17 73.2,56.27 73.2,57 73.3,57.1 75.29,57.1 76.47,55.92 79.77,55.92 80.57,56.72 80.57,57.4 81.1,57.93 81.97,57.93 84.01,59.97 85.33,59.97 87.5,62.14 87.72,62.14 88.66,63.08 88.84,63.08 88.98,62.94 89.13,62.94 89.25,63.05 89.25,63.49 89.32,63.57 89.5,63.57 89.6,63.47 89.6,63.05 89.7,62.95 89.84,62.95 89.93,63.05 89.93,63.47 90.04,63.57 92.49,63.57 92.63,63.43 92.63,62.95 92.67,62.91 94.66,62.91 94.97,62.6 94.97,62.32 95.43,61.86 99.81,61.86 100.2,62.25 100.2,62.97 100.27,63.05 100.58,63.05 100.68,63.15 100.68,63.43 v1(100.54,63.57)
  BOTTOM w0.076: U80.AP1 103.33,63.68 102.56,63.68 102.23,64.02 100.99,64.02 v1(100.54,63.57)
  BOTTOM w0.102: R5127.2 71.07,49.79 71.07,49.8 71.44,50.17 71.44,50.8 71.88,51.24 v1(72.13,51.24) 72.72,51.24 72.94,51.46 72.94,51.98 v1(72.53,52.38)
EMMC_D<2>: length 54.7
  IN1 w0.079: v1(93.52,64.12) 93.01,64.12 92.91,64.22 92.91,65.55 92.8,65.66 92.61,65.66 92.45,65.49 92.16,65.49 91.99,65.66 91.53,65.66 91.43,65.55 91.43,65.26 91.33,65.16 91.13,65.16 91.03,65.26 91.03,65.55 90.92,65.66 89.29,65.66 89.18,65.55 89.18,64.48 87.46,62.75 87.24,62.75 85.07,60.59 83.76,60.59 81.71,58.54 80.84,58.54 79.95,57.65 79.95,56.97 79.51,56.53 76.73,56.53 75.55,57.71 72.66,57.71 71.37,56.43 71.37,56.3 70.72,55.64 68.08,55.64 67.76,55.33 67.76,53.75 68,53.51 70.59,53.51 70.71,53.4 70.71,52.62 71.32,52.01 v1(71.32,52)
  BOTTOM w0.076: 99.97,62.82 100.2,63.05 100.91,63.05 101.01,63.15 101.01,63.75 101.11,63.85 102.18,63.85 102.5,63.53 103.42,63.53 103.76,63.67 103.88,63.67 104.11,63.6 104.25,63.6 104.46,63.68 104.66,63.88 U80.AP3
  BOTTOM w0.102: v1(71.32,52) 71.25,52 R5128.2 ; 99.97,62.82 99.33,62.82 99.05,62.54 95.29,62.54 93.72,64.12 v1(93.52,64.12)
EMMC_D<3>: length 56
  IN1 w0.079: v1(73.58,52.84) 74.48,52.84 74.74,53.1 74.74,53.24 74.67,53.31 74.24,53.31 73.53,54.02 73.53,54.15 73.61,54.23 73.8,54.23 74.34,53.69 74.48,53.69 74.58,53.79 74.58,53.93 74.01,54.5 74.01,54.63 74.1,54.72 74.23,54.72 74.81,54.14 74.92,54.14 75.03,54.25 75.03,54.36 74.52,54.87 74.52,55 74.62,55.09 74.75,55.09 75.26,54.58 75.37,54.58 75.48,54.69 75.48,54.85 75.4,54.92 75.4,55.04 75.46,55.09 80.76,55.09 80.87,55.2 80.87,55.46 81.14,55.74 81.68,55.74 81.83,55.89 81.83,56.58 82.88,57.63 84.66,57.63 85.6,58.57 85.6,59.07 87.81,61.29 88.49,61.29 88.59,61.39 88.59,61.84 88.75,62.01 88.84,62.01 88.94,61.91 88.94,61.39 89.04,61.29 90.4,61.29 90.81,61.7 92.81,61.7 92.89,61.62 93.33,61.18 93.54,61.18 93.88,60.85 95.01,60.85 95.2,61.04 100.21,61.04 102.06,62.88 102.06,63.44 v1(102.06,63.45)
  BOTTOM w0.076: U80.AN3 104.87,63.48 104.41,63.48 104.25,63.43 104.11,63.43 103.89,63.49 103.77,63.49 103.55,63.4 103.53,63.38 103.23,63.38 103.04,63.19 102.19,63.19 102.06,63.32 v1(102.06,63.45)
  BOTTOM w0.102: R5129.2 71.79,46.45 71.79,48.95 72.43,49.59 73.43,49.59 74.21,50.37 74.21,51.84 74.07,51.98 74.07,52.16 73.96,52.27 73.96,52.63 73.75,52.84 v1(73.58,52.84)
EMMC_D<4>: length 56.2
  IN1 w0.079: v1(73.58,52.13) 73.56,52.15 73.55,52.15 73.15,52.56 73.15,53.16 73.25,53.27 73.47,53.27 73.58,53.37 73.58,53.51 73.47,53.62 73.14,53.62 73.04,53.72 73.04,53.95 73.49,54.41 73.49,54.66 73.65,54.82 73.91,54.82 73.99,54.9 73.99,55.01 73.68,55.33 73.68,55.46 73.77,55.55 73.9,55.55 74.15,55.3 74.52,55.3 74.62,55.39 74.62,55.86 74.71,55.95 74.84,55.95 74.94,55.86 74.94,55.2 75.07,55.06 75.14,55.06 75.38,55.31 75.38,55.61 75.49,55.71 75.67,55.71 75.77,55.61 75.77,55.42 75.89,55.3 80.41,55.3 80.51,55.4 80.51,55.51 80.42,55.6 80.42,55.7 80.56,55.83 80.67,55.83 80.76,55.74 80.86,55.74 80.97,55.85 80.97,56.24 81.27,56.55 81.5,56.55 82.79,57.84 83.18,57.84 83.28,57.94 83.28,58.37 83.38,58.46 83.51,58.46 83.61,58.37 83.61,57.94 83.71,57.84 83.86,57.84 83.96,57.94 83.96,58.28 84.07,58.38 84.22,58.38 84.32,58.28 84.32,57.94 84.42,57.84 84.57,57.84 85.39,58.66 85.39,59.16 87.75,61.52 87.97,61.52 88.77,62.32 90.01,62.32 90.07,62.25 90.37,62.25 90.47,62.15 90.47,62.01 90.57,61.9 90.77,61.9 90.85,61.98 90.85,62.17 90.93,62.25 91.09,62.25 91.17,62.17 91.17,61.98 91.25,61.9 91.4,61.9 91.48,61.98 91.48,62.17 91.56,62.25 91.72,62.25 91.8,62.17 91.8,62 91.9,61.9 92.04,61.9 92.14,62 92.14,62.15 92.25,62.25 92.4,62.25 92.5,62.15 92.5,62 92.6,61.9 92.73,61.9 92.83,62 92.83,62.16 92.92,62.25 94.01,62.25 94.11,62.15 94.11,61.98 94.01,61.88 93.77,61.88 93.67,61.78 93.67,61.35 93.96,61.05 94.92,61.05 95.11,61.24 100.13,61.24 101.46,62.57 v1(101.46,63.45)
  BOTTOM w0.076: v1(101.46,63.45) 101.91,62.99 103.06,62.99 103.28,63.21 U80.AN1
  BOTTOM w0.102: R5130.2 71.56,47.24 71.56,49.05 72.51,49.99 v1(73.07,49.99) 73.51,49.99 73.99,50.47 73.99,51.72 v1(73.58,52.13)
EMMC_D<5>: length 56.4
  IN1 w0.079: v1(72.53,53.07) 72.53,53.65 72.36,53.83 71.92,53.83 71.41,54.34 68.69,54.34 68.59,54.44 68.59,54.72 68.69,54.82 71.06,54.82 72.2,55.96 74.14,55.96 74.91,56.73 75.37,56.73 76.39,55.71 79.85,55.71 80.77,56.63 80.77,57.23 81.27,57.72 82.05,57.72 84.1,59.76 85.41,59.76 87.58,61.93 87.8,61.93 88.6,62.73 90.18,62.73 90.24,62.66 90.74,62.66 90.81,62.74 90.81,63.27 90.91,63.36 91.04,63.36 91.13,63.27 91.13,62.74 91.21,62.66 91.37,62.66 91.44,62.74 91.44,63.27 91.54,63.36 91.67,63.36 91.76,63.27 91.76,62.74 91.84,62.66 91.99,62.66 92.07,62.74 92.07,63.27 92.17,63.36 92.3,63.36 92.39,63.27 92.39,62.74 92.47,62.66 94.33,62.66 95.34,61.65 99.89,61.65 100.6,62.36 v1(100.6,62.62)
  BOTTOM w0.076: U80.AN2 104.27,62.99 104.06,62.99 103.94,62.95 103.74,62.95 103.58,63.02 103.33,63.02 103.14,62.83 101.68,62.83 101.48,62.62 v1(100.6,62.62)
  BOTTOM w0.102: v1(72.53,53.07) 73.17,52.43 73.17,51.36 72.4,50.59 72.4,50.53 71.11,49.24 71.11,48.81 R5131.2
EMMC_D<6>: length 56.2
  IN1 w0.079: v1(99.76,62.39) 99.44,62.06 99.08,62.06 99,62.14 99,62.26 98.92,62.34 98.76,62.34 98.69,62.26 98.69,62.14 98.61,62.06 98.45,62.06 98.37,62.14 98.37,62.26 98.29,62.34 98.13,62.34 98.06,62.26 98.06,62.14 97.98,62.06 97.82,62.06 97.74,62.14 97.74,62.26 97.66,62.34 97.5,62.34 97.43,62.26 97.43,62.14 97.35,62.06 97.19,62.06 97.11,62.14 97.11,62.26 97.03,62.34 96.87,62.34 96.8,62.26 96.8,62.14 96.72,62.06 96.56,62.06 96.48,62.14 96.48,62.26 96.4,62.34 96.24,62.34 96.17,62.26 96.17,62.14 96.09,62.06 95.8,62.06 94.75,63.12 93.24,63.12 92.83,63.52 92.83,63.7 92.75,63.77 91.12,63.77 91.04,63.85 91.04,63.99 90.96,64.07 90.8,64.07 90.72,63.99 90.72,63.85 90.64,63.77 90.49,63.77 90.41,63.85 90.41,63.99 90.33,64.07 90.17,64.07 90.09,63.99 90.09,63.85 90.01,63.77 89.86,63.77 89.78,63.85 89.78,63.99 89.7,64.07 89.54,64.07 89.46,63.99 89.46,63.85 89.38,63.77 89.06,63.77 87.63,62.34 87.41,62.34 85.24,60.18 83.93,60.18 81.88,58.13 81.01,58.13 80.36,57.48 80.36,56.8 79.68,56.12 76.56,56.12 75.37,57.3 72.83,57.3 71.78,56.26 71.78,56.13 70.89,55.23 68.32,55.23 68.18,55.09 68.18,54.08 68.33,53.93 71.24,53.93 71.71,53.45 71.71,52.44 72.42,51.73 v1(72.53,51.73)
  BOTTOM w0.076: U80.AM4 105.19,62.83 104.09,62.83 103.97,62.78 103.71,62.78 103.63,62.82 103.36,62.82 103.21,62.66 101.88,62.66 101.21,61.98 100.17,61.98 v1(99.76,62.39)
  BOTTOM w0.102: v1(72.53,51.73) 71.99,51.73 R5132.2
EMMC_D<7>: length 55.7
  IN1 w0.079: v1(93.75,63.51) 93.31,63.51 92.84,63.98 92.67,63.98 92.59,64.06 92.59,65.14 92.5,65.23 92.37,65.23 92.27,65.14 92.27,64.06 92.19,63.98 92.04,63.98 91.96,64.06 91.96,65.14 91.87,65.23 91.74,65.23 91.64,65.14 91.64,64.06 91.56,63.98 91.34,63.98 91.05,64.27 90.75,64.27 90.64,64.37 90.64,64.68 90.54,64.78 90.42,64.78 90.31,64.68 90.31,64.37 90.21,64.27 90.04,64.27 89.93,64.37 89.93,65.35 89.84,65.45 89.7,65.45 89.6,65.35 89.6,64.37 89.5,64.27 89.27,64.27 87.55,62.55 87.32,62.55 85.16,60.38 83.84,60.38 81.8,58.34 80.93,58.34 80.16,57.57 80.16,56.89 79.6,56.33 76.64,56.33 75.46,57.51 72.75,57.51 71.58,56.34 71.58,56.21 70.8,55.44 68.16,55.44 67.97,55.24 67.97,54 68.25,53.72 70.69,53.72 70.92,53.49 70.92,53.03 v1(71.32,52.64)
  BOTTOM w0.076: 98.9,62.29 99.37,61.82 101.28,61.82 101.95,62.5 103.46,62.5 U80.AM1
  BOTTOM w0.102: R5133.2 71.16,52.48 v1(71.32,52.64) ; v1(93.75,63.51) 94,63.51 95.2,62.31 98.87,62.31 98.9,62.29
EMMC_RCLK: length 7.7
  BOTTOM w0.076: U80.AM2 104.08,62.47 103.93,62.47 103.88,62.41 103.87,62.41 103.87,62.4 103.62,62.28 103.33,62.28 103.29,62.33 102.04,62.33 101.88,62.17
  BOTTOM w0.102: 101.88,62.17 101.34,61.64 99.18,61.64 99.16,61.66 v1(98.86,61.66) 97.6,61.66 R5136.2
EMMC_RCLK_D: length 60.6
  TOP w0.102: v1(59.81,47.56) 59.33,48.04 59.33,50.39 60.53,51.6 62.5,51.6 63.84,52.93 64.75,52.93 v1(64.75,52.93)
  IN1 w0.079: v1(97.44,59.71) 96.98,59.25 95.85,59.25 95.45,59.65 94.96,59.65 94.86,59.55 94.86,59.06 94.76,58.96 94.5,58.96 94.4,59.06 94.4,59.55 94.3,59.65 93.48,59.65 93.08,60.06 92.79,60.06 92.61,59.88 90.13,59.88 89.81,59.56 87.67,59.56 86.72,58.61 86.72,58.11 84.8,56.18 84.16,56.18 83.91,56.42 83.27,56.42 82.95,56.11 82.95,55.13 81.79,53.97 78.57,53.97 78.1,53.5 76.75,53.5 74.67,51.42 74.67,51.26 73.51,50.11 71.02,50.11 69.17,51.96 66.05,51.96 65.85,52.15 65.85,54.18 65.75,54.28 65.4,54.28 65.3,54.18 65.3,53.63 65.19,53.53 64.81,53.53 64.71,53.63 64.71,54.17 64.61,54.27 64.24,54.27 64.14,54.17 64.14,53.3 64.51,52.93 v1(64.75,52.93)
  BOTTOM w0.102: R5136.1 97.44,59.94 v1(97.44,59.71) ; RSM2150.1 64.71,56.22 64.71,52.97 v1(64.75,52.93) ; v1(59.81,47.56) 59.68,47.43 USM2006.H5
EMMC_RCOMP: length 11.7
  BOTTOM w0.203: RAP1054.1 95.29,70 v1(96.03,70) 97.54,70 101.16,66.38 101.16,65.24 101.76,64.64 103.75,64.64 U80.AT1
EN_PP1800_DX_AUDIO: length 6.6
  TOP w0.102: R1143.2 97.76,55.18 v1(98.34,54.59) 98.42,54.52 101.85,54.52 102.35,55.01 v3(103.02,55.01)
  BOTTOM w0.076: v3(103.02,55.01) 103.02,54.81 103.24,54.6 U80.U1
EN_PWR_WIFI: length 150.4
  TOP w0.102: v1(206.27,19.74) 206.27,21.14 v1(206.47,21.34) 206.8,21.68 211.17,21.68 215.21,25.71 215.21,27.21 214.98,27.44 PU21.2
  IN2 w0.079: v1(206.27,19.74) 206.56,19.45 206.56,18.94 206.32,18.7 205.76,18.7 204.94,19.51 201.62,19.51 201.08,18.98 200.37,18.98 200.08,19.28 199.27,19.28 198.77,18.78 189.22,18.78 188.32,17.87 184.13,17.87 181.59,20.41 173.84,20.41 172.28,18.86 169.89,18.86 169.23,19.52 167.4,19.52 167.08,19.2 155.41,19.2 155.1,18.88 149.22,18.88 147.7,20.4 147.7,20.77 146.86,21.62 146.76,21.62 145.79,22.59 124.29,22.59 123.82,23.06 119.73,23.06 116.42,26.37 109.23,26.37 108.65,26.94 101.99,26.94 97.5,31.43 97.22,31.43 96.47,32.18 96.47,33.66 91.64,38.5 91.64,39.65 91.18,40.1 90.48,40.1 89.97,40.61 89.97,41.81 89.03,42.75 89.03,43.19 v1(88.93,43.29)
  BOTTOM w0.102: EUPM3247.A52 88.93,43.29 v1(88.93,43.29)
EN_USB_C0_5V_OUT: length 91.4
  TOP w0.102: PR99.1 34.25,69.25 PQ130.2 v1(31.51,69.25) 31.31,69.04 31.31,67.36 PU2.C3 30.78,67.11 v1(30.6,66.93)
  IN1 w0.079: v1(30.6,66.93) 30.77,67.1 39.48,67.1 41.6,64.99 41.6,61.12 41.37,60.9 41.37,59.47 41.63,59.22 42.23,59.22 42.46,59.44 42.46,59.75 41.96,60.25 41.96,63.46 42.7,64.21 45.86,64.21 47.2,62.86 47.6,62.86 48.24,62.22 48.24,58.14 49.12,57.26 49.26,57.26 50.05,56.47 51.3,56.47 54.2,53.58 54.2,52.64 55.12,51.71 55.94,51.71 57.65,50 57.65,47.51 57.92,47.24 58.53,47.24 59.5,46.27 62.51,46.27 64.68,44.1 67.99,44.1 70.27,41.82 73.57,41.82 75.89,39.5 80.08,39.5 80.26,39.68 80.26,40.29 80.4,40.43 85.91,40.43 v1(86.52,41.04)
  BOTTOM w0.102: EUPM3247.B60 v1(86.52,41.04)
EN_USB_C0_CHARGE*: length 97.3
  TOP w0.102: PU3.A3 32.02,61.82 v1(32.22,62.03)
  IN1 w0.079: v1(95.72,32.99) 95.72,32.96 95.46,32.7 94.28,32.7 90.26,28.68 88.86,28.68 87.92,27.73 85.44,27.73 85.13,27.42 83.88,27.42 83.32,27.99 79,27.99 78.72,28.26 73.79,28.26 72.98,29.08 70.51,29.08 67.75,31.85 67.75,31.95 61.28,38.42 59.25,38.42 57.31,40.35 53.59,40.35 49.9,44.05 49.9,47.04 48.3,48.64 48.3,49.63 46.77,51.16 46.12,51.82 46.12,54.38 42.49,58 39.16,58 35.13,62.03 v1(32.22,62.03)
  BOTTOM w0.102: v1(95.72,32.99) 95.72,33.23 92.7,36.26 92.7,36.6 v1(92.22,37.08) 91.75,37.55 89.66,37.55 89.17,37.06 89.17,36.54 88.82,36.18 88.13,36.18 87.77,36.53 87.77,37.22 87.85,37.29 EUPM3247.A64
EN_VCCST: length 83.6
  TOP w0.102: PU12.9 102.46,34.03 102.37,33.94 PU11.4 103.08,33.45 103.22,33.31 103.22,32.05 102.71,31.53 102.33,31.53 102.19,31.39 PR72.1 103.13,30.08 v1(103.34,30.08) ; v1(94.56,38.56) 94.79,38.79 94.79,42.2 93.21,43.77 93.21,43.82 92.25,44.79 92.25,45.62 89.24,48.62 88.75,48.62 87.06,50.32 87.06,57.03 87.62,57.6 87.62,62.44 87.47,62.59 87.47,65.25 86.51,66.2 86.51,69.04 86.86,69.38 86.86,71.11 89.22,73.48 89.22,77.86 89.63,78.27 89.63,82.09 91.25,83.71 91.25,84.59 92.75,86.09 96.18,86.09 96.69,85.57 v1(96.69,85.58)
  IN2 w0.079: v1(103.34,30.08) 101.8,30.08 101.01,30.87 100.52,30.87 98.7,32.69 98.7,33.6 97.17,35.13 97.17,35.8 96.62,36.34 96.62,37.05 95.11,38.56 v1(94.56,38.56)
  BOTTOM w0.102: v1(96.69,85.58) 96.69,86.06 96.94,86.32 96.94,87.49 97.27,87.82 98.66,87.82 PR79.2
EOPIO_RCOMP: length 2.8
  TOP w0.254: v3(140.67,50.2) 140.53,50.2 139.91,50.82 v1(139.73,50.82) 139.03,51.52 R48.1
  BOTTOM w0.203: U80.H65 v3(140.67,50.2)
EQ0: length 3.8
  TOP w0.102: U26.13 21.5,48.38 20.9,48.98 v1(20.77,48.98) v1(19.78,48.98)
  BOTTOM w0.102: v1(19.78,48.98) 19.73,49.03 18.62,49.03 R5109.2
EXT_BOOT_STALL_STRAP: length 1.4
  TOP w0.102: TP80.1 107.26,62.15 v3(107.57,62.46)
  BOTTOM w0.102: U80.AM7 107.15,62.04 v3(107.57,62.46)
FAN_PWM_CN: length 8.1
  BOTTOM w0.102: CN4.4 183.88,65.43 v1(183.18,66.13) C952.1 R872.2 182.35,68.45 182.16,68.64 180.89,68.64 180.69,68.84 Q5.3
FAN_PWR_DIS*: length 149.7
  TOP w0.102: v1(199.61,18.7) 200.07,19.16 200.07,22.94 201.05,23.92 PU50.1 203.41,23.92 203.55,23.78 203.55,22.82 203.74,22.62 PU50.4 205.56,22.62 PC308.1 206.6,24.29 207.47,25.16 PU51.3
  IN2 w0.079: v1(199.61,18.7) 199.33,18.42 189.37,18.42 186.92,15.97 185.27,15.97 181.37,19.87 174.06,19.87 172.46,18.27 167.89,18.27 167.5,18.66 155.65,18.66 155.27,18.27 148.46,18.27 145.13,21.6 123.97,21.6 123.69,21.88 121,21.88 120.72,21.6 118.46,21.6 114.89,25.17 108.73,25.17 108.15,25.74 101.72,25.74 101.41,25.43 100.8,25.43 99.21,27.03 99.21,27.37 97.89,28.68 96.69,28.68 95.85,29.53 95.85,30.66 91.51,34.99 91.02,34.99 90.29,35.72 90.29,36.01 89.93,36.37 89.61,36.37 89.39,36.59 89.39,37.11 88.05,38.45 88.05,39.21 87.34,39.92 87.34,42.23 87.08,42.49 87.08,42.92 86.9,43.1 86.9,43.71 86.68,43.92 86.28,43.92 v1(85.87,43.52)
  BOTTOM w0.102: v1(85.87,43.52) 86.25,43.9 86.48,43.9 87.12,44.54 EUPM3247.B53
FBVR1P: length 19.6
  TOP w0.102: v1(77.03,71.48) 76.62,71.08 75.25,71.08 74.85,70.68 PR30.1
  IN1 w0.079: v4(69.47,77.23) 68.91,77.23 68.64,77.51 68.64,77.81 69,78.16 69.16,78.16 69.52,78.53 69.52,78.78 69.77,79.02 70.06,79.02 70.28,78.81 70.66,78.81 70.86,79.01 72.16,79.01 72.78,78.39 72.78,78.25 74.07,76.97 74.07,76.51 75.06,75.52 75.72,75.52 76.64,74.6 76.64,71.87 v1(77.03,71.48)
  BOTTOM w0.152: PU3254.J10 v4(69.47,77.23)
FBVR3P: length 19.9
  TOP w0.254: PR24.1 57.64,86.16 60.6,86.16 61.89,84.87 v1(61.89,84.64)
  IN1 w0.079: v4(69.01,79.65) 69.5,79.65 69.88,80.02 69.88,80.29 69.56,80.6 69.56,80.78 69.84,81.06 69.84,81.39 69.45,81.78
  IN1 w0.203: 69.45,81.78 68.95,82.28 68.95,83.37 68.34,83.98 v1(68.34,84.36)
  IN2 w0.254: v1(61.89,84.64) 62.1,84.44 62.86,84.44 63.9,85.48 67.61,85.48 68.34,84.74 v1(68.34,84.36)
  BOTTOM w0.152: PU3254.F11 68.97,79.46 69.01,79.5 v4(69.01,79.65)
FBVR4P: length 19.7
  TOP w0.102: v1(66.51,90.91) 66.87,91.27 66.87,94.45 PR26.1
  IN1 w0.079: v1(66.51,90.91) 66.25,90.65 66.25,87.67 67.79,86.13 70.41,86.13 71.34,85.2 71.34,84.08 71.66,83.77 71.66,80.56 72.01,80.2 v4(72.01,79.72)
  BOTTOM w0.102: v4(72.01,79.72) 72.01,79.44 71.97,79.4 PU3254.F5
FBVR5P: length 17.3
  TOP w0.102: v1(77.56,85.45) 77.81,85.7 PR28.1 77.81,86.4 77.57,86.64 PR19.1
  IN2 w0.079: v4(71.53,77.13) 71.99,77.13 72.34,76.78 72.35,76.78 72.51,76.61 72.59,76.61 72.86,76.33 73.25,76.33 74.26,77.35 75.29,77.35 76.9,78.96 76.9,80.81 75.64,82.07 75.64,82.89 76.48,83.74 76.96,83.74 77.41,84.19 77.41,85.3 v1(77.56,85.45)
  BOTTOM w0.152: v4(71.53,77.13) 71.47,77.19 PU3254.J6
FLASH_DSC_OVERRIDE*: length 60.8
  TOP w0.102: v1(79.24,44.49) 78.62,44.49 78.38,44.73 78.38,45.45 77.28,46.54 75.94,46.54 v1(75.08,47.4) 73.43,49.05 v1(73.43,50.59)
  IN2 w0.079: v1(73.43,50.59) 72.93,51.09 72.93,53.51 73.86,54.44 74.57,54.44 75.98,55.85 75.98,59.82 79.03,62.87 80.18,62.87 81.17,63.86 81.17,64.93 86.36,70.12 86.36,71.58 86.61,71.83 86.61,75.58 87.48,76.44 87.48,77.31 92.01,81.84 97.88,81.84 v1(98.39,82.35)
  BOTTOM w0.102: RAP1430.2 97.38,83.4 Q105.2 98.39,82.38 v1(98.39,82.35) ; EUPM3247.B33 78.44,44.54 78.49,44.49 v1(79.24,44.49)
FLASH_SPI_CLK: length 58.4
  TOP w0.102: v1(66.11,57.67) 66.06,57.61 66.06,55.94 65.52,55.41 R888.1
  IN1 w0.079: v1(70.73,58.53) 70.73,59.32 71.65,60.24 75.96,60.24 77.78,58.43 78.92,58.43 79.18,58.68 79.18,59.71 79.65,60.18 80.69,60.18 81.04,60.54 81.04,60.91 84.42,64.28 86.16,64.28 86.56,64.68 86.56,65.67 90.67,69.78 91.66,69.78 92.8,70.92 94.76,70.92 95.21,71.37 95.6,71.37 95.7,71.47 96.89,71.47 97.56,70.81 99.24,70.81 102.56,67.49 102.56,66.52 v1(102.33,66.3)
  BOTTOM w0.076: v1(102.33,66.3) 102.61,66.58 102.94,66.58 103.36,66.16 103.69,66.16 103.96,65.89 U80.AV2
  BOTTOM w0.102: v1(66.11,57.67) 66.29,57.84 66.29,59.75 66.75,60.21 68.37,60.21 69.21,59.37 69.21,58.72 70.23,57.7 R866.1 70.73,57.85 v1(70.73,58.53)
FLASH_SPI_CLK_R: length 3.4
  TOP w0.102: R888.2 63.84,55.77 62.99,56.63 v1(62.81,56.63) 62.09,56.63 61.7,57.02 U82.19
FLASH_SPI_CS*: length 37
  TOP w0.102: R865.1 79.22,56.61 v1(78.83,56.99)
  IN1 w0.079: v1(78.83,56.99) 78.83,57.18 80.65,59 81.52,59 83.56,61.04 83.68,61.04 85.92,63.28 86.58,63.28 87.56,64.26 87.56,65.25 90.94,68.64 94.28,68.64 95.45,69.81 98.82,69.81 101.1,67.53 101.1,65.45 101.87,64.68 102.43,64.68 102.96,65.21 v1(102.96,65.37)
  BOTTOM w0.076: v1(102.96,65.37) 103.09,65.5 104.25,65.5 104.55,65.2 U80.AU3
FLASH_SPI_MISO: length 61.1
  TOP w0.102: v1(64.46,59.34) 64.62,59.5 RAP3023.1 R889.1
  IN1 w0.079: v1(79.57,59.32) 80.05,59.8 80.85,59.8 81.43,60.38 81.43,60.76 82.33,61.66 83.43,61.66 85.67,63.9 86.32,63.9 86.94,64.52 86.94,65.51 90.83,69.4 91.82,69.4 92.85,70.42 99.08,70.42 102.09,67.42 v1(102.09,66.87) ; v1(78.34,58.03) 76.46,58.03 75.06,59.43 75.06,59.5 74.7,59.86 73.64,59.86 72.82,59.04 71.9,59.04 70.94,58.08 66.84,58.08 66.54,58.38 65.42,58.38 v1(64.46,59.34)
  BOTTOM w0.076: v1(102.09,66.87) 102.11,66.89 102.9,66.89 103.46,66.33 103.74,66.33 103.89,66.17 104.34,66.17 104.62,66.46 U80.AW3
  BOTTOM w0.102: v1(78.34,58.03) 78.65,58.03 79.23,58.62 80.91,58.62 82.32,57.21 82.63,57.21 R868.1 83.03,57.48 81.2,59.31 79.58,59.31 v1(79.57,59.32)
FLASH_SPI_MISO_R: length 3.4
  BOTTOM w0.102: UAP1012.2 80.94,56.93 81.22,56.65 81.7,56.65 81.86,56.8 R868.2 82.29,56.76 RAP1409.1
FLASH_SPI_MISO_TPM: length 3.1
  TOP w0.102: R889.2 63.47,60.99 v1(62.57,60.09) 62,59.52 U82.24
FLASH_SPI_MOSI: length 57.6
  TOP w0.102: R890.1 v1(65.24,57.44)
  IN1 w0.079: v1(101.77,65.67) 101.31,66.14 101.31,67.62 98.91,70.01 95.36,70.01 94.24,68.89 90.91,68.89 87.35,65.34 87.35,64.35 86.49,63.49 85.84,63.49 83.6,61.25 83.47,61.25 81.44,59.21 80.54,59.21 78.69,57.36 76.55,57.36 75.74,58.17 71.75,58.17 70.48,56.9 v1(70.48,56.04)
  BOTTOM w0.076: U80.AV3 104.84,65.59 104.38,65.59 104.32,65.66 103.25,65.66 103.11,65.8 101.89,65.8 v1(101.77,65.67)
  BOTTOM w0.102: v1(70.48,56.04) 70.48,55.7 R869.1 69.84,55.28 69.66,55.46 69.66,56.77 68.8,57.63 68.8,59.19 68.19,59.8 66.92,59.8 66.69,59.58 66.69,57.46 66.29,57.06 65.63,57.06 v1(65.24,57.44)
FLASH_SPI_MOSI_R: length 7.1
  BOTTOM w0.102: v1(75.84,51.93) 75.84,52.13 75.46,52.51 RAP1410.1 75.46,53.46 74.53,54.39 UAP1012.5 71.9,54.39 71.01,55.28 R869.2
FLASH_SPI_MOSI_TPM: length 2.8
  TOP w0.102: R890.2 62.2,57.44 61.62,58.02 U82.21
G3_SLEEP_ENA: length 3.7
  BOTTOM w0.102: R1158.2 83.1,33.08 82.64,32.62 RPM3573.2 83.07,32.17 v1(83.46,31.78) 84.17,31.07 QPM3371.2
GT_CSN: length 45.1
  TOP w0.203: v1(194.4,41.09) 194.23,41.26 PC23.2 PC9109.2 PR145.1
  IN1 w0.203: v1(190.39,43.92) 189.22,45.09 189.22,51.57 186.88,53.91 176.24,53.91 173.75,51.42 173.75,47.84 v1(172.46,46.54)
  BOTTOM w0.203: PR139.1 v1(172.46,46.54) ; v1(190.39,43.92) 190.65,43.67 PR85.2 191.25,43.14 191.09,42.97 PC2.2 191.28,42.38 PC1327.2 193.07,41.6 PC1328.2 193.61,41.59 194.12,41.09 v1(194.4,41.09) 194.4,41.17 194.45,41.22 194.45,42.04 194.71,42.31 194.71,42.96 194.86,43.11 PR181.1 PR91.2 195.24,44.09 PR129.1
GT_CSP: length 9.1
  TOP w0.203: 195.01,44.09 193.76,44.09 v1(193.75,44.08) 193.35,43.68 PR122.1 ; 195.01,44.09 PR145.2 PC9109.1 PC23.1 195.21,41.5 195.21,40.48 195.4,40.29 PU5.7 ; 195.01,44.09 195.01,44.59 ; 195.01,44.59 PR123.1 ; 195.01,44.59 v1(195.01,45.52)
  BOTTOM w0.203: PR152.1 194.22,43.61 v1(193.75,44.08)
GT_FCCM: length 19.8
  TOP w0.203: v1(187.95,38.42) 187.95,39.99 188.73,40.77 189.07,40.77 189.23,40.93 191.58,40.93 191.94,40.57 v1(192.3,40.57) 192.5,40.57 193.04,40.04 193.04,39 193.18,38.85 PU5.11
  IN2 w0.203: v1(179.07,39.37) 179.21,39.37 180.16,38.42 v1(187.95,38.42)
  BOTTOM w0.279: v1(179.07,39.37) 178.91,39.37 178.52,39.76 PU7.1 ; v1(187.95,38.42) 187.43,38.93 PU8.1
GT_PWM1: length 17
  TOP w0.203: v1(192.45,39.92) 192.45,38.98 192.98,38.45 PU5.12
  IN2 w0.203: v1(179.33,39.98) 180.55,38.76 187.39,38.76 188.65,40.02 192.36,40.02 v1(192.45,39.92)
  BOTTOM w0.279: v1(179.33,39.98) 179.21,40.1 PU7.22
GT_PWM2: length 9.2
  TOP w0.203: PU5.13 192.61,38.05 v1(192.09,38.56) 192.08,38.58 192.08,39.63 191.46,40.24 191.46,40.33 191.16,40.62 189.36,40.62 189.2,40.46 188.86,40.46 188.26,39.86 188.26,39.07 v1(188.43,38.9)
  BOTTOM w0.279: PU8.22 188.07,39.61 188.27,39.41 188.27,39.06 v1(188.43,38.9)
GT_SW_DRV1: length 29.8
  TOP w0.203: PR122.2 v1(193.02,45.27)
  IN2 w0.203: v1(181.03,49.37) 181.14,49.49 181.14,52.94 181.91,53.71 189.69,53.71 192.83,50.58 192.83,45.46 v1(193.02,45.27)
  BOTTOM w0.203: v1(193.02,45.27) 193.17,45.12 PR93.1 ; 177.29,47.07 177.29,48.96 177.7,49.37 v1(181.03,49.37)
  vias: v5(175.93,44.8)
GT_SW_DRV2: length 31.1
  TOP w0.203: PR123.2 193.87,44.59 193.59,44.87 193.59,45.37 193.24,45.73 192.52,45.73 192.33,45.53 v1(192.33,45.11) 192.06,44.85 PR96.1
  IN2 w0.203: v1(181.7,49.39) 181.57,49.52 181.57,52.82 182.04,53.28 189.6,53.28 192.43,50.45 192.43,45.21 v1(192.33,45.11)
  BOTTOM w0.203: v1(181.7,49.39) 181.89,49.39 181.92,49.36 184.93,49.36 185.36,48.93 185.36,46.66
  vias: v5(184.36,44.29)
HDMI_5V: length 11.7
  BOTTOM w0.305: CN12.18 11.83,51 11.83,48.65 13.28,47.2 13.28,45.27 14.99,43.56 U23.4 U23.7
  vias: v1(16.17,52.15) v1(16.15,51.54)
HDMI_ALS_PD: length 1.9
  TOP w0.102: v1(22.34,48.67) 22.17,48.67 21.9,48.41 U26.12
  BOTTOM w0.102: v1(22.34,48.67) 22.34,48.62 21.79,48.06 R5110.2
HDMI_DDCCLK_MB: length 23
  TOP w0.102: U26.28 20.3,41.49 20.39,41.39 20.39,41.31 20.19,41.1 19.73,41.1 19.43,41.4 v1(19.43,41.47)
  BOTTOM w0.102: CN12.15 9.69,50.86 9.87,50.86 9.97,50.76 9.97,43.47 11.24,42.2 15.32,42.2 15.47,42.06 U23.1 U23.10 16.93,42.06 17.11,42.24 17.26,42.24 R5116.2 18.39,42.21 19.71,42.21 20.11,41.82 20.11,41.35 19.89,41.14 19.57,41.14 19.43,41.28 v1(19.43,41.47)
HDMI_DDCDATA_MB: length 23
  TOP w0.102: U26.29 20.7,41.49 20.61,41.39 20.61,41.22 20.28,40.89 19.59,40.89 19.59,40.89 v1(19.43,40.74)
  BOTTOM w0.102: CN12.16 10.19,50.36 10.19,43.56 11.33,42.42 15.31,42.42 15.46,42.56 U23.2 U23.9 16.93,42.56 17.04,42.45 17.36,42.45 R680.2 18.35,42.43 19.8,42.43 20.32,41.9 20.32,41.27 19.98,40.93 19.62,40.93 v1(19.43,40.74)
HDMI_MB_HPD: length 13.9
  TOP w0.102: U26.25 v1(18.81,43.77)
  BOTTOM w0.102: v1(18.81,43.77) 17.52,43.77 17.23,44.06 U23.6 U23.5 15.25,44.06 13.71,45.6 v1(13.71,48.03) 13.71,50.47 R529.1 R527.1
HP_CN_OUT_L: length 8.1
  TOP w0.508: J1C1.1 14.81,8.65 15.66,9.51 v1(15.66,10.2) 15.66,10.77 C3.2 16.38,11.07 16.42,11.11 D48.1 17.63,11.11 17.67,11.07 R1D9.1
HP_CN_OUT_R: length 23.9
  TOP w0.508: R1D10.1 C4.2 17.71,8.87 16.74,8.87 D46.1 16.48,8.88 v1(15.8,8.2)
  IN2 w0.508: v1(15.8,8.2) 15.8,11.55 16.71,12.45 16.71,16.95 14.55,19.11 7.31,19.11 J1C1.2
HP_DET_CN: length 5
  BOTTOM w0.102: CN12.19 9.82,52.99 11.47,52.99 12.44,52.03 12.94,52.03 13.15,52.24 R527.2
HP_OUT_L: length 13.1
  TOP w0.305: U1.12 26.63,14.77 v1(26.76,14.64)
  TOP w0.508: v1(19.07,11.85) R1D9.2 18.25,12.23 17.88,12.6 R1D22.2 17.91,13.01 v1(18.56,13.01)
  IN2 w0.508: v1(26.76,14.64) 25.14,13.01 20.85,13.01 20.36,13.5 19.04,13.5 v1(18.56,13.01)
HP_OUT_R: length 17.3
  TOP w0.305: U1.13 v1(26.76,15.27)
  TOP w0.508: v1(20.26,10.15) 19.8,9.69 R1D21.2 R1D10.2
  IN2 w0.508: v1(20.26,10.15) 21.24,10.15 21.81,9.58 27.35,9.58 28.47,10.7 28.47,13.39 28.03,13.83 28.03,14.69 27.45,15.27 v1(26.76,15.27)
HP_RING2: length 25.6
  IN1 w0.508: 15.64,7.35 15.41,7.58 5.17,7.58 J1C1.3
  IN2 w0.508: J1C1.3 5.1,7.65 14.55,7.65 16.07,6.13 v1(16.6,6.13)
  vias: v1(17.24,6.13) v1(19.17,14.28) v1(19.7,14.59)
HP_SLEEVE: length 13.8
  TOP w0.305: U1.28 19.52,15.27
  TOP w0.508: 19.52,15.27 18.64,15.27
  IN1 w1.016: J1C1.4 4.32,18.2 5.45,19.34 14.88,19.34
  vias: v1(15.23,15.2) v1(15.89,15.2)
HSJ_DET_L*: length 9.7
  TOP w0.102: U1.27 19.66,15.77 v1(18.76,16.67) 17.87,17.57 C1M7.1 R1D7.1 17.32,18.69 17.48,18.52 R1B26.2 17.81,19.55 v1(17.47,19.9)
  BOTTOM w0.102: Q129.3 17.06,20.73 17.47,20.33 v1(17.47,19.9)
HSJ_DET_PCH_L: length 37.1
  TOP w0.102: R2B2.1 v1(15.71,22.51) R1D18.1 ; v1(30.57,23.02) 31.07,23.52 R1D13.2 31.08,23.54 R3493.1 31.33,24.66 31.48,24.82 31.48,25.79 31.18,26.09 31.18,27.19 32.1,28.1 34.88,28.1 R1B30.2 36.92,25.18 36.93,25.17 R1D4.2
  IN2 w0.079: v1(15.71,22.51) 18.33,19.9 26.54,19.9 27.7,21.06 28.62,21.06 v1(30.57,23.02)
  BOTTOM w0.102: v1(15.71,22.51) 15.51,22.31 15.51,20.23 16.35,19.39 18.2,19.39 Q129.1
HSJ_MIC_DET: length 129.9
  TOP w0.102: v1(56.78,39.1) 56.38,38.69 55.92,38.69 55.53,39.09 49.66,39.09 49.07,38.49 43.78,38.49 43.14,37.85 37.51,37.85 36.8,37.14 35.78,36.13 35.78,29.98 34.28,28.48 32.12,28.48 30.9,27.26 30.9,25.92 31.08,25.74 R3493.2 ; v1(99.74,72.5) 99.94,72.3 99.94,71.81 100.45,71.3 100.45,70.68 103.83,67.29 106.95,67.29 107.43,66.81 109.34,66.81 110.9,65.24 110.9,64.68 110.77,64.55 110.77,62.91 v3(110.31,62.45)
  IN1 w0.079: v1(59.96,64.04) 61.78,62.23 71.43,62.23 72.16,61.49 75.42,61.49 75.87,61.94 78.1,61.94 78.32,62.17 78.63,62.17 79.02,61.78 81.37,61.78 84.29,64.7 84.79,64.7 90.39,70.3 90.39,70.57 90.91,71.09 91.52,71.09 93.99,73.56 93.99,73.78 94.46,74.25 95.24,74.25 96.22,73.27 97.72,73.27 97.85,73.15 99.09,73.15 v1(99.74,72.5)
  IN2 w0.079: v1(56.78,39.1) 56.78,50.82 58.28,52.31 58.28,54.62 56.93,55.96 56.93,59.41 57.96,60.44 57.96,61.53 59.96,63.53 v1(59.96,64.04)
  BOTTOM w0.076: v3(110.31,62.45) 109.91,62.04 U80.AM11
I2C0_SCL: length 83
  TOP w0.102: Q137.6 48.37,62.38 48.61,62.14 48.61,61.51 R5155.1 48.05,60.95 v1(48.05,60.05) 48.05,58.91 48.55,58.41 v1(48.83,58.41)
  IN1 w0.079: v1(48.83,58.41) 48.83,58.21 50.13,56.91 51.51,56.91 59.35,49.07 61.93,49.07 62.78,48.22 62.78,46.77 64.91,44.64 66.3,44.64 66.69,45.03 70.18,45.03 70.99,44.22 72.59,44.22 73.86,42.96 74.57,42.96 76.14,41.38 77.21,41.38 78.06,42.24 80.22,42.24 80.58,42.59 84.22,42.59 84.54,42.91 84.54,43.38 84.77,43.61 85.15,43.61 85.63,44.09 88.3,44.09 91.31,47.1 91.31,47.71 92.22,48.63 92.22,48.96 92.84,49.57 92.84,50.71 94.11,51.99 96.76,51.99 97.28,52.51 98.05,52.51 98.27,52.29 100.33,52.29 100.69,51.94 101.49,51.94 101.91,52.36 v1(101.92,52.36)
  BOTTOM w0.076: R1142.2 99.66,53.42 99.71,53.37 RAP3054.1 99.94,53.53 100.12,53.7 101.21,53.7 101.92,52.99 v1(101.92,52.36) 102.05,52.23 102.96,52.23 103.13,52.4 103.57,52.4 103.75,52.34 103.94,52.34 104.08,52.4 104.23,52.4 104.43,52.33 104.57,52.33 104.69,52.37 104.93,52.61 U80.N3 105.25,52.61 105.76,53.12 105.76,54.34 U80.U6
I2C0_SDA: length 87.5
  TOP w0.102: v1(50.44,59.49) v1(50.44,60.92) 50.44,63.99 49.62,64.8 R5154.1 48.87,63.91 49.11,63.68 Q137.3
  IN1 w0.079: v1(101.41,52.81) 100.89,53.33 97.85,53.33 96.68,52.17 94.04,52.17 92.66,50.79 92.66,49.64 92.04,49.03 92.04,48.7 91.13,47.79 91.13,47.18 88.22,44.27 85.56,44.27 85.07,43.79 84.69,43.79 84.35,43.45 84.35,42.98 84.14,42.77 80.5,42.77 80.15,42.42 77.76,42.42 77.61,42.27 75.51,42.27 74.64,43.14 73.93,43.14 72.67,44.4 71.07,44.4 70.26,45.21 66.61,45.21 66.22,44.82 64.98,44.82 62.96,46.85 62.96,48.29 62,49.25 59.42,49.25 51.58,57.09 50.2,57.09 49.78,57.51 49.78,59.14 50.13,59.49 v1(50.44,59.49)
  BOTTOM w0.076: R1141.2 99.53,52.48 RAP3053.1 99.94,52.2 100.07,52.08 101.11,52.08 101.29,52.26 101.29,52.69 v1(101.41,52.81) 101.54,52.69 101.54,52.18 101.74,51.98 103.01,51.98 103.22,52.19 103.69,52.19 103.73,52.18 103.97,52.18 104.12,52.23 104.21,52.23 104.41,52.17 104.6,52.17 104.73,52.21 105.2,52.21 U80.M4 105.47,52.5 105.94,52.97 105.94,54.08 106.68,54.83 U80.U7
I2C1_SCL: length 136.8
  IN1 w0.079: v3(107.88,55.21) 107.39,55.69 105.41,55.69 105.12,55.41 104.63,55.41 103.87,54.64 102.13,54.64 102.05,54.72 96.52,54.72 96.17,55.07 93.67,55.07 93.18,54.59 92.65,54.59 92.05,53.99 88.85,53.99 v1(87.47,52.61)
  IN2 w0.079: v1(87.47,52.61) 87.06,52.21 87.06,50.05 90.92,46.19 90.92,44.38 91.46,43.85 91.46,43.02 92.83,41.65 93.13,41.65 95.66,39.13 96.52,39.13 98.46,37.19 99.98,37.19 101.41,35.76 101.41,34.24 101.85,33.8 102.83,32.81 102.83,31.79 105.15,29.47 105.15,29.11 106.18,28.07 109.13,28.07 109.53,27.67 116.72,27.67 120.2,24.19 124.29,24.19 124.76,23.72 146.95,23.72 150.54,20.12 154.72,20.12 154.92,20.33 161.97,20.33 v1(162.75,21.11)
  BOTTOM w0.102: v1(87.47,52.61) 87.17,52.61 RAP1010.1 ; v3(107.88,55.21) 107.88,55.15 U80.U9 ; CN3.6 174.25,22.88 173.97,23.16 CRCP4042.5 CRCP4042.6 173.97,25.04 173.81,25.2 163.72,25.2 162.3,23.79 162.3,22.02 162.55,21.77 162.55,21.31 v1(162.75,21.11)
I2C1_SDA: length 135.5
  IN1 w0.079: v3(107.23,55.21) 107.23,55.27 107.14,55.36 105.55,55.36 105.26,55.07 104.77,55.07 104,54.31 101.99,54.31 101.91,54.39 96.39,54.39 96.03,54.74 93.8,54.74 93.32,54.26 92.79,54.26 92.19,53.66 88.99,53.66 87.88,52.55 87.88,52.39 v1(87.46,51.98)
  IN2 w0.079: v1(87.46,51.98) 87.4,51.91 87.4,50.19 87.61,49.98 91.25,46.33 91.25,44.52 91.79,43.99 91.79,43.16 92.96,41.99 93.27,41.99 95.8,39.46 96.66,39.46 98.6,37.52 100.12,37.52 101.74,35.9 101.74,34.37 103.17,32.95 103.17,31.92 105.48,29.61 105.48,29.24 106.32,28.4 109.26,28.4 109.67,28 116.86,28 120.34,24.52 124.43,24.52 124.9,24.05 147.08,24.05 150.67,20.46 154.58,20.46 154.78,20.66 161.84,20.66 161.99,20.81 v1(161.99,21.13)
  BOTTOM w0.102: v1(161.99,21.13) 162.19,21.33 162.19,21.62 161.94,21.87 161.94,23.93 163.57,25.56 173.96,25.56 174.47,25.04 CRCP4042.7 CRCP4042.4 174.47,23.34 175.25,22.57 CN3.5 ; v3(107.23,55.21) 107.55,54.88 U80.U8 ; RAP1009.1 86.93,51.98 v1(87.46,51.98)
I2C4_SCL: length 166.3
  TOP w0.102: R5148.1 25.13,21.9 26.43,21.9 26.99,22.46 28,22.46 29.97,24.43 29.97,27.67 31.84,29.55 33.8,29.55 34.87,30.61 34.87,36.51 37.13,38.77 42.76,38.77 43.4,39.4 48.69,39.4 49.41,40.12 56.95,40.12 57.63,39.44 57.63,34.76 61.48,30.92 68.43,30.92 69.62,29.73 72.68,29.73 73.93,28.48 81.2,28.48 83.23,26.45 84.3,26.45 87.83,22.92 89.26,22.92 93.12,19.06 94.02,19.06 95.42,17.66 96.23,17.66 98.34,15.55 99.24,15.55 100.31,14.49 103.27,14.49 104.84,12.91 105.94,12.91 106.14,13.11 106.14,14.16 107.1,15.12 110.69,15.12 110.96,15.4 110.96,15.83 v1(110.89,15.91) ; v1(110.42,40.84) 110.63,40.63 110.88,40.63 111.83,39.68 111.83,37.85 C1139.1 111.8,36.98 111.8,36.68 RAP1049.1 111.8,35.78 111.8,34.53 112,34.33 RAP3043.2 111.8,33.9 111.8,33.11 110.79,32.09 110.79,30.06 109.87,29.14 v1(109.72,29.14)
  IN1 w0.076: 108.73,48.88 107.91,48.06 107.91,46.91 108,46.83 108,44.23 108.84,43.38 108.84,42.44 108.85,42.44 108.85,41.64 109.81,40.67 110.26,40.67 v1(110.42,40.84)
  IN1 w0.079: 108.73,48.88 108.8,48.95 108.8,49.06 109.01,49.27 109.01,50.99 109.92,51.91 109.92,52.3 110.12,52.49 110.62,52.49 110.96,52.84 110.96,56.01 110.91,56.06 110.91,56.73 110.59,57.05 110.27,57.05 109.85,57.47 109.85,57.75 109.54,58.05 109.54,58.32 v3(109.76,58.54)
  BOTTOM w0.102: U80.AF12 110.15,58.93 v3(109.76,58.54) ; v1(110.89,15.91) 110.81,15.98 110.81,27.9 109.72,28.99 v1(109.72,29.14)
I2C4_SCL_C: length 4.9
  TOP w0.102: U1.18 24.46,18.27 24.53,18.34 24.53,18.75 24.97,19.18 25.35,19.18 25.95,19.79 25.95,19.9 C1113.1 R5148.2
I2C4_SDA: length 164.2
  TOP w0.102: v1(111.55,15.96) 111.32,15.73 111.32,15.25 110.83,14.77 107.25,14.77 106.49,14.01 106.49,12.96 106.09,12.56 104.7,12.56 103.12,14.13 100.16,14.13 99.09,15.2 98.19,15.2 96.08,17.31 95.27,17.31 93.87,18.7 92.97,18.7 89.11,22.56 87.68,22.56 84.15,26.09 83.09,26.09 81.05,28.13 73.78,28.13 72.53,29.37 69.48,29.37 68.28,30.56 61.33,30.56 57.28,34.61 57.28,39.29 56.8,39.77 49.55,39.77 48.83,39.05 43.55,39.05 42.91,38.41 37.27,38.41 35.22,36.36 35.22,30.47 33.95,29.19 31.99,29.19 30.32,27.52 30.32,24.29 R5149.1 ; v1(109.8,29.78) 109.97,29.78 110.43,30.23 110.43,32.24 111.45,33.26 111.45,33.85 RAP3044.2 111.28,34.33 111.45,34.5 111.45,35.76 RAP1047.1 111.44,36.69 111.44,36.96 C1138.1 111.48,37.92 111.48,39.53 110.77,40.23 v1(110.45,40.23)
  IN1 w0.076: 108.48,49.1 107.75,48.36 107.58,48.2 107.58,46.77 107.67,46.69 107.67,44.09 108.51,43.24 108.51,41.62 108.52,41.62 108.52,41.5 108.71,41.3 108.71,41.3 109.26,40.75 109.67,40.34 110.33,40.34 v1(110.45,40.23)
  IN1 w0.079: v3(109.15,58.52) 109.37,58.29 109.37,57.98 109.68,57.68 109.68,57.4 110.2,56.88 110.52,56.88 110.75,56.66 110.75,55.99 110.8,55.94 110.8,52.91 110.55,52.66 110.05,52.66 109.76,52.37 109.76,51.98 108.84,51.06 108.84,49.34 108.63,49.13 108.51,49.13 108.48,49.1
  BOTTOM w0.102: v1(109.8,29.78) 110.2,29.37 110.2,29.01 111.17,28.05 111.17,16.34 v1(111.55,15.96) ; v3(109.15,58.52) 109.5,58.86 U80.AF11
I2C4_SDA_C: length 4.9
  TOP w0.102: U1.17 24.96,18.27 24.89,18.34 24.89,18.6 25.11,18.83 25.49,18.83 26.31,19.64 26.31,19.9 C1114.1 R5149.2
I2C_SCL_INA: length 2
  BOTTOM w0.102: RAP1429.2 99.45,18.55 RPM3576.2 v1(99.15,19.72)
I2C_SCL_INA_R: length 2.3
  BOTTOM w0.102: CN17.38 99.93,16.58 99.84,16.67 99.84,17.31 v1(99.97,17.43) 100.17,17.64 RAP1429.1
I2C_SDA_INA: length 0.9
  BOTTOM w0.102: RPM3577.2 RAP1428.1
I2C_SDA_INA_R: length 2.3
  BOTTOM w0.102: RAP1428.2 98.93,9.68 99.93,10.68 CN17.37
I2S0_RXD: length 40.7
  TOP w0.102: v1(112.42,75.44) 112.42,75.54 v1(111.47,76.49) 107.51,80.45 103.22,80.45 102.41,81.25 100.04,81.25 99.75,80.96 99.75,79.11 99.1,78.46 99.1,78.29 98.9,78.09 97.33,78.09 96.99,77.76 96.99,77.37 98.14,76.22 98.14,76 97.81,75.67 97.4,75.67 96.71,74.98 96.71,74.36 96.95,74.12 96.95,73.55 96.67,73.27 94.64,73.27 94.56,73.19 94.22,73.19 93.95,73.47 93.95,74.28 94.32,74.65 U138.11
  BOTTOM w0.076: U80.BA21 115.08,67.46 115.08,68.74 114.94,68.88 114.94,69.44 114.4,69.99 114.4,71.17 113.33,72.24 113.33,72.47
  BOTTOM w0.102: 113.33,72.47 113.33,73.64 112.99,73.98 112.99,74.87 v1(112.42,75.44)
I2S0_SCLK: length 43
  TOP w0.102: U138.5 93.67,81.85 v1(94.18,82.35)
  IN1 w0.079: v1(94.18,82.35) 94.5,82.67 96.9,82.67 97.12,82.46 97.12,82 97.73,81.39 99.02,81.39 99.62,80.79 v1(100.16,80.79)
  BOTTOM w0.076: 114.2,72.6 114.2,72.4 115.21,71.39 115.21,70.11 115.61,69.71 115.61,69.15 115.95,68.81 115.95,68.3 115.89,68.18 115.89,68.04 115.95,67.81 115.95,67.68 115.89,67.5 115.79,67.37 115.68,67.27 U80.AY22
  BOTTOM w0.102: 114.2,72.6 114.2,74.05 113.81,74.45 113.81,75.72 113.69,75.83 113.69,76.07 113.01,76.76 v1(113.01,77.57) 113.01,77.97 112.32,78.65 112.32,78.9 112.43,79.01 112.43,79.19 112.26,79.36 112.12,79.36 111.98,79.22 111.84,79.22 111.64,79.42 111.64,79.56 112.05,79.97 112.05,80.13 112.05,80.13 111.86,80.33 111.73,80.33 111.3,79.9 111.16,79.9 110.96,80.1 110.96,80.25 111.37,80.66 111.37,80.79 111.37,80.8 111.17,80.99 111.02,80.99 110.62,80.59 110.47,80.59 110.28,80.78 110.28,80.93 110.71,81.36 110.71,81.48 110.51,81.68 110.51,81.68 110.34,81.68 109.93,81.27 109.79,81.27 109.17,81.89 105.42,81.89 103.77,83.54 100.83,83.54 100.29,82.99 100.29,80.92 v1(100.16,80.79)
I2S0_SFRM: length 40
  TOP w0.102: U138.2 95.62,82.04 95.85,82.28 v1(96.64,82.28)
  IN1 w0.079: v1(96.64,82.28) 96.64,82.01 97.59,81.06 98.88,81.06 99.55,80.4 100.34,80.4 v1(100.79,80.85)
  BOTTOM w0.076: U80.BA22 115.68,67.96 115.41,68.23 115.41,68.88 115.27,69.02 115.27,69.58 114.75,70.1 114.75,71.35 113.77,72.33 113.77,72.61
  BOTTOM w0.102: 113.77,72.61 113.77,73.84 113.39,74.22 113.39,75.5 112.07,76.82 112.07,77.5 111.95,77.62 111.95,77.77 112.26,78.08 112.26,78.22 112.06,78.42 111.91,78.42 111.61,78.11 111.46,78.11 111.26,78.31 111.26,78.45 111.57,78.76 111.57,78.9 111.38,79.1 111.23,79.1 110.92,78.79 110.78,78.79 110.58,78.99 110.58,79.13 110.89,79.44 110.89,79.59 110.69,79.78 110.55,79.78 110.24,79.47 110.1,79.47 109.9,79.67 109.9,79.82 110.21,80.12 110.21,80.27 110.01,80.47 109.87,80.47 109.56,80.16 109.41,80.16 109.22,80.35 109.22,80.5 109.53,80.81 109.53,80.95 109.33,81.15 109.18,81.15 108.88,80.84 108.73,80.84 108.04,81.53 105.28,81.53 104.88,81.93 103.74,81.93 103.26,82.4 103.26,82.84 102.96,83.14 100.94,83.14 100.64,82.84 100.64,81.43 100.79,81.28 v1(100.79,80.85)
I2S0_TXD: length 42.6
  TOP w0.102: v1(92.47,82.99) 91.92,82.44 91.92,80.33 92.13,80.13 92.59,80.13 93.18,79.54 93.18,76.66 93.02,76.5 U138.9 ; v1(112.47,76.99) 112.35,77.11 111.15,78.31 v1(110.65,78.31) 110.01,78.31 107.64,80.67 103.31,80.67 102.48,81.51 RAP1431.1 99.73,81.51 99.63,81.4 v1(99.62,81.4)
  IN1 w0.079: v1(92.47,82.99) 92.49,83.01 97.59,83.01 97.96,82.63 97.96,82.08 98.31,81.73 99.3,81.73 v1(99.62,81.4)
  BOTTOM w0.076: U80.BB22 115.68,68.85 115.44,69.09 115.44,69.65 114.93,70.16 114.93,71.43 113.99,72.37 113.99,72.62
  BOTTOM w0.102: v1(112.47,76.99) 112.47,76.74 113.62,75.6 113.62,74.3 113.99,73.93 113.99,72.62 ; Q105.3 99.52,81.3 v1(99.62,81.4)
I2S1_PCHRXD_NAUTXD: length 144.2
  TOP w0.102: v1(21.3,18.52) 21.46,18.36 U1.24
  IN2 w0.079: v1(70.43,39.33) 70.07,39.68 70.07,43.86 69,44.94 69,51.48 68.87,51.61 68.87,53.61 73.35,58.09 73.35,59.76 77.43,63.84 78.33,63.84 78.37,63.89 78.37,64.14 78.73,64.5 80.1,64.5 80.25,64.65 80.25,65.38 85.44,70.57 85.44,71.97 85.69,72.21 85.69,75.96 86.56,76.83 86.56,78.6 91.7,83.75 93.22,83.75 93.82,83.15 100.08,83.15 100.5,82.73 v1(101.31,82.73)
  BOTTOM w0.102: v1(70.43,39.33) 70.07,39.68 65.44,39.68 64.42,40.7 60.37,40.7 59.89,40.22 59.58,40.22 57.85,38.49 57.85,37.39 56.92,36.46 50.01,36.46 49.02,37.45 44.07,37.45 43.28,36.66 42.19,36.66 41.96,36.43 38.08,36.43 35.17,33.53 35.17,31.32 34.17,30.32 34.17,28.72 32.2,26.74 32.2,25.98 30.28,24.06 29.52,23.3 29.52,22.62 28.23,21.33 28.23,19.46 26.74,17.97 21.86,17.97 v1(21.3,18.52) ; R5057.1 111.2,77.73 111.2,77.81 107.78,81.23 105.15,81.23 104.75,81.62 103.54,81.62 102.48,82.68 v1(102.46,82.68) 102.41,82.73 v1(101.31,82.73)
I2S1_PCHRXD_NAUTXD_C: length 11.9
  BOTTOM w0.076: 113.55,72.6 113.55,72.29 114.58,71.27 114.58,70.05 115.11,69.51 115.11,68.95 115.25,68.81 115.25,67.88 115.29,67.84 115.29,67.83 115.41,67.7 115.41,67.28 115.22,67.08 115.22,67.08 115.11,66.97 U80.AY21
  BOTTOM w0.102: 113.55,72.6 113.55,73.75 113.18,74.12 113.18,75.36 112.67,75.88 112.41,75.88 v1(112.26,76.03) 111.89,76.4 111.75,76.4 R5057.2
I2S1_PCHTXD_NAURXD: length 146.4
  TOP w0.102: U1.25 20.19,16.77 19.91,17.05 v1(19.91,17.32)
  IN2 w0.079: v1(101.71,81.98) 101.35,82.34 100.64,82.34 100.01,82.97 93.75,82.97 93.15,83.56 91.78,83.56 86.74,78.52 86.74,76.75 85.87,75.88 85.87,72.14 85.62,71.89 85.62,70.5 80.43,65.3 80.43,64.58 80.17,64.32 78.81,64.32 78.55,64.07 78.55,63.81 78.4,63.66 77.5,63.66 73.53,59.69 73.53,58.01 69.05,53.53 69.05,51.68 69.18,51.55 69.18,45.01 70.26,43.93 70.26,40.11 70.88,39.48 70.88,39.13 v1(70.45,38.7)
  BOTTOM w0.102: v1(101.71,81.98) 101.21,81.48 101.21,80.45 101.45,80.21 103,80.21 103.17,80.39 107.17,80.39 108.78,78.78 v1(108.78,78.54) 108.78,78.53 R5060.1 ; v1(19.91,17.32) 20.35,17.76 26.82,17.76 28.44,19.38 28.44,21.25 29.72,22.54 29.72,23.22 30.77,24.26 32.4,25.9 32.4,26.66 34.37,28.63 34.37,30.23 35.37,31.23 35.37,33.44 38.16,36.23 42.05,36.23 42.27,36.46 43.37,36.46 44.16,37.24 48.94,37.24 49.93,36.25 57,36.25 58.06,37.31 58.06,38.39 59.68,40.01 59.99,40.01 60.47,40.5 64.34,40.5 65.36,39.48 69.77,39.48 70.04,39.21 70.04,38.94 70.27,38.7 v1(70.45,38.7)
I2S1_PCHTXD_NAURXD_C: length 14.1
  BOTTOM w0.076: 112.46,71.95 113.69,70.72 113.69,69.74 114.27,69.16 114.27,68.62 114.22,68.57 114.22,68.29 114.3,68.16 114.3,68 114.22,67.89 114.22,67.35 114.28,67.13 114.28,66.93 114.53,66.68 U80.AW20
  BOTTOM w0.102: R5060.2 109.11,76.53 109.11,75.95 v1(109.57,75.5) 109.88,75.5 109.92,75.54 111.26,75.54 111.51,75.29 111.51,74.22 112.42,73.31 112.42,71.99 112.46,71.95
I2S1_SCL: length 149.2
  TOP w0.102: v1(19.71,16.65) 20.09,16.27 U1.26
  IN2 w0.079: v1(69.6,39.07) 69.6,39.79 69.89,40.08 69.89,43.78 68.81,44.86 68.81,51.4 68.69,51.53 68.69,53.68 73.17,58.16 73.17,59.84 77.35,64.02 78,64.02 78.66,64.68 80.02,64.68 80.07,64.73 80.07,65.45 85.26,70.65 85.26,72.04 85.51,72.29 85.51,76.03 86.35,76.88 86.35,78.65 91.63,83.93 93.3,83.93 93.76,83.47 100.19,83.47 v1(100.39,83.66)
  BOTTOM w0.102: R5058.1 113.83,79.11 v1(113.33,79.6) 110.7,82.24 105.57,82.24 103.92,83.89 100.61,83.89 v1(100.39,83.66) ; v1(19.71,16.65) 19.88,16.65 20.79,17.56 26.91,17.56 28.64,19.29 28.64,21.17 29.93,22.45 29.93,23.14 32.61,25.82 32.61,26.58 34.58,28.55 34.58,30.15 35.58,31.15 35.58,33.36 38.24,36.02 42.13,36.02 42.36,36.25 43.45,36.25 44.24,37.04 48.85,37.04 49.85,36.05 57.09,36.05 58.26,37.22 58.26,38.26 59.81,39.81 60.09,39.81 60.57,40.29 64.25,40.29 65.27,39.27 69.4,39.27 v1(69.6,39.07)
I2S1_SCLK_C: length 11.3
  BOTTOM w0.076: 115.39,70.26 115.78,69.88 115.78,69.22 116.11,68.88 116.11,68.26 116.1,68.24 116.06,68.15 116.06,68.04 116.13,67.82 116.13,67.65 116.07,67.49 116.07,67.44 115.86,66.73 115.68,66.56 U80.AW22
  BOTTOM w0.102: R5058.2 113.83,76.65 114.05,76.43 114.05,74.62 114.44,74.23 114.44,72.46 115.39,71.51 115.39,70.26
I2S1_SFRM: length 144.7
  TOP w0.102: v1(21.94,18.58) 21.96,18.56 U1.23
  IN2 w0.079: v1(101.1,81.94) 100.78,81.94 99.97,82.75 93.59,82.75 92.96,83.38 91.85,83.38 86.92,78.45 86.92,76.68 86.05,75.81 86.05,72.06 85.8,71.82 85.8,70.42 80.61,65.23 80.61,64.1 79.97,63.46 77.56,63.46 73.84,59.74 73.84,58.04 69.23,53.43 69.23,51.76 69.36,51.63 69.36,45.09 70.44,44.01 70.44,40.18 71.09,39.52 v1(71.09,38.73)
  BOTTOM w0.102: R5059.1 110.51,77.94 107.45,81 104.42,81 v1(104.23,81.19) 103.34,81.19 102.15,82.38 101.54,82.38 101.1,81.94 v1(101.1,81.94) ; v1(71.09,38.73) 71.09,39.23 70.44,39.88 65.52,39.88 64.51,40.9 60.27,40.9 59.78,40.42 59.43,40.42 57.65,38.64 57.65,37.48 56.83,36.66 50.1,36.66 49.11,37.65 43.99,37.65 43.2,36.86 42.11,36.86 41.88,36.63 37.99,36.63 34.97,33.61 34.97,31.4 33.97,30.4 33.97,28.8 32,26.83 32,26.07 29.32,23.39 29.32,22.71 28.03,21.42 28.03,19.54 26.65,18.17 22.35,18.17 v1(21.94,18.58)
I2S1_SFRM_C: length 11.7
  BOTTOM w0.076: 113.11,72.34 113.11,72.21 114.23,71.09 114.23,69.92 114.78,69.37 114.78,68.81 114.92,68.67 114.92,67.74 114.54,67.36 U80.AY20
  BOTTOM w0.102: 113.11,72.34 113.11,73.54 112.78,73.87 112.78,74.27 v1(112.49,74.56) 112.04,75 112.04,75.51 111.48,76.07 110.91,76.07 R5059.2
I2S2_RXD: length 59.9
  TOP w0.102: v1(88.29,60.69) 88.29,62.2 87.77,62.72 87.77,65.37 86.82,66.32 86.82,68.92 87.16,69.26 87.16,70.99 89.53,73.35 89.53,77.74 89.93,78.14 89.93,81.96 91.56,83.59 91.56,84.46 92.88,85.78 94.86,85.78 95.65,85 v1(95.65,84.79) 95.6,84.74 95.6,83.5 96.16,82.94 96.79,82.94 97.1,82.63 97.1,81.09 R3504.2
  IN2 w0.079: v3(107.93,60.61) 107.93,60.61 107.15,61.39 106.51,61.39 106.15,61.74 105.82,61.74 105.13,62.44 102.69,62.44 101.07,60.81 93.41,60.81 92.39,61.83 90.59,61.83 90.11,61.35 88.83,61.35 88.29,60.81 v1(88.29,60.69)
  BOTTOM w0.102: U80.AK10 108.35,60.61 107.93,60.61 v3(107.93,60.61)
I2S2_SCLK: length 48
  TOP w0.102: v1(89.43,60.64) 89.43,61.23 89.02,61.64 89.02,62.3 88.83,62.49 88.83,65.14 87.4,66.57 87.4,68.67 87.75,69.02 87.75,70.75 90.11,73.11 90.11,77.49 90.52,77.9 90.52,81.72 92.14,83.34 92.14,84.06 93.16,85.07 R3502.2
  IN2 w0.079: v3(106.73,60.62) 105.99,61.36 105.04,61.36 103.88,60.19 99.83,60.19 99.37,59.73 98.61,59.73 98.07,60.27 93.18,60.27 92.17,61.29 90.82,61.29 90.2,60.67 89.46,60.67 v1(89.43,60.64)
  BOTTOM w0.102: U80.AK6 v3(106.73,60.62)
I2S2_SFRM: length 51.1
  TOP w0.102: v1(88.86,60.41) 88.86,61.3 88.66,61.49 88.66,62.15 88,62.81 88,65.47 87.05,66.42 87.05,68.82 87.39,69.16 87.39,70.89 89.76,73.26 89.76,77.64 90.16,78.05 90.16,81.87 91.79,83.49 91.79,84.2 93.01,85.43 94.4,85.43 R3501.2
  IN2 w0.079: v3(107.34,60.62) 106.89,61.07 106.54,61.07 106.06,61.54 104.75,61.54 103.82,60.61 93.32,60.61 92.3,61.62 90.68,61.62 90.12,61.07 89.26,61.07 88.86,60.67 v1(88.86,60.41)
  BOTTOM w0.102: v3(107.34,60.62) 106.9,61.06 U80.AK7
I2S2_TXD: length 42.2
  TOP w0.102: R3503.2 91.06,79.47 90.87,79.28 90.87,77.55 90.92,77.5 90.92,71.89 90.37,71.33 89.32,71.33 88.1,70.11 88.1,68.87 87.76,68.53 87.76,66.71 89.18,65.29 89.18,62.63 89.43,62.39 v1(89.43,61.91)
  IN2 w0.079: v1(89.43,61.91) 89.74,62.23 90.81,62.23 91,62.03 92.47,62.03 93.49,61.02 100.99,61.02 102.61,62.64 105.22,62.64 105.93,61.92 106.23,61.92 106.54,61.62 107.23,61.62 107.77,61.08 108.14,61.08 v3(108.54,61.47)
  BOTTOM w0.102: U80.AK9 108.54,61.44 v3(108.54,61.47)
I2S_MCLK: length 105.3
  TOP w0.102: R1106.1 98.77,38.15 v1(98.29,38.63)
  IN1 w0.079: v1(59.63,40.84) 60.09,40.39 62.27,40.39 66.9,35.77 68.94,35.77 70.41,34.3 71.36,34.3 74.22,31.43 83.35,31.43 83.88,30.9 84.65,30.9 84.96,30.59 87.51,30.59 87.9,30.98 88.32,30.98 95.37,38.03 97.69,38.03 v1(98.29,38.63)
  BOTTOM w0.102: v1(59.63,40.84) 59.32,40.84 57.29,38.82 57.29,37.63 56.75,37.08 v1(53.47,37.08) 50.18,37.08 49.26,38.01 43.84,38.01 43.05,37.22 41.96,37.22 41.73,36.99 37.84,36.99 34.61,33.76 34.61,31.55 33.61,30.55 33.61,29.6 31.12,27.11 31.12,25.7 28.96,23.54 28.96,22.85 27.67,21.57 27.67,19.71 27.17,19.21 25.04,19.21 24.91,19.08 21.81,19.08 20.92,19.97 R1124.1 21.18,20.34 21.44,20.08 U108.1 23.19,20.08 23.33,20.23 23.33,20.48 23.08,20.73 U108.2
I2S_MCLK_C: length 16.6
  TOP w0.102: v1(98.29,39.33) 98.69,38.93 R1106.2 99.18,39.53 98.92,39.79 v1(98.92,40.11)
  IN1 w0.079: v3(105.8,50.14) 105.8,48.45 104.87,47.52 104.87,46.8 102.28,44.21 101.9,44.21 100.1,42.41 100.1,41.29 v1(98.92,40.11)
  BOTTOM w0.102: v3(105.8,50.14) 105.8,50.73 U80.J5
I2S_MCLK_R: length 2.9
  TOP w0.102: U1.19 23.96,18.4 24.02,18.46 v1(24.02,18.83) 24.02,19.36 23.59,19.79 R851.2
ILIM_HI: length 2.2
  TOP w0.102: EU1B2.16 204.36,18.4 204.44,18.47 v1(204.44,18.73) 204.44,19.33 R1M4.2
